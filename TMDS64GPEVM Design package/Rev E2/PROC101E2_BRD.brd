# Allegro board PROC101E2_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB0_DP: length 94.3
  TOP w0.14: U23.AA19 v1(82.66,70.3)
  L08_SIG2 w0.094: v1(58.59,55.35) 58.45,55.21 58.45,55.07 58.55,54.98 59.88,54.98 60.41,55.51 60.41,57.1 63.55,60.25 63.55,61.49 64.26,62.19 64.26,67.3 65.71,68.76 69.41,68.76 69.81,68.36 75,68.36 76.39,66.97 80.66,66.97 81.73,68.04 81.73,69.7 82.06,70.03 82.38,70.03 v1(82.66,70.3)
  BOTTOM w0.107: FL22.2 10.01,56.13 10.31,56.42 12.02,56.42 14.45,53.99 31.88,53.99 33.76,55.87 55.29,55.87 56.86,57.44 58.35,57.44 59.61,56.17 59.61,55.29 59.28,54.96 58.7,54.96 58.59,55.06 v1(58.59,55.35)
USB0_DRVBUS: length 107.3
  TOP w0.147: v1(93.34,49.17) 92.53,48.35 92.53,48.09 91.87,47.43 91.32,47.43 78.07,34.18 63.12,34.18 54.61,42.69 44.05,42.69 40.01,46.74 40.01,48.87 36.42,52.45 36.42,54.83 34.75,56.5 30.97,56.5 30.7,56.24 R151.1 30.3,55.64 30.18,55.77 U36.4 ; U23.E19 v1(96.26,70.3)
  BOTTOM w0.147: v1(96.26,70.3) 96.26,68.3 96.75,67.81 96.75,66.58 96.6,66.43 96.6,63.88 97.44,63.04 97.44,53.27 v1(93.34,49.17)
USB0_RCALIB: length 12.8
  TOP w0.147: U23.U17 v1(85.86,71.9)
  L03_SIG1 w0.091: v1(85.86,71.9) 85.7,71.9 85.32,71.52 84.9,71.52 84.64,71.26 84.64,70.95 84.42,70.72 81.82,70.72 81.68,70.87 78.39,70.87 77.55,71.71 77.55,71.95 77.34,72.16 v1(77.34,72.53)
  BOTTOM w0.147: TP67.1 76.33,72.53 v1(77.34,72.53)
USB0_VBUS: length 11.4
  TOP w0.381: J24.1 5.23,52.93 5.33,52.82
  BOTTOM w0.254: J23.1 5.94,45.79 5.94,43.45 5.61,43.12 3.23,43.12 2.94,42.83 R428.1 ; v1(5.92,52.72) 6.77,52.72 7.37,53.33 U38.6
USB1_SHIELD: length 4.2
  TOP w0.508: J24.9 v1(2.73,54.23)
  L03_SIG1 w0.508: J24.10 2.79,58.32 2.79,58.31 ; 2.59,50.23 2.5,50.14 J24.8
  vias: v1(3.3,49.9) v1(4.19,50.79) v1(4.47,58.99)
VCOMH: length 3
  BOTTOM w0.254: C473.1 6.3,15.76 5.75,16.31 J36.2
VIO_CAN: length 19.4
  TOP w0.381: U3.5 15.4,125.78 15.54,125.64 C3.1 16.26,124.71 16.47,124.5 FB1.2 16.13,122.87 v1(16.13,122.32) ; v1(26.03,126.68) C8.1 U4.5
  BOTTOM w0.147: v1(26.03,126.68) 21.77,126.68 19.05,123.97 17.78,123.97 v1(16.13,122.32)
VMAIN: length 54.1
  TOP w0.254: U17.1 149.3,92.45 149.08,92.23 C65.2
  TOP w0.305: v1(155.83,61.61) C123.1 156.41,60.67 157.3,61.56 157.92,61.56 157.99,61.48 U30.25
  TOP w0.381: R80.2 172.97,95.77
  L03_SIG1 w0.254: v1(120.02,74.55) 134.75,74.55 136.4,72.9 139.19,72.9 v1(139.57,73.28)
  L08_SIG2 w0.254: v1(155.83,61.61) 144.16,73.28 v1(139.57,73.28)
  BOTTOM w0.254: 58.04,24.02 58.05,24.01 U97.2 ; R604.1 119.51,75.06 v1(120.02,74.55) ; R408.2 v1(172.34,52.08) ; v1(58.04,26.68) 58.17,26.56 58.8,26.56 59.05,26.3 R500.1
  vias: v1(57.02,26.68) v1(57.53,27.32) v1(57.53,26.18) v1(160.43,83.47) v1(160.43,82.45) v1(160.43,81.43) v1(161.44,83.47) v1(161.44,82.45) v1(161.44,81.43) v1(162.59,83.47) v1(162.59,82.45) v1(162.59,81.43) v1(163.6,83.47) v1(163.6,82.45) v1(163.6,81.43) v1(165.07,91.1) v1(165.07,89.88) v1(165.07,88.66) v1(166.29,91.1) v1(166.29,89.88) v1(166.29,88.66) v1(167.51,91.1) v1(167.51,89.88) v1(167.51,88.66) v1(168.73,93.54) v1(168.73,92.32) v1(168.73,91.1) v1(168.73,89.88) v1(168.73,88.66) v1(169.95,93.54) v1(169.95,92.32) v1(169.95,91.1) v1(169.95,89.88) v1(169.95,88.66) v1(171.17,93.54) v1(171.17,92.32) v1(171.17,91.1) v1(171.17,89.88) v1(171.17,88.66)
VMAIN_EN: length 13.1
  TOP w0.254: SW1.2 166.12,52.08 165.35,52.85 165.35,54.7 164.47,55.59 R577.1
  BOTTOM w0.254: SW1.2 R408.1 ; R408.1 C406.1 ; R408.1 170.45,51.44 170.95,50.94 171.2,50.94 171.43,50.71 R412.2
VPHY_3V3_FT4232: length 3.9
  BOTTOM w0.254: C425.2 133.33,40.44 U87.4
  BOTTOM w0.381: FB24.1 131.63,40.93 C425.2
VPLL_3V3_FT4232: length 6.8
  BOTTOM w0.254: U87.9 133.59,42.94 133.49,42.83 C422.2 132.32,42.83 132.21,42.94 FB23.1
  BOTTOM w0.381: R417.2 130.41,44.74 131.4,43.75 FB23.1
VPP_1V8: length 93.3
  TOP w0.147: U23.G15 v1(94.66,73.5)
  L05_PWR1 w0.114: 95.1,72.3 95.1,72.3 94.49,72.3 94.26,72.54 94.26,73.1 v1(94.66,73.5) 95.06,73.1 98.23,73.1 98.42,72.91 98.42,72.9 98.42,72.02 98.15,72.3 95.1,72.3
  L05_PWR1 w0.381: TP52.1 140.46,101.92 139.55,101 139.55,99.35 136,95.8 129.95,95.8 127.64,93.49 127.64,84.98 126.36,83.71 123.06,83.71 119.25,87.52 111.51,87.52 110.13,86.14 110.13,84.35 111,83.49 111,82.06 110.24,81.29 109.6,81.29 109.09,80.79 109.09,77.74 109.73,77.1 109.73,75.07 110.62,74.18 110.62,70.75 110.24,70.37 105.28,70.37 104.42,69.51 100.05,69.51 98.93,70.63 98.93,71.52 98.42,72.02
  BOTTOM w0.254: 141.82,105.04 142.17,104.7 U72.1 141.9,102.92 141.55,102.92 141.44,102.81 141.04,102.81
VPP_DDR_2V5: length 21
  BOTTOM w0.508: TP47.1 88.52,120.79 82.55,120.79 81.28,119.52 81.28,110.63
VPP_LDO_EN: length 197.8
  TOP w0.147: v1(150.75,44.46) 152.15,44.46 153.67,42.94 153.67,40.65 151.51,38.5 150.37,38.5 149.22,37.35 149.22,36.21 146.56,33.54 132.59,33.54 130.94,31.89 130.94,28.34 132.08,27.19 v1(132.08,23.13)
  L03_SIG1 w0.091: v1(150.75,44.46) 146.81,48.4 146.81,54.24 142.88,58.18 142.88,92.42 144.34,93.89 144.34,99.15 v1(145.03,99.84)
  L08_SIG2 w0.091: v1(132.08,23.13) 131.65,23.56 123.49,23.56 122.05,22.11 115.19,22.11 111.36,18.28 102.19,18.28 99.41,21.06 93.77,21.06 91.34,18.62 81.92,18.62 77.25,23.29 64.3,23.29 60.74,26.85 60.74,26.91 52.7,34.94 v1(51.82,34.94)
  BOTTOM w0.147: R582.2 R263.2 145.54,101.11 TP53.1 145.16,99.96 v1(145.03,99.84) ; v1(51.82,34.94) 51.84,34.91 U91.16
VREF: length 9.6
  TOP w0.203: 143.66,24.54 143.86,24.73 U59.9
  TOP w0.381: v1(142.39,24) C180.1 143.66,24.54
  BOTTOM w0.254: R505.2 141.48,24 v1(142.39,24) ; C180.1 143.78,24 144.11,23.67 U95.3
  BOTTOM w0.381: v1(142.39,24) C180.1
VSENSE: length 12.9
  TOP w0.254: v1(145.59,95.88) 145.59,95.86 146.07,95.38 U17.6
  BOTTOM w0.381: v1(145.59,95.88) 145.99,96.28 150.12,96.28 150.98,95.41 C272.2 R279.2 R294.1
XDS110_DIR: length 2.6
  BOTTOM w0.147: U98.2 150.39,22.66 R507.2 150.89,22.37 U98.3
XDS110_EMU0: length 30.4
  TOP w0.147: U55.8 v1(137.03,26.81) ; v1(148.59,11.7) 148.95,12.06 R202.2 149.56,12.06 150.35,12.85 U59.42
  L08_SIG2 w0.091: v1(137.03,26.81) 141.08,26.81 141.59,26.3 145.29,26.3 149.22,22.37 149.22,19.71 150.62,18.31 150.62,13.22 149.48,12.08 148.97,12.08 v1(148.59,11.7)
XDS110_EMU1: length 24.1
  TOP w0.147: U59.43 150.75,12.56 150.79,12.52 R203.2 v1(151.49,12.06) ; U55.1 v1(137.03,23.51)
  L08_SIG2 w0.091: v1(137.03,23.51) 137.56,23.51 146.69,14.38 146.69,12.59 148.01,11.26 150.69,11.26 v1(151.49,12.06)
XDS110_TCK: length 7.8
  TOP w0.147: v1(147.7,16.27) 147.7,15.82 147.52,15.63 147.52,15.09 147.55,15.05 U59.35
  BOTTOM w0.147: U98.12 151.89,18.1 151.89,17.29 150.88,16.27 v1(147.7,16.27)
XDS110_TDI: length 10.9
  TOP w0.147: U59.38 v1(148.75,12.87)
  BOTTOM w0.147: U98.13 151.39,17.4 150.8,16.8 147.59,16.8 147.25,16.46 147.25,13.8 148.18,12.87 v1(148.75,12.87)
XDS110_TDO: length 30.6
  TOP w0.147: v1(134.49,25.8) 134.62,25.8 134.85,25.56 U56.7 ; v1(147.96,12.33) 148.27,12.65 148.27,13.04 148.35,13.11 U59.37
  L08_SIG2 w0.091: v1(134.49,25.8) 135.76,24.53 146.63,24.53 149,22.15 149,19.62 150.4,18.22 150.4,15.42 147.96,12.97 v1(147.96,12.33)
XDS110_TMS: length 7.7
  TOP w0.147: v1(148,15.38) 147.95,15.33 U59.36
  BOTTOM w0.147: v1(148,15.38) 148.38,15.76 151.38,15.76 152.39,16.77 U98.11
XDS110_TRST#: length 7.8
  TOP w0.147: U59.40 v1(149.55,12.84)
  BOTTOM w0.147: U98.10 152.89,16.18 v1(149.55,12.84)
XDS_RSTN: length 3.3
  TOP w0.147: R198.1 R199.1 161.78,17.79 161.51,17.53 U59.70
XDS_USB_DM: length 24.7
  TOP w0.107: J28.2 173.05,24.29 172.84,24.07 172.55,24.07 v1(172.25,24.37) 171.89,24.02 171.58,24.02 171.32,23.76 171.32,23.35 171.22,23.24 171.02,23.24 170.88,23.38 U58.5 ; U59.93 159.66,26.73 159.59,26.8 158.48,26.8 158.37,26.69 v1(158.37,26.52)
  BOTTOM w0.107: v1(172.25,24.37) 171.95,24.07 167.39,24.07 166.75,24.71 158.49,24.71 157.57,25.63 157.57,26.59 157.88,26.9 158.48,26.9 158.58,26.8 158.58,26.63 158.47,26.52 v1(158.37,26.52)
XDS_USB_DP: length 24.7
  TOP w0.107: J28.3 173.04,23.64 172.82,23.85 172.55,23.85 v1(172.25,23.55) 172,23.8 171.67,23.8 171.54,23.67 171.54,23.26 171.31,23.02 171.03,23.02 170.89,22.88 U58.4 ; U59.94 159.66,27.13 159.56,27.02 158.69,27.02 v1(158.37,27.34)
  BOTTOM w0.107: v1(158.37,27.34) 158.15,27.12 157.79,27.12 157.35,26.68 157.35,25.54 158.4,24.49 166.66,24.49 167.3,23.85 171.95,23.85 v1(172.25,23.55)
XDS_USB_ID: length 22.2
  TOP w0.147: U58.2 v1(169.16,23.38)
  TOP w0.254: J28.4 172.32,22.99 v1(171.96,22.62)
  BOTTOM w0.147: v1(169.16,23.38) 169.93,23.38 170.69,22.62 v1(171.96,22.62) 172.72,22.62 173.23,23.13 173.23,25.03 172.47,25.8 168.28,25.8 167.39,26.68 165.74,26.68 164.98,27.44 R478.2
XDS_USB_VBUS: length 6.4
  TOP w0.147: U58.6 170.5,24.31 170.43,24.38 v1(170.43,24.83)
  TOP w0.254: v1(172.47,25.14) 172.67,24.94 J28.1 ; v1(165.61,12.59) 165.61,12.31 166.02,11.9 U61.2 ; U61.8 v1(171.03,12.55)
  BOTTOM w0.254: v1(143.64,31.38) 143.68,31.34 R469.1 ; R467.1 162.22,31.34 v1(162.26,31.38)
  vias: v1(164.47,13.6) v1(164.59,12.84)
N5126260: length 13.1
  TOP w0.147: U15.48 v1(35.81,104.73) 34.28,104.73 TP11.1 ; v1(35.94,97.04) 36.39,97.04 36.49,97.14 U15.13
  L03_SIG1 w0.091: v1(35.94,97.04) 35.94,97.48 35.81,97.61 v1(35.81,104.73)
N15202140: length 2.3
  TOP w0.147: U59.95 v1(159.3,27.53)
  BOTTOM w0.147: R478.1 159.39,27.44 v1(159.3,27.53)
N15204440: length 14.2
  TOP w0.254: U61.5 169.95,8.93 169.21,8.19 163.53,8.19 162.94,8.78 162.94,9.52 C198.2 R204.2 v1(162.05,10.81)
  BOTTOM w0.254: C198.2 162.35,9.54 162.05,9.84 v1(162.05,10.81)
N15205319: length 3.2
  TOP w0.147: U59.68 161.72,16.73 161.95,16.5 C193.2 163.29,16.5 163.31,16.52 R200.1
N15212041: length 4.2
  TOP w0.147: R205.1 155.56,11.17 155.56,11.41 157.15,13.01 U59.59
N15239696: length 3.2
  TOP w0.147: v1(160.91,28.84) 160.65,28.58 U59.96
  BOTTOM w0.147: R467.2 C447.2 160.99,28.97 160.91,28.89 v1(160.91,28.84)
N15241750: length 3.2
  TOP w0.147: v1(145.03,28.84) 145.25,28.63 U59.1
  BOTTOM w0.147: v1(145.03,28.84) 144.91,28.97 R468.1 R469.2
N15242949: length 6.6
  TOP w0.147: v1(140.95,28.49) 141.48,27.95 143.38,27.95 144.21,27.13 U59.3
  BOTTOM w0.147: R466.1 v1(140.95,28.49)
N15242980: length 2.7
  TOP w0.147: LD22.2 142.19,29.18 v1(141.99,28.97)
  BOTTOM w0.147: R466.2 141.86,30.17 141.86,29.1 v1(141.99,28.97)
N15243226: length 10.2
  TOP w0.147: U59.4 144.1,26.73 143.26,27.57 141.1,27.57 140.08,28.59 v1(140.08,29.22)
  BOTTOM w0.147: R462.1 140.82,31.74 140.08,31 v1(140.08,29.22)
N15365714: length 4.4
  BOTTOM w0.147: R543.2 72.62,15.99 72.48,15.85 71.15,15.85 70.41,15.12 J38.27
N15365947: length 3.3
  BOTTOM w0.147: J38.30 68.91,14.87 69.82,15.78 69.82,16.07 70.29,16.54 R545.2
N15366015: length 3
  BOTTOM w0.147: J38.31 68.41,15.01 69.19,15.79 R546.2
N15366091: length 2.7
  BOTTOM w0.147: R547.2 68.05,15.26 67.91,15.13 J38.32
N15507744: length 1.6
  TOP w0.147: C159.2 165.74,35.34 U43.2
N15584817: length 2.2
  TOP w0.147: SW2.13 v1(87,28.21)
  BOTTOM w0.147: R508.1 v1(87,28.21)
N15584821: length 2.2
  TOP w0.147: SW2.14 v1(85.73,28.21)
  BOTTOM w0.147: R512.1 v1(85.73,28.21)
N15584825: length 2.2
  TOP w0.147: SW2.15 v1(84.46,28.21)
  BOTTOM w0.147: R517.1 v1(84.46,28.21)
N15584829: length 2.2
  TOP w0.147: SW2.16 v1(83.19,28.21)
  BOTTOM w0.147: R527.1 v1(83.19,28.21)
N15591045: length 2.2
  TOP w0.147: SW2.9 v1(92.07,28.21)
  BOTTOM w0.147: R472.1 v1(92.07,28.21)
N15591049: length 2.2
  TOP w0.147: SW2.10 v1(90.8,28.21)
  BOTTOM w0.147: R487.1 v1(90.8,28.21)
N15591053: length 2.2
  TOP w0.147: SW2.11 v1(89.53,28.21)
  BOTTOM w0.147: R496.1 v1(89.53,28.21)
N15591057: length 2.2
  TOP w0.147: SW2.12 v1(88.27,28.21)
  BOTTOM w0.147: R501.1 v1(88.27,28.21)
N15854407: length 1.9
  TOP w0.147: U14.3 126.62,106.42 R43.1
N15854417: length 5.3
  TOP w0.147: R73.1 126.32,97.91 126.34,97.93 C47.2 126.89,98.52 ; U14.9 127.12,98.75 126.89,98.52 ; 126.89,98.52 126.62,98.79 U14.8
N15854427: length 3.8
  TOP w0.147: R74.1 128.7,97.91 128.68,97.93 C47.1 127.87,98.57 127.62,98.82 U14.10
N15854463: length 1.8
  TOP w0.147: U6.3 R28.1
N15854467: length 7.8
  TOP w0.147: U6.9 150.12,122.05 150.24,121.93 150.5,121.93 150.62,122.06 U6.8 150.62,124.22 150.49,124.35 v1(150.24,124.35)
  BOTTOM w0.147: v1(150.24,124.35) 150.24,123.9 150.18,123.84 C204.2 149.61,122.82 149.29,122.51 R216.1
N15854483: length 6.7
  TOP w0.147: v1(150.24,125.11) 149.62,124.49 U6.10
  BOTTOM w0.147: R215.1 152.04,122.55 151.76,122.82 C204.1 151.16,124.19 v1(150.24,125.11)
N15854545: length 2.8
  TOP w0.147: U11.3 v1(147.19,108.22)
  BOTTOM w0.147: v1(147.19,108.22) 146.74,108.22 146.62,108.09 R244.1
N15854547: length 1.7
  TOP w0.147: U28.3 138.56,72.91 138.54,72.93 R122.1
N15854553: length 33.1
  TOP w0.147: U11.8 142.24,108.22 142.37,108.09 142.37,107.85 142.24,107.72 U11.9 v1(139.84,107.72)
  BOTTOM w0.147: R229.1 131.08,115.84 C214.2 129.67,116.85 128.78,115.97 128.78,113.93 127.76,112.92 126.62,112.92 125.86,112.16 125.86,107.58 126.15,107.29 138.39,107.29 139.14,108.04 139.51,108.04 v1(139.84,107.72)
N15854557: length 10.5
  TOP w0.147: v1(138.94,68.59) 139.06,68.48 U28.9 139.06,66.42 138.95,66.31 138.69,66.31 138.56,66.44 U28.8
  BOTTOM w0.147: R350.1 134.47,68.3 135.96,66.82 138.56,66.82 138.83,67.09 C393.2 138.94,67.56 v1(138.94,68.59)
N15854581: length 9
  TOP w0.147: U28.10 139.56,68.2 v1(139.95,68.59)
  BOTTOM w0.147: v1(139.95,68.59) 139.81,68.45 C393.1 139.81,66.86 139.83,66.84 139.83,66.69 139.57,66.44 135.64,66.44 135.13,66.94 R352.1
N15854603: length 33.7
  TOP w0.147: U11.10 139.43,107.22 v1(139.32,107.33)
  BOTTOM w0.147: R228.1 132.68,115.57 132.06,116.18 C214.1 132.06,117.51 131.83,117.74 129.41,117.74 128.27,116.6 128.27,114.19 127.64,113.55 126.62,113.55 125.35,112.28 125.35,107.58 125.95,106.99 138.98,106.99 v1(139.32,107.33)
N15854737: length 1.8
  TOP w0.147: U1.3 R1.1
N15854741: length 5.7
  TOP w0.147: R11.1 86.36,123.19 U1.8 86.36,125.24 v1(86.74,125.62) 86.86,125.5 U1.9
  BOTTOM w0.147: C203.2 86.51,124.94 86.42,125.03 86.42,125.3 v1(86.74,125.62)
N15854757: length 5.4
  TOP w0.147: v1(87.63,125.62) 87.36,125.35 U1.10 87.36,123.31 87.38,123.29 87.38,123.2 87.52,123.06 R10.1
  BOTTOM w0.147: C203.1 87.48,125.47 v1(87.63,125.62)
N15854857: length 2.1
  TOP w0.254: R12.2 131.7,124.73
N15854859: length 2.4
  TOP w0.254: J4.1 129.16,123.55 129.29,123.42 R13.2
N16248811: length 3.3
  TOP w0.147: R60.1 v1(60.45,102)
  BOTTOM w0.147: R60.1 v1(60.45,102) 60.07,102.38 60.07,103.01 59.94,103.14 U70.20
N16248833: length 3.4
  TOP w0.147: R61.1 v1(61.72,102)
  BOTTOM w0.147: R61.1 v1(61.72,102) 61.21,102.5 61.21,102.88 60.94,103.16 U70.18
N16248855: length 6.5
  TOP w0.147: R65.1 v1(62.99,101.23)
  BOTTOM w0.147: R272.1 63.72,100.34 63.61,100.45 R65.1 v1(62.99,101.23) 62.99,103.01 62.24,103.76 U70.17
N16248877: length 2.8
  BOTTOM w0.147: U70.8 61.44,109.62 61.82,110 61.98,110 62.48,110.5 R235.1
N16248899: length 2.4
  BOTTOM w0.147: U70.7 60.94,110.43 61.21,110.7 R236.1
N16248921: length 2.3
  BOTTOM w0.147: R237.1 59.94,110.7 59.94,110.7 U70.5
N16248943: length 2.4
  BOTTOM w0.147: U70.3 58.94,110.43 58.67,110.7 R238.1
N16248965: length 2.5
  BOTTOM w0.147: R239.1 57.4,110.5 57.94,109.97 U70.1
N16303893: length 2.2
  TOP w0.147: SW3.11 v1(109.3,28.23)
  BOTTOM w0.147: v1(109.3,28.23) R515.1
N16303897: length 2.2
  TOP w0.147: SW3.12 v1(108.03,28.23)
  BOTTOM w0.147: v1(108.03,28.23) R511.1
N16303901: length 2.2
  TOP w0.147: SW3.13 v1(106.76,28.23)
  BOTTOM w0.147: v1(106.76,28.23) R504.1
N16303905: length 2.2
  TOP w0.147: SW3.14 v1(105.49,28.23)
  BOTTOM w0.147: v1(105.49,28.23) R499.1
N16303921: length 2.2
  TOP w0.147: SW3.9 v1(111.84,28.23)
  BOTTOM w0.147: v1(111.84,28.23) R530.1
N16303925: length 2.2
  TOP w0.147: SW3.10 v1(110.57,28.23)
  BOTTOM w0.147: v1(110.57,28.23) R520.1
N16679303: length 4.5
  TOP w0.147: U59.60 157.55,12.62 v1(156.51,11.57)
  TOP w0.203: v1(156.51,11.57) R206.2
  BOTTOM w0.203: v1(156.51,11.57) R206.2
N16679944: length 5
  TOP w0.147: v1(160.32,11.66) 159.86,11.66 158.75,12.77 U59.63
  TOP w0.203: v1(160.32,11.66) R209.2
  BOTTOM w0.203: v1(160.32,11.66) R209.2
N16679981: length 4.1
  TOP w0.147: v1(157.78,11.57) 157.78,12.38 157.95,12.55 U59.61
  TOP w0.203: v1(157.78,11.57) R207.2
  BOTTOM w0.203: v1(157.78,11.57) R207.2
N16680014: length 4.4
  TOP w0.147: v1(159.05,11.66) 158.35,12.35 U59.62
  TOP w0.203: R208.2 v1(159.05,11.66)
  BOTTOM w0.203: v1(159.05,11.66) R208.2
N16753626: length 4.8
  BOTTOM w0.147: J33.6 63.72,39.42 65.02,38.12 65.02,37.68 65.49,37.21 R449.2
N16753680: length 4.3
  BOTTOM w0.147: R409.2 65.39,50.2 66.22,49.36 J33.15
N16754334: length 5.9
  BOTTOM w0.147: R447.2 68.03,37.21 67.15,38.09 66.01,38.09 65.22,38.88 J33.12
N16814557: length 1.4
  BOTTOM w0.147: U89.5 153,38 R445.2
N16814563: length 2.2
  BOTTOM w0.147: U89.4 153.76,39.42 154.05,39.13 154.05,38.64 R438.1
N16814605: length 2.4
  BOTTOM w0.147: U84.5 134.78,53.36 133.88,54.26 R400.2
N16814611: length 2.2
  BOTTOM w0.147: U84.4 133.65,52.56 133.1,53.1 R406.1
N16814651: length 2
  BOTTOM w0.147: R397.2 141.08,54.64 141.29,54.43 U82.5
N16814659: length 2.4
  BOTTOM w0.147: R403.1 140.22,54.62 140.34,54.51 140.34,54.12 140.62,53.83 U82.4
N16879988: length 2.8
  TOP w0.147: R38.1 94.69,106.84 U13.F9
N16880168: length 7.1
  TOP w0.147: U13.T7 92.4,97.86 92.57,97.7 92.57,97.69 93.4,96.86 95.18,96.86 95.69,96.35 95.69,95.99 95.8,95.89 96.79,95.89 97.03,95.65 TP15.1
N16887346: length 7.4
  TOP w0.147: U23.H5 v1(93.86,82.3)
  BOTTOM w0.114: v1(93.86,82.3) 94.05,82.3 94.45,81.9 95.62,81.9 95.86,81.67 95.86,81.65 95.86,81.65 95.86,81.34 95.86,81.31 96.07,81.1 98.81,81.1
  BOTTOM w0.147: 98.81,81.1 99.13,80.79 R320.1
N16887366: length 0.6
  TOP w0.147: U23.K2 v1(92.26,84.7)
N16887368: length 4.4
  TOP w0.147: v1(94.87,87.5) 93.58,87.5 91.84,85.76 91.84,85.12 U23.K1
N16887377: length 0.6
  TOP w0.147: U23.H3 v1(93.86,83.9)
N16887386: length 0.6
  TOP w0.147: U23.F3 v1(95.46,83.9)
N16887395: length 0.6
  TOP w0.147: U23.E4 v1(96.26,83.1)
N16887404: length 0.6
  TOP w0.147: U23.F5 v1(95.46,82.3)
N16937764: length 1.8
  TOP w0.147: U37.5 86.69,51.72 86.87,51.9 R147.1
N16938293: length 1.5
  BOTTOM w0.147: R506.1 151.89,22.31 151.89,22.3 U98.5
N17211229: length 2.9
  BOTTOM w0.147: R548.2 66.9,15.82 67.41,15.31 J38.33
N17247526: length 2
  TOP w0.147: LD16.2 v1(45.09,43.45)
  BOTTOM w0.147: v1(45.09,43.45) R421.2
N17247539: length 2.2
  TOP w0.147: LD17.2 v1(47.12,43.45)
  BOTTOM w0.147: R420.2 46.61,43.96 v1(47.12,43.45)
N17247599: length 2
  TOP w0.147: LD18.2 v1(49.15,43.45)
  BOTTOM w0.147: R419.2 v1(49.15,43.45)
N17247637: length 2
  TOP w0.147: LD19.2 v1(51.18,43.45)
  BOTTOM w0.147: R418.2 v1(51.18,43.45)
N17247662: length 2.2
  TOP w0.147: LD14.2 50.42,60.45 v1(50.29,60.58)
  BOTTOM w0.147: v1(50.29,60.58) R381.2
N17247701: length 2.2
  TOP w0.147: LD13.2 48.39,60.42 48.26,60.55 v1(48.26,60.58)
  BOTTOM w0.147: R382.2 v1(48.26,60.58)
N17247743: length 2.2
  TOP w0.147: LD12.2 v1(46.35,60.59)
  BOTTOM w0.147: v1(46.35,60.59) 46.35,59.99 46.23,59.86 R383.2
N17247786: length 2.1
  TOP w0.147: v1(43.31,59.45) 43.59,59.74 LD11.2
  BOTTOM w0.147: v1(43.31,59.45) 43.45,59.31 R384.2
N17248427: length 2
  TOP w0.147: U34.7 v1(50.67,47.77)
  BOTTOM w0.147: v1(50.67,47.77) R413.2
N17248432: length 4.6
  TOP w0.147: v1(49.53,53.09) 50.53,53.09 50.67,53.23 U34.10
  BOTTOM w0.147: R402.2 50.67,53.71 50.05,53.09 v1(49.53,53.09)
N17248439: length 3.1
  TOP w0.147: v1(51.82,52.97) 51.94,53.1 U34.9
  BOTTOM w0.147: v1(51.82,52.97) 51.82,53.58 51.94,53.71 R401.2
N17546132: length 5.1
  BOTTOM w0.147: J38.26 70.91,15.2 71.22,15.51 71.6,15.51 71.6,15.51 73.28,15.51 73.76,15.99 R542.2
N17546158: length 3.3
  BOTTOM w0.147: J38.28 69.91,15.04 71.42,16.54 R544.2
N17682848: length 2.8
  TOP w0.147: R92.4 129.31,96.26 129.29,96.29 R74.2
N17682861: length 2.8
  TOP w0.147: R92.1 125.71,96.04 125.73,96.06 R73.2
N17683733: length 3.4
  BOTTOM w0.147: R227.3 R215.2
N17683748: length 3.4
  BOTTOM w0.147: R227.2 R216.2
N17685678: length 1.8
  BOTTOM w0.147: R228.2 132.72,113.83 132.99,113.55 R233.1
N17685693: length 1.7
  BOTTOM w0.147: R233.4 130.24,113.49 130.68,113.93 R229.2
N17685736: length 2
  BOTTOM w0.147: R351.1 132.84,66.25 133.5,66.91 R352.2
N17685749: length 2
  BOTTOM w0.147: R350.2 133.5,68.38 132.88,69 R351.4
N17686321: length 1.6
  TOP w0.147: R10.2 88.9,121.53 88.83,121.46 R22.2
N17686333: length 1.4
  TOP w0.147: R22.3 86.08,121.38 86.11,121.4 R11.2
N17786037: length 2.1
  TOP w0.254: U9.2 32.86,118.48 33.15,118.76
N17786049: length 4.7
  TOP w0.254: U9.4 34.29,116.48 v1(34.42,116.6)
  BOTTOM w0.254: R232.2 33.4,113.9 33.38,113.92 R231.1 33.38,115.57 v1(34.42,116.6)
N18116794: length 1.9
  BOTTOM w0.147: R286.2 33.73,95.17 33.47,95.43 Q13.1
N18116818: length 2.1
  BOTTOM w0.147: R230.1 27.59,113.39 27.69,113.3 28.37,113.3 Q12.1
N18116875: length 1.3
  TOP w0.147: R30.1 32.69,112.06 32.63,112 Q3.1
N18117332: length 1.4
  BOTTOM w0.147: Q14.1 R324.2
N18117389: length 1.2
  BOTTOM w0.147: Q16.1 R343.1
N18275385: length 1.8
  TOP w0.147: U48.6 94.88,31.89 v1(94.64,32.13)
  BOTTOM w0.147: R459.1 v1(94.64,32.13)
N18276744: length 1.5
  TOP w0.147: R190.2 C169.1
N18280417: length 2
  TOP w0.254: U53.4 R195.2
N18280437: length 2.9
  BOTTOM w0.147: U93.4 79.21,25.58 79.67,26.04 R491.2
N18280477: length 2
  TOP w0.254: U52.4 R194.2
N18280857: length 2.7
  BOTTOM w0.147: U94.4 74.73,24.75 75.46,25.49 R492.2
N18289350: length 2.3
  BOTTOM w0.147: C277.1 131.5,93.76 130.73,93.76 130.61,93.64 U76.5
N18321769: length 2.2
  BOTTOM w0.147: U70.31 55.84,107.56 55.23,108.18 R243.1
N18546027: length 2.3
  TOP w0.381: LD5.1 164.5,97.58 164.47,97.61 R64.2
N18546044: length 2.7
  TOP w0.381: D2.1 160.5,96.59 LD5.2
N18867885: length 4.1
  BOTTOM w0.147: R325.2 70.87,74.15 70.52,73.8 69.22,73.8 68.81,73.4 U79.21
N18867903: length 3
  BOTTOM w0.147: R326.2 69.56,74.71 68.31,73.47 U79.20
N18867905: length 2.7
  BOTTOM w0.147: R327.2 68.33,74.15 67.81,73.64 U79.19
N18867915: length 2.6
  BOTTOM w0.147: R328.2 67.06,74.15 67.31,73.89 U79.18
N18867925: length 2.9
  BOTTOM w0.147: U79.17 66.81,73.72 65.82,74.71 R329.2
N18867943: length 3.7
  BOTTOM w0.147: R330.2 64.55,74.71 65.21,74.06 65.91,74.06 66.31,73.65 U79.16
N18867953: length 4.2
  BOTTOM w0.147: U79.15 65.81,73.27 65.43,73.65 64.34,73.65 63.28,74.71 R331.2
N18867955: length 4.8
  BOTTOM w0.147: U79.14 65.31,72.92 64.96,73.27 63.45,73.27 62.01,74.71 R332.2
N18968782: length 1.5
  TOP w0.254: U36.5 R153.2
N18977129: length 5.6
  BOTTOM w0.147: U87.3 132.83,39.94 C433.1 132.02,39.13 Y3.2
N18977189: length 8.9
  BOTTOM w0.147: U87.2 133.4,39.44 133.17,39.21 133.17,35.91 132.93,35.67 C439.1 131.89,35.67 131.55,35.33 Y3.1
N19031494: length 2.4
  TOP w0.254: v1(30.86,116.98) 30.87,116.98 U9.9
  BOTTOM w0.254: C215.1 30.12,117.22 30.35,116.98 v1(30.86,116.98)
N19312123: length 3.3
  BOTTOM w0.147: D7.3 3.94,41.57 3.92,41.58 R428.2 R427.1
N19753713: length 8.5
  TOP w0.254: D5.1 165.45,69.81 166.22,69.04 C116.2 165.57,64.65 165.56,64.66 165.23,64.66 164.85,64.28 U30.11
N19753729: length 7.8
  TOP w0.147: U30.10 166.03,63.48 C116.1 166.65,63.67 168.78,65.8 168.78,68.85
N19753760: length 2.7
  TOP w0.254: 175.73,77.41 175.73,78.14 175.51,78.35 174.5,78.35 174.39,78.25 R112.1
N19753772: length 20.2
  TOP w0.147: v1(169,63.23) 168.81,63.04 R129.2 167.3,63.04 166.73,62.48 U30.8
  TOP w0.254: U26.4 166.89,77.45 v1(166.93,77.48)
  L08_SIG2 w0.091: v1(169,63.23) 167.74,64.49 167.74,76.67 v1(166.93,77.48)
N19753820: length 23.4
  TOP w0.254: U30.13 v1(163.17,65.5)
  L08_SIG2 w0.091: v1(171.07,80.66) 168.15,80.66 163.17,75.69 v1(163.17,65.5)
  BOTTOM w0.147: v1(171.07,80.66) 170.7,80.29 R317.1
N19753822: length 6.2
  TOP w0.254: U22.4 v1(165.9,79.69)
  BOTTOM w0.147: R321.2 166.57,79.02 v1(165.9,79.69) 166.51,80.29 R317.2
N19753872: length 27.5
  TOP w0.147: U30.4 166.26,60.48 v1(166.69,60.06)
  TOP w0.254: v1(171.73,77.56) 171.74,77.57 C85.1 172.85,78.23 R112.2
  L08_SIG2 w0.091: v1(166.69,60.06) 167.12,60.49 167.12,62.12 166.4,62.85 166.4,77.64 166.83,78.07 169.54,78.07 170.05,77.56 v1(171.73,77.56)
N19753878: length 27.9
  TOP w0.147: v1(166.69,61.4) 166.26,60.98 U30.5
  TOP w0.254: v1(171.11,79.44) 171.34,79.21 C85.2 172.84,79.21 R109.2
  L08_SIG2 w0.091: v1(166.69,61.4) 165.84,62.25 165.84,77.43 166.85,78.45 169.95,78.45 170.38,78.02 171.12,78.02 171.42,78.32 171.42,79.12 v1(171.11,79.44)
N19753964: length 1.2
  TOP w0.147: R141.1 168.16,60.14 168.17,60.16 C125.1
N19754006: length 1.5
  TOP w0.147: U30.30 158.66,58.98 158.06,58.38 C131.1
N19754185: length 1.8
  TOP w0.147: C132.1 166.44,58.18 165.65,58.98 U30.1
N19754201: length 5.2
  TOP w0.147: 156.71,63.95 C115.2 157.51,63.93 157.96,63.48 U30.21
  TOP w0.254: 156.12,63.95 156.71,63.95 ; 156.12,63.95 155.67,64.4 ; 156.12,63.95 155.77,63.95 155.44,64.28 ; 156.12,63.95 156.12,64.31 155.8,64.63
N19754203: length 8.2
  TOP w0.254: D4.1 157.69,68.92 157.51,68.73 C115.1 158.23,64.93 158.88,64.28 U30.20
N19754223: length 1.5
  TOP w0.147: R130.2 158.2,63.02 158.24,62.98 U30.22
N19754237: length 16.9
  TOP w0.147: R130.1 156.55,63 v1(156.55,62.19) 156.67,62.19 156.95,62.48 U30.23
  TOP w0.254: U24.4 155.8,73.32 v1(156.34,72.79)
  BOTTOM w0.254: v1(156.55,62.19) 156.55,62.7 156.34,62.92 v1(156.34,72.79)
N19754314: length 4.6
  TOP w0.254: v1(156.75,82.3) 156.92,82.12 U21.4
  BOTTOM w0.147: R318.1 157.43,81.62 v1(156.75,82.3) 156.16,81.71 R319.1
N19754320: length 17.3
  TOP w0.254: v1(159.6,65.24) 159.85,65.24 160.18,64.92 U30.19
  L08_SIG2 w0.091: v1(156.59,78.25) 159.6,75.24 v1(159.6,65.24)
  BOTTOM w0.147: R319.2 156.16,78.68 v1(156.59,78.25)
N19754322: length 17.3
  TOP w0.254: v1(160.62,65.37) 160.68,65.31 U30.18
  L08_SIG2 w0.091: v1(160.62,65.37) 161.16,65.92 161.16,75.44 v1(157.61,79)
  BOTTOM w0.147: v1(157.61,79) 157.43,79.17 R318.2
N19754431: length 3.7
  TOP w0.147: R129.1 167.63,63.88 167.07,63.32 167.07,63.32 166.72,62.98 U30.9
N19754435: length 22.5
  TOP w0.254: U30.12 163.67,65.05 164.12,65.5 v1(164.63,65.5)
  L08_SIG2 w0.091: v1(164.63,65.5) 164.63,76.66 166.79,78.81 170.73,78.81 v1(170.99,78.55)
  BOTTOM w0.147: R321.1 170.52,79.02 v1(170.99,78.55)
N19754522: length 2.9
  TOP w0.254: R119.1 144.75,74.97 144.5,74.71 144.5,74.02
N19754526: length 25.2
  TOP w0.147: U30.26 158.19,60.98 158.15,61.02 v1(157.7,61.02)
  TOP w0.254: v1(149.26,75.88) 149.2,75.94 C94.1 147.63,75.94 R113.2
  L08_SIG2 w0.091: v1(157.7,61.02) 157.7,73.89 155.7,75.88 v1(149.26,75.88)
N19754534: length 24.8
  TOP w0.147: U30.27 158.2,60.48 157.93,60.21 v1(157.73,60.21)
  TOP w0.254: 148.71,74.97 C94.2 ; 148.71,74.97 R119.2 ; 148.71,74.97 148.72,74.97 v1(149.26,74.97)
  L08_SIG2 w0.091: v1(149.26,74.97) 155.52,74.97 157.26,73.23 157.26,60.69 v1(157.73,60.21)
N19754630: length 1.5
  TOP w0.147: U30.32 160.18,57.31 160.07,57.2 C137.2
N19754677: length 1.1
  TOP w0.147: C136.1 155.01,57.91 R142.1
N20142928: length 1.7
  BOTTOM w0.254: U62.2 90.04,127.14 89.64,126.74 C200.1
N20753582: length 2.5
  BOTTOM w0.254: R267.2 R261.2 C248.1
N22464359: length 1.7
  TOP w0.254: R174.2 109.58,64.23 U39.5
N23484157: length 3.5
  TOP w0.147: v1(55.88,103.52) R53.1
  BOTTOM w0.147: U70.24 56.9,103.76 56.65,103.52 v1(55.88,103.52) R53.1
N23484680: length 3.2
  TOP w0.147: v1(59.18,102) R59.1
  BOTTOM w0.147: R59.1 v1(59.18,102) 58.94,102.24 U70.22
N24658557: length 2.8
  TOP w0.147: LD20.2 v1(143.38,32.4)
  BOTTOM w0.147: v1(143.38,32.4) 142.48,32.4 142.35,32.53 R462.2
N24754956: length 11.7
  TOP w0.147: v1(36.24,70.96) 36.24,63.62 v1(35.52,62.91)
  BOTTOM w0.147: U80.13 v1(36.24,70.96) 35.35,70.96 TP69.1 ; U80.48 35.68,62.75 v1(35.52,62.91)
N24775601: length 13.8
  TOP w0.147: U20.48 35.33,85.37 v1(34.78,85.92) 34.33,86.37 TP19.1 ; U20.13 v1(36.37,77.15)
  BOTTOM w0.147: v1(36.37,77.15) 36.37,84.33 v1(34.78,85.92)
N24776171: length 1.4
  BOTTOM w0.147: R334.2 Q15.1
N24776230: length 1.6
  TOP w0.147: Q4.1 R99.1
N24826481: length 4.3
  BOTTOM w0.147: U74.3 173.95,101.48 174.34,101.87 R266.2 R260.1 C245.1
N24972917: length 1.8
  BOTTOM w0.147: R280.2 138.94,94.43 R295.3
N24972919: length 1.8
  BOTTOM w0.147: R295.2 137.41,94.52 R281.2
N24972921: length 6.8
  TOP w0.147: U16.8 137.41,97.02 137.52,96.92 137.81,96.92 137.91,97.02 U16.9 137.91,98.97 v1(137.69,99.2)
  BOTTOM w0.147: R281.1 137.41,96.94 137.69,97.21 C269.2 v1(137.69,99.2)
N24972925: length 4.5
  TOP w0.147: v1(138.68,99.33) 138.41,99.06 U16.10
  BOTTOM w0.147: v1(138.68,99.33) 138.68,98.44 138.67,98.42 C269.1 138.67,97.21 138.94,96.94 R280.1
N24973001: length 1.8
  TOP w0.147: U16.3 R48.1
N25209998: length 1.8
  BOTTOM w0.14: U71.1 73.66,102.69 73.64,102.68 R268.1
N25294505: length 1.6
  TOP w0.254: LD6.2 R80.1
N25395961: length 2.8
  TOP w0.147: U23.A12 99.91,76.3 99.94,76.34 v1(100.4,76.34)
  BOTTOM w0.147: v1(100.4,76.34) 100.4,77.05 100.58,77.23 R323.2
N25526660: length 3
  BOTTOM w0.147: U70.12 63.5,106.56 63.88,106.19 64.24,106.19 64.41,106.02 R254.2
N25657725: length 1.6
  TOP w0.147: U23.A19 v1(99.65,70.7)
  BOTTOM w0.147: R345.1 100.01,70.34 v1(99.65,70.7)
N25657961: length 4.8
  BOTTOM w0.147: J36.3 5.92,16.81 6.13,16.6 8.43,16.6 9.11,17.29 R541.2
N25658118: length 1.8
  BOTTOM w0.147: U99.3 R516.2
N26002209: length 4
  TOP w0.147: U40.B2 96.52,45.86 R157.2
N26002808: length 1.9
  BOTTOM w0.147: Q19.1 94.86,16.66 R552.1
N26002814: length 1.9
  TOP w0.147: LD26.2 R210.1
N26002874: length 2.1
  BOTTOM w0.147: R553.1 102.34,14 101.89,14.46 Q18.1
N26002883: length 1.8
  TOP w0.147: LD23.2 R197.1
N26004018: length 3.4
  TOP w0.254: C49.1 144.78,96.03 144.51,95.75 R82.1 145.34,95.14 145.6,94.88 U17.7
N26004022: length 1.3
  TOP w0.254: C48.2 143.51,95.82 143.53,95.8 R82.2
N26004036: length 12.8
  TOP w0.147: 150.13,94.17 150.22,94.17 ; 149.85,93.89 149.83,93.88
  TOP w0.254: 150.36,93.88 150.37,93.87
  TOP w0.305: 149.85,93.88 U17.2 ; 149.85,93.88 149.85,93.89 150.13,94.17 ; 149.85,93.88 150.87,93.88 v1(151,93.74) ; 149.85,93.88 150.19,93.54
  TOP w0.381: C54.1 v1(142.62,93.87)
  BOTTOM w0.381: v1(142.62,93.87) 145.03,93.87 146.05,92.85 150.11,92.85 v1(151,93.74)
N26004038: length 1.8
  TOP w0.254: U17.9 145.55,93.88 145.54,93.87 C54.2
N26004052: length 2.3
  BOTTOM w0.381: R277.2 R279.1 C272.1
N26016842: length 1.6
  BOTTOM w0.305: 58.04,19.06 58.05,19.07 U97.9
N26016868: length 4.2
  BOTTOM w0.147: U97.7 59.05,19.94 59.44,19.55 R535.1 60.79,18.54 60.81,18.56 TP98.1
N26016893: length 1.9
  BOTTOM w0.147: U97.3 58.55,24.04 R500.2
N26118637: length 2.9
  TOP w0.147: U4.1 v1(20.7,121.93)
  BOTTOM w0.147: R221.2 v1(20.7,121.93)
N26118639: length 2.9
  TOP w0.147: U4.4 v1(24.51,121.93)
  BOTTOM w0.147: R220.2 v1(24.51,121.93)
N26120249: length 2.9
  TOP w0.147: U3.1 v1(10.8,121.93)
  BOTTOM w0.147: R223.2 v1(10.8,121.93)
N26120251: length 2.9
  TOP w0.147: U3.4 v1(14.6,121.93)
  BOTTOM w0.147: R222.2 v1(14.6,121.93)
N26140693: length 3.1
  BOTTOM w0.147: R372.2 78.19,59.09 77.54,58.43 76.68,58.43 76.18,57.94 U81.21
N26140695: length 2.3
  BOTTOM w0.147: R373.2 76.85,59.09 75.68,57.91 U81.20
N26140697: length 1.9
  BOTTOM w0.147: U81.19 75.18,58.02 75.69,58.54 R374.2
N26140699: length 1.8
  BOTTOM w0.147: R375.2 74.42,58.54 74.68,58.28 U81.18
N26140701: length 2.2
  BOTTOM w0.147: U81.17 74.18,58.1 73.19,59.09 R376.2
N26140703: length 2.9
  BOTTOM w0.147: R377.2 71.92,59.09 72.48,58.53 73.21,58.53 73.68,58.06 U81.16
N26140705: length 4.1
  BOTTOM w0.147: U81.15 73.18,58.06 73.06,58.18 70.87,58.18 70.61,58.43 R378.2
N26140707: length 4.1
  BOTTOM w0.147: R379.2 69.38,59.09 69.86,58.61 69.93,58.61 71.12,57.42 72.21,57.42 72.26,57.37 U81.14
N26145534: length 1.5
  TOP w0.147: Q5.1 133.85,82.18 v1(133.75,82.08)
  BOTTOM w0.147: R312.1 134.37,82.08 v1(133.75,82.08)
N26145544: length 2.7
  TOP w0.147: LD7.2 133.14,86.28 v1(133.1,86.23)
  BOTTOM w0.147: R305.1 133.6,86.28 133.55,86.23 v1(133.1,86.23)
N26145600: length 1.6
  TOP w0.147: Q2.1 157.8,120.77 157.75,120.72 R20.1
N26145606: length 2.5
  TOP w0.147: LD2.2 v1(156.46,126)
  BOTTOM w0.14: v1(156.46,126) R211.1
N26145666: length 1.5
  TOP w0.147: R14.1 126.09,121.39 126.02,121.46 Q1.1
N26145672: length 1.4
  TOP w0.147: LD3.2 121.92,121.22 121.94,121.2 R15.1
N26145732: length 1.4
  TOP w0.147: R136.1 10.05,59.03 9.99,59.09 Q7.1
N26145738: length 3.8
  TOP w0.147: LD10.2 v1(9.73,62)
  BOTTOM w0.147: R365.1 8.8,61.95 8.84,62 v1(9.73,62)
N26145798: length 1.6
  TOP w0.147: Q6.1 133.83,64.72 133.78,64.77 R127.1
N26145804: length 2.7
  TOP w0.147: v1(138.81,61.72) LD8.2
  BOTTOM w0.147: R360.1 v1(138.81,61.72)
N26145856: length 1.9
  BOTTOM w0.147: Q11.1 29.27,121.6 29.36,121.51 R217.1
N26145862: length 3.5
  TOP w0.147: LD1.2 32.85,126.25 33.27,125.83 v1(33.27,124.98)
  BOTTOM w0.147: R212.1 v1(33.27,124.98)
N26149805: length 1.9
  BOTTOM w0.147: R454.2 106.19,35.4 106.17,35.42 U90.4
N26149864: length 2.5
  BOTTOM w0.147: R555.2 56.28,11.32 56.13,11.18 J30.2
N26219977: length 2.2
  TOP w0.147: SW3.15 v1(104.22,28.23)
  BOTTOM w0.147: v1(104.22,28.23) R490.1
N26220001: length 2.2
  TOP w0.147: SW3.16 v1(102.95,28.23)
  BOTTOM w0.147: v1(102.95,28.23) R475.1
N26314477: length 4
  BOTTOM w0.147: 109.4,96.62 109.41,96.61 109.41,96.55
  BOTTOM w0.254: C278.1 C279.1 109.41,94.66 C285.1 109.41,96.55 109.4,96.56 R298.2
N26314562: length 4.1
  BOTTOM w0.381: R307.2 116.4,79.37 C296.1 116.32,80.66 C292.1 C291.1
N26442461: length 2.4
  TOP w0.147: U51.5 R185.1
N26454965: length 1.7
  TOP w0.147: U41.4 141.85,44.09 141.9,44.14 R171.1
N26523524: length 2.3
  TOP w0.147: R158.1 101.75,45.86 101.47,45.58 U40.A5
N26648719: length 3.1
  BOTTOM w0.147: TP92.1 52.32,37.23 53.22,37.23 53.99,36.45 U91.18
N26648730: length 2.7
  BOTTOM w0.147: U91.19 54.49,36.45 53.09,37.86 TP90.1
N26648748: length 2.6
  BOTTOM w0.147: U91.20 54.99,36.71 54.22,37.49 54.22,37.98 TP88.1
N26648766: length 2.8
  BOTTOM w0.147: TP87.1 55.24,37.59 55.5,37.34 U91.21
N26648784: length 3.3
  BOTTOM w0.147: U91.22 56,38.01 56.03,38.05 56.03,38.9 TP86.1
N26648802: length 2.2
  BOTTOM w0.147: U91.23 56.5,37.71 TP89.1
N26648820: length 2.1
  BOTTOM w0.147: TP91.1 57.28,37.1 57.17,37.1 57,36.92 U91.24
N26733190: length 4.7
  TOP w0.254: v1(17.65,59.96) 17.78,60.08 U32.4
  BOTTOM w0.254: R361.2 18.67,62.66 18.69,62.64 R364.1 18.69,60.99 v1(17.65,59.96)
N26733205: length 2.8
  TOP w0.254: U32.2 19.21,58.08 18.53,57.4 18.41,57.4
N26733231: length 2.4
  TOP w0.254: U32.9 21.2,59.58 v1(21.21,59.58)
  BOTTOM w0.254: v1(21.21,59.58) 21.72,59.58 21.95,59.34 C402.1
N26735382: length 2.4
  TOP w0.254: U5.9 97.16,117.46 v1(97.16,117.46)
  BOTTOM w0.254: v1(97.16,117.46) 97.16,116.95 96.92,116.72 C202.1
N26735416: length 3.6
  TOP w0.254: v1(97.54,121.02) 97.66,120.89 U5.4
  BOTTOM w0.254: R213.1 98.31,120.75 98.04,121.02 v1(97.54,121.02) 97.63,121.11 R214.2
N26735457: length 2.1
  TOP w0.254: U5.2 95.66,119.46 95.38,119.75
N26735496: length 5.4
  BOTTOM w0.254: U65.6 138.6,119.39 138.56,119.44
N26735653: length 3.5
  TOP w0.254: R144.2 132.09,56.42 132.18,56.51 R145.1 133.5,57.04 U33.2
N26736579: length 7.7
  TOP w0.254: 130.8,76.1 U25.6 ; 130.8,76.1 129.22,74.52 127.53,74.52 ; 130.8,76.1 130.51,76.1 130.29,75.87 ; 130.8,76.1 130.8,75.8 130.55,75.55
N26736751: length 1.9
  TOP w0.254: R57.2 154.43,103.73 155.11,104.4 U12.1
N26736805: length 2.7
  TOP w0.254: v1(155.96,107.46) 155.76,107.26 U12.7
  BOTTOM w0.147: R44.2 155.27,107.13 155.6,107.46 v1(155.96,107.46) 156.65,107.46 R49.1
N26881621: length 2.9
  TOP w0.147: v1(138.3,30.24) 138.08,30.46 LD21.1
  BOTTOM w0.147: R464.2 137.07,30.89 137.72,30.24 v1(138.3,30.24)
N27030520: length 2.1
  BOTTOM w0.147: R252.1 70.23,105.79 70.25,105.81 U71.3
N27215594: length 2.8
  TOP w0.147: J14.14 28.56,97.42 29.16,96.83 R76.2
N27215846: length 1.6
  BOTTOM w0.147: J14.12 24.87,107.09 C231.2
N27215858: length 1.6
  BOTTOM w0.147: C240.2 21.27,106.06 21.28,106.05 J14.6
N27215870: length 1.8
  BOTTOM w0.147: C273.2 J14.1
N27215882: length 1.7
  BOTTOM w0.147: C282.2 24.87,93.79 24.89,93.81 J14.7
N27217693: length 3.4
  BOTTOM w0.147: J21.B1 15.3,70.75 16.07,69.98 FB19.2
N27218001: length 2.2
  BOTTOM w0.147: J21.B14 13.41,79.51 13.64,79.75 R316.2
N27218087: length 2.5
  BOTTOM w0.147: J21.B11 14.08,71.67 R347.2
N27219244: length 3.7
  BOTTOM w0.147: J21.A1 15.3,79.95 16.19,80.85 FB14.2
N27219534: length 4.2
  BOTTOM w0.147: J21.A14 12.95,79.78 12.95,81.11 13.64,81.79 R313.2
N27219552: length 2.5
  BOTTOM w0.147: J21.A11 10.87,73.09 R336.2
N27838027: length 1.8
  TOP w0.147: R24.1 126.23,118.74 U10.6
N27914276: length 1.7
  TOP w0.254: R577.2 164.17,56.82 U30.40
N27928121: length 2
  TOP w0.147: U30.31 159.68,57.43 158.81,56.56 R578.1
N27928168: length 6.6
  TOP w0.254: R579.1 R602.2 142.01,95.73 142.52,95.22 142.52,94.91 142.95,94.49 145.17,94.49 145.28,94.38 U17.8
N27943339: length 1.3
  BOTTOM w0.254: U65.1 146.42,120.14 R580.1
N27943633: length 1.7
  TOP w0.254: v1(96.52,120.76) 96.66,120.62 U5.6
  BOTTOM w0.147: R581.1 v1(96.52,120.76)
N27943804: length 1.5
  BOTTOM w0.254: R582.1 143.78,102.87 143.24,102.33 U72.3
N27943890: length 2.5
  TOP w0.147: U33.4 137.04,56.39 138.04,55.39 R583.1
N27943939: length 1.5
  TOP w0.254: U25.1 134.83,75.1 135.19,74.74 135.19,74.74 135.27,74.66 R584.1
N27944274: length 1.6
  TOP w0.254: v1(34.16,117.62) 34.02,117.48 U9.6
  BOTTOM w0.254: R585.1 33.77,117.22 v1(34.16,117.62)
N27944496: length 1.2
  BOTTOM w0.254: R586.1 U62.4
N27944776: length 1.7
  TOP w0.254: v1(17.91,58.94) 18.05,59.08 U32.6
  BOTTOM w0.254: R587.1 18.57,58.94 v1(17.91,58.94)
N27944822: length 1.2
  BOTTOM w0.147: R588.1 47.17,94.84 U77.3
N27945052: length 1.2
  BOTTOM w0.254: U100.3 14.14,18.86 R589.1
N27977097: length 4.7
  TOP w0.147: R138.1 99.19,59.45 99.44,59.2 C133.2 99.44,58.32 99.33,58.21 99.32,58.21 99.21,58.1 99.21,56.38 99.38,56.21 Y1.1
N27977103: length 2.4
  TOP w0.147: Y1.3 101.75,58.35 C134.2 101.75,59.67 R139.1
N28035755: length 3.8
  TOP w0.147: v1(89.15,66.04) 89.15,66.67 89.35,66.87 89.35,68.51 89.46,68.62 U23.N21
  BOTTOM w0.147: R591.2 v1(89.15,66.04)
N28118242: length 2.7
  TOP w0.147: LD7.1 136.23,84.5 136.02,84.28 Q5.3
N28118245: length 2.6
  TOP w0.147: Q2.3 158.75,123.86 159.55,124.66 LD2.1
N28118248: length 2.3
  TOP w0.147: LD3.1 123.01,124 123.8,123.2 Q1.3
N28118251: length 3.3
  TOP w0.381: Q7.3 7.2,61.52 7.63,61.95 LD10.1
N28118254: length 2.9
  TOP w0.147: Q6.3 136.81,64.44 137.32,64.95 LD8.1
N28118257: length 3.2
  TOP w0.147: v1(28.32,126.38) 28.78,126.38 28.9,126.25 LD1.1
  BOTTOM w0.147: Q11.3 v1(28.32,126.38)
N28118260: length 7.2
  TOP w0.254: LD4.2 v1(151.26,103.01)
  BOTTOM w0.254: R276.2 151.51,98.06 151.26,98.31 v1(151.26,103.01)
N28118377: length 2.8
  TOP w0.147: LD9.2 172.71,63.68 v1(172.71,64.91)
  BOTTOM w0.147: R362.2 172.19,64.39 v1(172.71,64.91)
N28118380: length 2.4
  TOP w0.147: v1(163.7,52.97) LD15.2
  BOTTOM w0.147: R407.2 v1(163.7,52.97)
N28118607: length 2.8
  TOP w0.147: LD25.2 v1(18.8,10.68)
  BOTTOM w0.14: R556.2 v1(18.8,10.68)
N28118686: length 1.1
  TOP w0.381: R201.2 LD24.2
N28119618: length 2.6
  TOP w0.147: v1(100.82,16.76) 101.33,16.76 101.8,17.24 LD23.1
  BOTTOM w0.147: v1(100.82,16.76) 100.62,16.56 Q18.3
N28119621: length 3.2
  TOP w0.147: LD26.1 95.38,12.73 v1(95.91,13.27)
  BOTTOM w0.147: v1(95.91,13.27) Q19.3
N248107881: length 1.5
  TOP w0.147: R189.2 C168.1

## Copper pours and planes (outline as drawn)
DGND on TOP (solid shape): 41.89,79.1 36.34,79.1 36.34,84.65 41.89,84.65
DGND on TOP (solid shape): 74.12,56.34 74.23,56.36 74.29,56.27 74.29,56.03 74.2,55.94 74.2,55.59 73.44,54.83 73.28,54.99 73.63,55.34 73.63,55.85
DGND on TOP (solid shape): 166.1,23.64 163,23.64 162.26,24.42 162.31,24.45 163.23,24.45 163.46,24.68 164.25,24.68 164.25,25.25 164.25,25.26 166.1,25.26
DGND on TOP (solid shape): 58.32,32.25 58.42,32.19 58.4,32.08 57.35,31.03 53.36,31.03 51.5,29.17 51.39,29.15 51.33,29.24 51.33,29.87 53.71,32.25
DGND on TOP (solid shape): 67.44,71 67.5,71.1 67.61,71.08 67.74,70.95 67.74,70.43 66.44,69.13 66.33,69.13 66.28,69.16 66.3,69.21 67.33,70.25 67.33,70.51 67.44,70.62
DGND on TOP (solid shape): 152.12,42.7 152.12,42.64 152.11,42.6 152.07,42.58 151.88,42.56 151.72,42.46 151.45,42.46 150.05,41.06 149.81,41.06 149.81,43.16 151.66,43.16
DGND on TOP (solid shape): 91.54,38 91.54,37.21 91.25,36.91 90.57,36.91 90.57,37.85 90.5,37.85 90.42,37.88 90.39,37.95 90.39,38.02 90.38,38.09 90.39,38.18 90.48,38.22 91.33,38.22
DGND on TOP (solid shape): 98.15,68.18 98.15,66.13 100.08,64.2 100.08,61.57 101.16,60.49 101.25,60.49 101.25,59.21 101.27,59.21 101.27,58.32 101.48,58.32 101.48,58.13 100.85,58.13 100.85,56.93 99.49,56.93 99.49,57.98 99.72,58.21 99.72,58.3 99.92,58.3 99.92,59.24 99.81,59.24 99.81,61.41 99.78,61.41 99.78,61.45 99.47,61.45 99.47,64.11 97.74,65.84 97.74,68.4 97.92,68.4
DGND on TOP (solid shape): 121.81,61.42 123.05,61.42 123.05,61.62 123.45,61.62 123.54,61.55 123.52,61.44 123.1,61.02 120.97,61.02 120.8,61.19 120.8,62.21 120.78,62.23 120.75,62.34 120.85,62.4 121.81,62.4
DGND on TOP (solid shape): 66.71,71.42 66.82,71.44 66.89,71.34 66.89,70.85 66.78,70.74 66.78,70.48 65.88,69.58 65.63,69.58 63.57,67.52 63.46,67.49 63.4,67.59 63.4,67.96 65.21,69.77 65.84,69.77 66.32,70.25 66.32,71.02
DGND on TOP (solid shape): 68.06,71.75 68.1,71.8 68.15,71.78 68.24,71.7 68.32,71.64 68.43,71.62 68.76,71.62 68.76,70.06 67.29,68.59 66.94,68.59 66.84,68.66 66.86,68.77 68.3,70.2 68.3,71.18 68.06,71.41
DGND on TOP (solid shape): 72.71,54.91 72.76,54.88 72.75,54.82 72.7,54.77 72.64,54.68 72.62,54.58 72.62,54.41 72.64,54.31 72.7,54.22 72.76,54.15 72.04,53.44 71.46,53.44 71.36,53.5 71.39,53.61 72.69,54.91
DGND on TOP (solid shape): 49.34,31.52 49.4,31.61 49.51,31.59 49.76,31.34 49.76,28.96 48.83,28.03 48.72,28.01 48.66,28.1 48.66,28.93 48.77,29.09 48.79,29.28 48.81,29.36 48.89,29.39 49.34,29.39
DGND on TOP (solid shape): 80.43,69.07 80.48,69.03 80.47,68.98 80.45,68.96 80.45,68.03 79.08,68.03 79.08,68.38 79.12,68.46 79.22,68.47 79.64,68.54 79.77,68.94 79.79,69.03 79.87,69.07
DGND on TOP (solid shape): 64.49,33.52 64.57,33.48 64.59,33.4 64.58,33.34 64.57,33.28 64.55,33.21 64.47,33.17 64.4,33.17 64.4,31.93 64.65,31.93 64.65,31.57 64.9,31.32 64.91,31.26 64.86,31.23 64.84,31.23 64.84,29.13 61.37,29.13 61.28,29.19 61.3,29.3 62.63,30.63 62.63,32.79 63.36,33.52
DGND on TOP (solid shape): 43.17,77.06 43.23,77.15 43.34,77.13 43.72,76.75 43.74,76.64 43.65,76.58 43.61,76.58 42.12,75.09 41.7,75.09 41.67,75.12 41.64,75.15 41.6,75.21 41.61,75.29 41.66,75.39 41.68,75.51 41.71,75.58 41.78,75.6 41.9,75.6 41.9,76.58 43.17,76.58
DGND on TOP (solid shape): 46.55,30.22 46.6,30.22 46.64,30.2 46.65,30.16 46.93,30.16 46.93,29.38 46.97,29.34 46.98,29.28 47,29.09 47.11,28.93 47.11,28.12 46.46,27.47 45.78,27.47 45.7,27.51 45.68,27.6 45.68,27.81 45.58,27.99 45.54,28.02 46.38,28.86 46.38,30.13 46.42,30.21 46.51,30.23
DGND on TOP (solid shape): 120.65,65.91 122.95,65.91 123.03,65.82 123.04,65.77 123,65.73 120.84,65.73 120.84,65.18 120.53,65.18 120.51,65.2 120.26,65.2 120.26,65.39 119.01,65.39 119.01,65.2 118.76,65.2 118.63,65.32 118.26,65.52 117.92,65.29 117.84,65.23 117.75,65.26 116.82,66.19 116.8,66.3 116.89,66.36 120.2,66.36
DGND on TOP (solid shape): 82.52,76.21 82.5,76.19 82.33,75.94 82.44,75.66 82.47,75.58 82.44,75.51 81.08,74.14 80.57,74.14 80.48,74.21 80.5,74.32 81.05,74.87 81.05,75.49 81.35,75.79 81.43,75.82 81.5,75.78 82,75.75 81.96,76.24 81.92,76.32 81.95,76.4 81.98,76.43 82.52,76.43
DGND on TOP (solid shape): 104.95,66.87 108.97,66.87 109.05,66.83 109.07,66.75 109.07,66.63 109.11,66.51 109.12,66.5 109.12,66.43 109.01,66.43 109,66.45 108.53,66.52 108.31,66.1 108.29,66.01 108.21,65.98 104.99,65.98 103.87,67.09 102.48,67.09 102.13,67.44 102.1,67.52 102.15,67.6 102.35,67.94 102.17,68.29 102.12,68.36 102.15,68.45 102.26,68.64 102.26,68.86 102.27,68.95 102.35,68.99 102.82,68.99
DGND on TOP (solid shape): 51,82.73 51.2,82.54 51.29,82.48 51.39,82.45 51.56,82.45 51.66,82.48 51.75,82.54 51.88,82.66 52,82.54 52.09,82.48 52.19,82.45 52.24,82.45 52.29,82.42 52.28,82.37 48.02,78.11 46.74,78.11 46.65,78.18 46.67,78.29 47.01,78.63 47.01,80.87 47.06,80.92 48.05,80.92 48.14,81 48.19,80.95 48.19,80.94 48.85,80.67 48.72,81.37 48.65,81.44 48.68,81.54 48.77,81.63 49.3,81.11 49.58,81.11 49.68,81.13 49.77,81.19 49.97,81.39 49.97,81.67 50.15,81.67 50.25,81.7 50.34,81.76 50.54,81.95 50.54,82.35 50.01,82.88 50.59,83.45 51,83.45
DGND on TOP (solid shape): 33.12,83.98 33.52,83.98 33.52,83.28 32.44,83.28 31.72,84 30.48,84 30.41,84.03 30.38,84.09 29.67,84.33 29.99,83.65 30.01,83.66 30.07,83.6 30.01,83.54 29.99,83.54 29.67,82.87 30.38,83.1 30.41,83.17 30.48,83.2 31.39,83.2 32.03,82.55 32.12,82.5 32.21,82.48 33.52,82.48 33.52,81.79 30.08,81.79 29.62,81.33 28.51,81.33 28.51,82.04 28.09,82.45 27.5,82.45 27.14,82.08 26.73,82.49 26.64,82.49 26.64,82.57 26.67,82.59 27.51,83.71 26.99,85.01 26.96,85.13 27.05,85.19 31.9,85.19
DGND on TOP (solid shape): outline of 210 points within 124.86,28.2 148.95,46.98
DGND on TOP (solid shape): outline of 234 points within 116.56,66.54 125.78,83.68
DGND on TOP (solid shape): outline of 247 points within 71.08,85.8 82.36,95.2
DGND on TOP (solid shape): outline of 253 points within 130.78,74.3 138.09,88.43
DGND on TOP (solid shape): outline of 101 points within 42.32,82.92 55.51,90.29
DGND on BOTTOM: 23.37,59.96 19.56,59.96 19.43,60.09 19.43,63.01 23.5,63.01 23.5,60.09
DGND on L02_GND1: 1.02,8.02 1.02,47.69 1.02,47.69 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.87 1.02,60.87 1.02,132.98 9.02,132.98 9.02,130.95 9.27,130.7 10.89,130.7 12.32,129.27 12.32,128.54 11.68,127.9 11.68,124.98 13.72,124.98 13.72,128.02 13.08,128.65 13.08,129.29 14.36,130.57 15.88,130.57 16.51,131.21 16.51,132.98 18.67,132.98 18.67,130.57 20.95,130.57 22.23,129.3 22.23,128.79 21.59,128.16 21.59,124.98 23.62,124.98 23.62,128.41 26.92,131.71 26.92,132.98 176.78,132.98 176.78,8.02 ; 1 cut-out
DGND on L03_SIG1: 73.69,73.1 73.69,68.5 77.01,68.5 77.01,73.1 ; 1 cut-out
DGND on L04_GND2: 1.02,8.02 1.02,47.31 1.02,47.31 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.52 1.02,60.52 1.02,132.98 176.78,132.98 176.78,8.02
DGND on L07_GND3: 1.02,8.02 1.02,46.95 1.02,46.95 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.39 1.02,60.39 1.02,132.98 176.78,132.98 176.78,8.02
DGND on L09_GND4: 1.02,8.02 1.02,49.01 1.02,49.01 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.34 1.02,60.34 1.02,132.98 176.78,132.98 176.78,8.02
GNDUSB on TOP: 168.23,35.45 168.23,38.94 174.69,38.94 174.94,39.2 174.94,42.18 174.69,42.43 173.04,42.43 173.04,46.5 177.35,46.5 177.35,35.45
VCC1V2_DDR on TOP: 87.36,115.06 87.36,119.63 92.46,119.63 92.46,115.06
VCC1V2_DDR on TOP: 98,119.81 98,126.22 101.85,126.22 101.85,119.81
VCC1V2_DDR on BOTTOM: 87.88,119.78 92.99,119.78 92.99,115.08 87.88,115.08
VCC1V2_DDR on L08_SIG2: 87.76,115.57 93.85,115.57 93.85,118.75 94.87,119.76 102.23,119.76 102.23,124.01 93.53,124.01 87.76,118.24
VCC1V8 on TOP: 95.85,37.99 95.85,36.29 102.11,36.29 102.11,37.99
VCC1V8 on TOP: 113.06,46.85 113.06,45.61 121.74,45.61 121.74,46.85
VCC1V8 on TOP: 132.08,116.02 139.56,116.02 139.56,107.34 132.08,107.34
VCC1V8 on BOTTOM: 132.08,107.34 132.08,112.03 134.49,112.03 134.49,116.85 141.1,116.85 141.11,116.85 141.91,116.85 142.37,116.39 142.37,110.12 139.59,107.35 137.19,107.35 137.19,107.34
VCC1V8 on L06_PWR2: 127.52,36.52 118.45,27.45 94.61,27.45 90.42,31.64 90.42,49.8 90.55,49.93 119.28,49.93 133.74,64.38 137.28,64.38 147.57,74.68 147.57,92.01 131.95,107.63 131.95,110.18 130.11,112.03 126.55,112.03 122.98,115.6 95.78,115.6 91.52,119.86 75.55,119.86 74.11,118.42 74.11,95.19 67.96,95.19 67.96,122.07 70.46,124.57 81.14,124.57 82.51,123.2 84.74,123.2 86.11,124.57 95.63,124.57 98.44,121.77 129.96,121.77 131.55,120.18 145.6,120.18 156.46,109.32 156.46,65.46 144.82,53.81 137.79,53.81 137.79,50.81 136.91,49.93 135.89,49.93 134.62,51.2 132.46,51.2 127.52,46.25
VCC1V8_HSE on TOP: 74.24,124.81 70.61,124.81 70.61,122.44 74.55,122.44 74.55,124.5
VCC1V8_HSE on BOTTOM: 70.36,122.44 70.36,129.14 71.91,130.7 74.55,130.7 74.55,125.11 74.55,125.11 74.55,123.46 73.53,122.44
VCC3V3_IO_HSE on TOP: 38.69,121.76 38.69,124.02 38.39,124.32 37.94,124.32 37.88,124.37 37.88,126 41.53,126 41.53,121.76
VCC3V3_IO_HSE on BOTTOM: 38.44,124.98 38.44,120.42 41.27,120.42 41.27,124.98
VCC3V3_PREREG on TOP: 149.79,96.95 158.01,96.95 158.01,101.94 149.32,101.94 149.32,97.42
VCC3V3_PREREG on TOP: 156.19,102.38 156.19,104.79 159.26,104.79 159.64,104.41 159.64,102.76 159.26,102.38
VCC3V3_PREREG on TOP: 136.6,57.5 136.6,59.79 139.51,59.79 139.51,57.84 139.17,57.5
VCC3V3_PREREG on TOP: 131.09,75.72 132.86,75.72 132.86,73.31 134.01,73.31 134.01,71.18 131.09,71.18
VCC3V3_PREREG on TOP: 97.28,119.11 95.24,119.11 94.11,117.98 94.11,115.25 97.13,115.25 97.13,117.61 96.9,117.84 96.9,118.6 97.03,118.73 97.28,118.73
VCC3V3_PREREG on BOTTOM: 144.91,122.82 141.22,122.82 141.22,119.9 141.48,119.65 144.78,119.65 144.91,119.78
VCC3V3_PREREG on BOTTOM: 142.11,102.5 141.6,102.5 140.39,101.28 140.39,100.05 142.73,100.05 142.73,101.88
VCC3V3_PREREG on L05_PWR1: 133.48,55.89 131.95,57.42 131.95,66.57 135.62,66.57 136.5,67.45 136.5,70.9 136.14,71.26 131.17,71.26 128.6,73.83 128.6,94.22 129.79,95.41 134.72,95.41 143.26,103.95 143.26,113.3 135.76,120.79 98.04,120.79 97.93,120.91 97.93,115.33 97.16,114.55 93.34,114.55 92.84,115.06 92.84,121.93 98.3,127.4 141,127.4 160.53,107.87 160.53,101.97 151,92.45 139.76,92.45 136.84,89.53 136.84,81.49 143.25,75.08 143.25,66.93 140.84,64.53 140.84,57.29 139.45,55.89 ; 1 cut-out
VCC3V3_TA on TOP: 72.39,21.1 72.39,16.77 75.16,14 84.09,14 84.71,14.62 84.71,17.92 84.45,18.18 77.95,18.18 75.03,21.1
VCC3V3_TA on BOTTOM: 57.66,21.1 50.14,21.1 50.14,13.6 55.37,13.6 55.37,18.3 56.82,19.75 57.51,19.75 57.66,19.89
