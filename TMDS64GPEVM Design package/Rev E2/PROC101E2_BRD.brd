# Allegro board PROC101E2_BRD.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VCC3V3_TA on BOTTOM: 66.52,20.87 66.52,19.65 72.95,19.65 72.95,20.87
VCC3V3_TA on BOTTOM: 82.27,17.82 82.27,13.17 84.96,13.17 84.96,17.82
VCC3V3_TA on L05_PWR1: 50.51,14.4 50.51,16.65 57.24,23.38 66.42,23.38 68.33,21.48 68.33,18.3 63.88,13.86 51.05,13.86
VCC3V3_TA on L06_PWR2: 64.01,21.86 64.01,51.37 69.72,57.09 69.72,65.04 70.62,65.94 72.26,65.94 73.15,65.04 73.15,61.36 73.77,60.73 79.97,60.73 86.71,53.99 109.73,53.99 109.98,53.74 109.98,42.56 112.19,40.35 112.19,38.4 111.65,37.86 104.9,37.86 103.98,38.78 103.98,40.25 106.17,42.43 106.17,50.13 105.49,50.81 73.7,50.81 72.71,49.82 72.71,26.11 74.55,24.27 96.9,24.27 98.55,22.62 98.55,18.94 66.93,18.94
VCC3V3_XDS on TOP: 167.39,11.44 167.39,10.56 167.26,10.43 163.58,10.43 163.58,12.08 164.72,12.08 165.35,11.44
VCC3V3_XDS on L05_PWR1: 139.04,23.76 133.48,23.76 131.95,25.29 131.95,28.84 135.64,32.53 154.56,32.53 159.51,27.57 162.69,27.57 165.93,24.33 165.93,10.29 163.91,8.27 150.61,8.27 140.46,18.42 140.46,22.34
VCC_1V8_FT4232 on TOP: 132.24,46.75 132.24,37.83 135.13,34.94 146.43,34.94 149.35,37.86 149.35,45.35 148.84,45.86 146.43,45.86 144.15,43.58 144.15,41.13 142.12,39.11 135.8,39.11 134.49,40.42 134.49,46.24 133.99,46.75
VCC_3V3_FT4232 on L06_PWR2: 128.27,46.75 134.37,52.85 144.4,52.85 144.4,48.91 143.51,48.02 138.94,48.02 134.24,43.32 134.24,37.35 135.38,36.21 145.67,36.21 147.45,37.99 147.45,43.58 156.21,43.58 156.21,41.04 147.4,32.23 141.74,32.23 136.7,27.19 128.4,27.19 125.48,30.11 125.48,33.15 128.27,35.94
VCC_3V3_MIPI on BOTTOM: 58.55,53.48 58.55,52.16 61.85,52.16 61.85,53.48
VCC_3V3_MIPI on L08_SIG2: 59.69,52.21 59.69,53.23 62.1,53.23 62.1,52.21
VCC_3V3_SYS on TOP: 20.75,45.99 20.75,43.7 26.04,43.7 26.04,45.99
VCC_3V3_SYS on TOP: 19.56,59.7 19.56,58.31 20.33,57.54 23.42,57.54 23.42,59.63 21.14,59.63 20.83,59.32 20.07,59.32 19.94,59.45 19.94,59.7
VCC_3V3_SYS on TOP: 32.51,116.85 32.51,118.25 31.74,119.02 28.65,119.02 28.65,117.01 31.02,117.01 31.24,117.24 32,117.24 32.13,117.11 32.13,116.85
VCC_3V3_SYS on TOP: 138.55,88.15 138.56,88.15 138.56,93.02 142.04,93.02 142.04,88.79 146.25,88.79 146.25,77.59 138.81,77.59 138.55,77.85
VCC_3V3_SYS on TOP: 115.65,63.67 118.62,63.67 119.95,62.33 119.95,60.85 115.62,60.85 115.42,61.05 115.42,63.44
VCC_3V3_SYS on BOTTOM: 43.58,45.35 43.58,46.88 52.84,46.88 52.84,45.35
VCC_3V3_SYS on BOTTOM: 49.72,91.07 49.72,91.58 48.5,92.8 47.31,92.8 47.31,90.57 47.56,90.31 48.96,90.31
VCC_3V3_SYS on BOTTOM: 42.79,58.63 42.79,56.53 52.07,56.53 52.07,58.63
VCC_3V3_SYS on BOTTOM: 15.75,18.68 16.26,18.68 17.48,19.9 17.48,21.21 15.24,21.21 14.99,20.96 14.99,19.45
VCC_3V3_SYS on BOTTOM: 75.82,112.22 76.71,112.22 76.71,115.46 75.82,115.46
VCC_3V3_SYS on BOTTOM: 138.56,93.28 141.55,93.28 143.62,91.21 145.37,91.21 145.37,80.54 138.55,80.54 138.55,88.15 138.56,88.15
VCC_3V3_SYS on BOTTOM: 91.72,129.74 91.72,132.65 90.42,132.65 90.42,129.74
VCC_3V3_SYS on BOTTOM: 74.82,120.4 76.21,120.4 77.09,119.52 77.09,116.94 76.71,116.94 76.71,118.38 76.26,118.83 74.82,118.83
VCC_3V3_SYS on L05_PWR1: 1.35,53.3 1.02,53.3 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.27,59.12 1.27,132.98 175.81,132.98 175.81,8.02 1.27,8.02 1.27,47.79 1.06,47.79 1.06,50.41 1.44,50.41 1.83,50.41 2.64,50.78 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 ; 7 cut-outs
VCC_3V3_SYS on L06_PWR2: 1.27,8.02 1.27,132.98 177.04,132.98 177.04,8.02 ; 39 cut-outs
VCC_5V0 on TOP: 171.63,87.52 171.63,79.83 176.73,79.83 176.73,88.14 172.26,88.14
VCC_5V0 on TOP: 34.87,48.53 33.48,48.53 33.1,48.91 33.1,51.32 33.22,51.45 34.75,51.45 35.13,51.07 35.13,48.78
VCC_5V0 on TOP: 81.72,125.48 81.72,122.4 84.79,122.4 84.79,125.48
VCC_5V0 on BOTTOM: 171.63,87.52 171.63,79.83 176.78,79.83 176.78,88.14 172.26,88.14
VCC_5V0 on L03_SIG1: 33.81,49.47 33.81,51.25 35.2,51.25 35.2,49.47
VCC_5V0 on L03_SIG1: 24.26,118.38 24.26,116.47 26.29,116.47 26.29,118.38
VCC_5V0 on L06_PWR2: 173.01,81.29 173.01,106 158.08,120.93 132.07,120.93 130.65,122.35 98.78,122.35 95.88,125.24 85.96,125.24 84.42,123.7 82.65,123.7 81.11,125.24 34.04,125.24 28.32,119.52 28.32,112.92 16.64,112.92 16.64,126.75 22.87,132.98 174.75,132.98 176.71,131.02 176.71,81.29
VCC_5V0_HSE on TOP: 70.75,126.07 70.75,125.11 74.29,125.11 74.8,124.6 80.64,124.6 80.9,124.86 80.9,127.01 79.5,128.41 75.56,128.41 74.53,127.38 74.53,126.22 74.38,126.07
VCC_CORE on TOP: 124.16,77.54 124.16,83.58 127.41,83.58 128.05,84.21 128.05,91.99 131.97,91.99 131.97,84.71 131.32,84.05 131.32,82.62 130.32,82.62 130.32,77.54
VDD3V3_CLKBUF on L05_PWR1: 52.83,105.55 52.83,109.36 54.48,111.01 67.31,111.01 67.65,110.67 67.65,109.02 68.58,108.09 73.91,108.09 75.56,106.44 75.56,103.52 74.8,102.76 68.71,102.76 67.82,101.87 67.82,95.39 65.66,93.23 62.87,93.23 59.69,96.41 59.69,99.46 54.74,104.41 53.98,104.41
VDD_0V85 on TOP: 154.55,106.31 153.53,107.33 150.63,107.33 150.63,109.21 150.63,109.21 150.63,114.31 155.45,114.31 155.45,106.44 155.32,106.31
VDD_0V85 on BOTTOM: 155.32,116.34 155.32,107.57 150.79,107.57 150.79,116.34
VDD_1V0 on BOTTOM: 44.34,92.44 45.17,92.44 45.17,94.17 41.2,94.17 40.89,93.87 40.89,91.58 41.15,91.33 43.23,91.33
VDD_1V0 on L05_PWR1: 34.04,101.61 34.04,104.28 36.7,106.95 39.51,106.95 39.72,106.74 39.72,104.95 42.67,102 48.64,102 49.15,101.49 49.15,99.71 48.78,99.34 44.2,99.34 43.91,99.05 43.91,91.93 43.31,91.33 41.36,91.33 41.01,91.69 41.01,93.15 41.82,93.96 41.82,97.01 38.73,100.09 35.56,100.09
VDD_1V1 on TOP: 18.86,59.9 12.45,59.9 12.45,65.47 18.86,65.47
VDD_1V1 on L06_PWR2: 13.08,66.31 13.08,59.58 15.75,56.91 43.78,56.91 49.55,62.68 49.55,86.53 47.76,88.31 40.99,88.31 35.24,82.56 34.54,82.56 34.54,81.68 35.81,81.68 35.81,66.44 34.29,66.44 34.29,65.42 35.69,65.42 35.69,62.5 29.28,62.5 25.47,66.31
VDD_2V5 on TOP: 33.21,116.14 39.62,116.14 39.62,111.09 33.21,111.09
VDD_2V5 on L06_PWR2: 29.46,63.26 35.17,63.26 35.17,64.54 34.92,64.78 33.4,64.78 33.27,64.91 33.27,66.94 33.53,67.2 34.92,67.2 35.17,67.44 35.17,80.62 34.87,80.91 33.66,80.91 33.4,81.17 33.4,83.2 33.53,83.33 34.92,83.33 35.17,83.57 35.17,101.41 39.5,105.75 39.5,113.26 38.7,114.06 32.76,114.06 27.3,108.6 27.3,65.42
VDD_2V8 on BOTTOM: 20.09,13.29 20.09,18.81 16.51,18.81 15.49,17.79 15.49,13.29
VDD_CORE on TOP: 121.51,84.11 121.51,90.57 119.06,90.57 119.06,99.31 124.97,99.31 124.97,91.45 127.38,91.45 127.38,84.11
VDD_CORE on BOTTOM: 103.63,81.03 100.6,81.03 100.6,86.49 103.63,86.49
VDD_CORE on L05_PWR1: 111.3,83.76 107.44,79.9 107.44,76.98 106.52,76.06 93.82,76.06 93.38,75.62 92.84,75.62 92.84,76.25 92.64,76.45 91.85,76.45 91.69,76.3 91.69,75.62 91.06,75.62 91.06,76.34 92.08,77.36 92.08,78.88 91.82,79.14 90.42,79.14 90.04,78.75 90.04,77.36 89.79,77.1 89.03,77.1 88.9,77.23 88.9,77.99 87.76,79.14 87.76,85.1 90.64,87.99 97.95,87.99 98.46,88.5 107.24,97.55 125.42,97.55 127.64,95.34 127.64,85.23 126.36,83.96 122.95,83.96 119.26,87.64 112.39,87.64 111.3,86.55 ; 1 cut-out
VDD_DDR4 on TOP: 86.91,119.78 86.91,115.05 81.9,115.05 81.9,119.78
VDD_DDR4 on BOTTOM: 97.79,92.12 99.82,92.12 99.82,86.5 97.79,86.5
VDD_DDR4 on BOTTOM: 74.8,118.19 74.8,117.04 74.89,116.96 76.55,116.96 76.55,118.19
VDD_DDR4 on L06_PWR2: 91.06,81.93 91.06,80.02 91.44,79.64 93.6,79.64 94.36,80.41 96.26,80.41 98.17,80.28 104.01,86.12 104.01,105.99 90.89,119.12 76.42,119.12 75.4,118.11 75.4,101.91 87.5,89.81 87.5,85.49
VDD_DLL_MMC0 on BOTTOM: 115.82,70.5 115.82,75.58 112.62,75.58 112.62,70.5
VDD_MMC1 on TOP: 113.06,63.18 113.06,59.83 107.85,59.83 107.85,63.18
VDD_MMC1 on L03_SIG1: 103.96,73.07 103.96,72.63 106.1,70.5 106.1,67.25 108.64,64.71 108.64,62.22 109.29,61.56 111.63,61.56 111.63,68.09 106.65,73.07
VDD_MMC1 on L06_PWR2: 108.97,62.68 108.97,61.24 110.28,61.24 110.28,62.68
VDD_MMC1 on L06_PWR2: 39.6,22.27 39.6,19.65 42.32,19.65 42.32,22.27
VDDA1V8 on TOP: 128.27,57.16 126.24,59.2 126.24,67.06 126.25,67.07 130.94,67.07 130.94,61.96 130.93,61.96 130.93,60.99 132.59,59.33 134.36,59.33 135,58.69 135,57.55 132.72,57.55 132.33,57.16
VDDA1V8 on BOTTOM: 128.81,57.93 126.24,60.5 126.24,67.06 126.25,67.07 130.94,67.07 130.94,61.96 130.93,61.96 130.93,60.99 132.1,59.82 132.1,58.34 131.7,57.93
VDDA_1V8 on TOP: 109.22,68.09 109.22,69.99 111.12,69.99 111.12,77.87 111.89,77.87 112.27,78.25 112.27,80.66 108.71,80.66 108.71,83.58 109.47,83.58 109.47,85.1 112.01,85.1 112.01,82.69 113.86,80.84 113.86,68.09
VDDA_1V8 on TOP: 90.3,58.31 90.3,55.01 91.69,55.01 91.69,58.31
VDDA_1V8 on TOP: 130.81,68.05 126.21,68.05 126.21,72.63 130.81,72.63
VDDA_1V8 on BOTTOM: 130.82,68.05 126.21,68.05 126.21,73.06 130.82,73.06
VDDA_1V8 on BOTTOM: 110.62,71.13 112.01,71.13 112.14,71.01 112.14,68.47 111.89,68.21 108.71,68.21 108.58,68.34 108.58,69.86 108.84,70.12 110.36,70.12 110.49,70.25 110.49,71.01
VDDA_1V8 on BOTTOM: 91.47,62.37 91.47,58.99 94.31,58.99 94.31,62.37
VDDA_1V8 on BOTTOM: 108.05,80.51 108.05,83.59 110.59,83.59 110.62,83.57 110.62,81.38 109.74,80.51
VDDA_1V8 on L03_SIG1: 94.7,78.3 94.91,78.09 94.91,75.7 94.07,74.86 91.4,74.86 90.3,75.97 90.3,78.3
VDDA_1V8 on L06_PWR2: 89.46,54.75 75.06,69.15 75.06,78.5 71.02,82.54 71.02,84.9 71.4,85.28 76.4,85.28 79.91,81.78 79.91,75.88 81.02,74.77 81.02,70.98 89.61,62.39 92.53,62.39 96.17,66.03 104.37,66.03 109.73,71.39 133.86,71.39 133.86,67.58 131.95,65.67 112.43,65.67 101.51,54.75 ; 3 cut-outs
VDDA_1V8 on L08_SIG2: 89.42,74.09 89.42,77.53 90.18,78.29 94.75,78.29 95.28,77.77 95.28,74.74 94.19,73.65 89.86,73.65
VDDA_1V8_MCU on TOP: 106.43,72.53 110.45,72.53 110.45,69.86 107.44,69.86 107.19,69.61 106.43,69.61
VDDA_1V8_MCU on BOTTOM: 107.95,70.35 107.95,72.66 110.24,72.66 110.24,70.35
VDDA_1V8_MCU on L05_PWR1: 92.03,76.09 92.03,75.73 91.59,75.3 91.59,74.36 91.86,74.09 92.04,74.09 93.91,72.22 98.84,72.22 100.31,70.75 110.11,70.75 110.24,70.88 110.24,75.66 93.85,75.66 93.52,75.33 92.91,75.33 92.5,75.74 92.5,76.09 92.44,76.15 92.08,76.15 ; 1 cut-out
VDDA_1V8_SERDES on TOP: 88.27,58.94 88.27,65.42 92.33,65.42 92.33,58.94
VDDA_1V8_SERDES on L05_PWR1: 86.04,66.85 86.04,64.55 86.4,64.19 90.82,64.19 91.12,64.49 91.12,65.86 87.76,69.23 87.76,74.43 87.14,75.05 84.96,75.05 84.96,67.93
VDDA_1V8_USB0 on BOTTOM: 88.2,62.35 88.2,65.63 92.36,65.63 92.36,62.75 91.06,62.75 91.06,59.04 89.43,59.04 89.43,62.35
VDDA_1V8_USB0 on L06_PWR2: 85.89,73.93 87.63,73.93 87.88,73.67 87.88,69.23 90.68,66.44 92.58,66.44 92.96,66.05 92.96,63.64 92.33,63.01 89.71,63.01 85.27,67.44 85.27,73.32
VDDA_ADC on BOTTOM: 109.35,74.82 109.35,72.93 110.62,72.93 110.62,71.64 112.4,71.64 112.4,74.82
VDDA_CORE on TOP: 113.03,100.68 118.56,100.68 118.56,94.4 116.59,94.4 116.59,96.56 115.82,97.33 113.03,97.33
VDDA_CORE on BOTTOM: 116.2,72.53 116.2,70.1 118.69,70.1 118.69,72.53
VDDA_CORE on BOTTOM: 69.77,77.99 69.77,81.76 72.26,81.76 72.26,77.99
VDDA_CORE on L03_SIG1: 117.22,70.88 117.22,69.74 118.87,69.74 118.87,70.88
VDDA_CORE on L03_SIG1: 113.28,100.98 113.28,99.84 115.57,99.84 115.57,100.98
VDDA_CORE on L05_PWR1: 70.41,79.34 70.41,80.23 72.19,80.23 72.19,79.34
VDDA_CORE on L05_PWR1: 113.28,100.85 113.28,99.84 115.44,99.84 115.44,100.85
VDDA_PLL0 on BOTTOM: 72.62,82.29 75.39,82.29 76.4,81.27 79.35,81.27 79.35,82.69 78.36,83.68 72.62,83.68
VDDA_PLL1 on BOTTOM: 103.31,78.63 109.5,78.63 109.5,80.23 103.31,80.23
VDDA_PLL2 on TOP: 105.03,87.52 105.03,85.36 106.03,85.36 106.29,85.61 111.38,85.61 111.38,87.52
VDDAR_0P85_SERDES0 on TOP: 72.9,77.48 75.69,77.48 75.69,75.71 72.9,75.71
VDDAR_0P85_SERDES0 on BOTTOM: 71.5,74.69 71.5,77.36 72.75,77.36 72.75,79.19 74.14,79.19 74.14,74.69
VDDAR_0P85_SERDES0 on L05_PWR1: 73.37,78.85 87.54,78.85 88.59,77.8 88.59,74.93 88.03,74.93 87.17,75.78 86.74,75.78 86.64,75.68 86.54,75.68 85.85,76.37 82.07,76.37 81.64,75.94 77.34,75.94 77.27,76.01 75.79,76.01 74.6,74.82 72.77,74.82 72.39,75.2 72.39,77.87
VDDAR_0P85_USB0 on BOTTOM: 72.75,81.96 72.75,80.02 74.52,80.02 74.52,74.78 76.54,74.78 76.71,74.94 76.71,75.88 76.12,76.47 76.12,81.96
VDDAR_CORE on TOP: 150.15,115.2 150.15,111.75 145.14,111.75 145.14,116.47 148.88,116.47
VDDAR_CORE on TOP: 113.28,96.03 113.28,90.87 119.76,90.87 119.94,91.05 119.94,93.69 119.89,93.74 116.33,93.74 116.08,93.99 116.08,95.77 115.82,96.03
VDDAR_CORE on BOTTOM: 150.15,116.47 150.15,111.75 150.11,111.75 150.5,111.37 150.5,105.55 149.86,104.92 148.59,104.92 147.57,105.93 147.57,109.32 145.14,111.75 145.14,116.47
VDDAR_CORE on L03_SIG1: 123.83,116.47 150.75,116.47 150.75,112.54 147.7,109.49 142.77,109.49 130.84,97.55 120.9,97.55 116.97,93.61 116.97,91.12 112.65,91.12 112.65,96.6 123.83,107.77
VDDC_1V2 on TOP: 163.32,21.86 163.32,23.18 168.04,23.18 168.04,21.86
VDDR_CORE on TOP: 107.19,80.34 107.19,78.63 111.72,78.63 111.72,80.34
VDDR_CORE on TOP: 116.68,80.48 116.68,80.02 118.92,80.02 118.97,80.08 118.97,81.85 118.85,81.98 118.85,83.68 119.3,84.14 120.65,84.14 120.65,89.53 120.65,89.96 115.42,89.96 115.42,81.75
VDDR_CORE on L05_PWR1: 88.88,75.77 90.45,77.34 90.45,78.65 90.57,78.77 91.57,78.77 91.7,78.64 91.7,77.4 90.73,76.44 90.73,74.89 93.9,71.72 98.04,71.72 100.15,69.61 110.36,69.61 111,70.25 111,76.21 109.47,77.74 109.47,80.79 109.6,80.91 113.46,80.91 116.36,83.81 118.49,83.81 118.49,82.31 119,81.8 119,80.15 118.52,79.67 118.52,76.1 118.49,76.08 118.49,74.24 112.09,67.83 111.49,67.83 109.29,65.64 97.57,65.64 95.38,67.83 90.81,67.83 88.88,69.76
VDDR_VTT on TOP: 84.33,95.39 96.77,95.39 96.77,97.92 98.68,97.92 98.68,93.61 82.65,93.61 81.15,95.12 81.15,97.93 83.06,97.93 84.07,96.92 84.07,95.65
VDDR_VTT on BOTTOM: 77.22,118.63 77.22,117.11 77.72,117.11 77.72,117.74 78.61,118.63 78.61,120.65 80.21,122.25 80.21,123.89 77.34,123.89 77.34,118.76
VDDR_VTT on BOTTOM: 81.41,95.51 81.41,106.87 83.95,106.87 83.95,95.9 84.96,94.88 94.17,94.88 94.17,91.9 92.81,91.9 92.81,92.53 92.26,93.08 83.84,93.08
VDDR_VTT on L05_PWR1: 76.96,124.09 76.96,121.55 78.23,120.28 78.23,117.11 81.92,113.43 81.92,95.26 96.79,95.26 101.73,100.2 101.73,106.19 86.23,106.19 86.23,117.74 78.99,124.98 77.85,124.98
VDDSHV_SD_IO on BOTTOM: 90.93,74.55 91.95,74.55 91.95,73.91 92.58,73.91 92.58,73.15 91.06,73.15 91.06,69.47 91.82,68.71 91.82,67.69 93.09,67.69 93.22,67.56 93.22,66.17 90.17,66.17 90.17,73.41 90.93,74.17
VDDSHV_SD_IO on L05_PWR1: 36.64,28.21 43.69,28.21 47.75,32.27 47.75,56.15 58.43,66.83 94.73,66.83 95.63,65.93 95.63,62.24 92.49,59.09 58.77,59.09 54.1,54.43 54.1,31.26 47.5,24.65 36.84,24.65 36.4,25.09 36.4,27.97
(no net) on TOP: 34.04,8.02 34.03,8.02 1.02,8.02 1.02,47.69 1.02,47.69 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.87 1.02,60.87 1.02,61.94 1.02,61.94 1.02,66.84 1.02,66.84 1.02,132.98 176.78,132.98 176.78,111.39 176.78,111.39 176.78,106.82 176.78,106.82 176.78,8.02 50.31,8.02 50.31,8.02 ; 101 cut-outs
(no net) on BOTTOM: 34.04,8.02 34.03,8.02 1.02,8.02 1.02,47.69 1.02,47.69 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.87 1.02,60.87 1.02,61.94 1.02,61.94 1.02,66.84 1.02,66.84 1.02,132.98 176.78,132.98 176.78,111.39 176.78,111.39 176.78,106.82 176.78,106.82 176.78,8.02 50.31,8.02 50.31,8.02 ; 137 cut-outs
(no net) on L03_SIG1: 1.02,8.02 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,132.98 176.78,132.98 176.78,44.62 176.2,44.62 174.73,43.16 176.2,41.69 176.78,41.69 176.78,39.87 176.2,39.87 174.73,38.41 176.2,36.94 176.78,36.94 176.78,27.48 176.2,27.48 174.73,26.01 176.2,24.55 176.78,24.55 176.78,22.73 176.2,22.73 174.73,21.26 176.2,19.8 176.78,19.8 176.78,8.02 ; 129 cut-outs
(no net) on L08_SIG2: 34.04,8.02 34.03,8.02 1.02,8.02 1.02,47.69 1.02,47.69 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.87 1.02,60.87 1.02,61.94 1.02,61.94 1.02,66.84 1.02,66.84 1.02,132.98 176.78,132.98 176.78,111.39 176.78,111.39 176.78,106.82 176.78,106.82 176.78,8.02 50.31,8.02 50.31,8.02 ; 88 cut-outs
CPSW_EARTH on TOP, BOTTOM: 2.79,90.69 1.02,92.47 1.02,110.5 8.38,110.5 8.89,110 8.89,97.05 11.18,94.76 14.48,94.76 15.49,93.74 15.49,91.2 14.99,90.69
DDR_VPP on BOTTOM: 87.38,109.49 87.38,109.97 86.33,111.02 83.39,111.02 83.39,109.35 86.6,109.35 86.74,109.49
DDR_VREFCA on BOTTOM: 78.03,115.58 78.03,112.59 79.37,112.59 79.37,115.58
FT4232_USB_VBUS on TOP: 170.88,41.92 170.88,46.24 172.28,46.24 172.28,41.92
FT4232_USB_VBUS on BOTTOM: 164.59,39.13 164.59,45.61 165.74,46.75 171.83,46.75 172.34,46.24 172.34,42.46 168.63,38.75 164.97,38.75
MAIN on TOP: 168.69,122.44 168.69,113.58 160.42,113.58 160.42,122.44
PRG_EARTH on L03_SIG1: 3.3,63.39 1.02,65.67 1.02,87.26 24.38,87.26 27.3,84.34 27.3,81.68 26.42,80.79 9.4,80.79 8.13,79.52 8.13,71.26 10.03,69.36 23.11,69.36 24.51,67.96 24.51,65.55 22.35,63.39
SHIELD on TOP: 170.81,112.92 170.81,123.71 176.59,123.71 176.59,112.92
SHIELD on BOTTOM: 167.23,113.29 167.23,123.71 176.75,123.71 176.75,113.29
SOC_DVDD1V8 on TOP: 106.23,74.82 109.44,74.82 109.44,73.04 106.23,73.04
SOC_DVDD1V8 on TOP, BOTTOM: 131.1,112.03 131.1,107.31 126.09,107.31 126.09,112.03
SOC_DVDD1V8 on L03_SIG1: 89.53,73.29 89.53,76.09 89.66,76.21 96.52,76.21 96.65,76.09 96.65,73.55 95.5,72.4 90.42,72.4
SOC_DVDD1V8 on L06_PWR2: 125.98,111.35 125.98,105.24 138.81,92.42 138.81,82.75 132.92,76.86 109.3,76.86 104.31,71.87 94.23,71.87 93.31,72.79 93.31,73.95 92.44,74.83 89.72,74.83 89.51,74.62 89.51,70.76 92.39,67.88 105.45,67.88 109,71.42 134.21,71.42 146.25,83.46 146.25,90.82 131.25,105.82 131.25,110.02 129.92,111.35
SOC_DVDD3V3 on TOP: 137.82,92.98 137.82,88.89 132.88,88.89 132.88,92.98
SOC_DVDD3V3 on BOTTOM: 102.83,73.27 105.53,73.27 105.53,74.86 102.83,74.86
SOC_DVDD3V3 on BOTTOM: 137.82,92.98 137.82,88.89 132.88,88.89 132.88,92.98
SOC_DVDD3V3 on L06_PWR2: 86.61,81.8 90.81,81.8 90.81,79.64 91.19,79.26 93.6,79.26 94.49,80.15 95.12,80.15 96.02,79.26 96.02,77.72 96.87,76.87 99.43,76.87 103.78,81.21 124.55,81.21 132.5,89.16 132.5,92.89 136.86,92.89 137.92,91.84 137.92,87.01 128.63,77.72 108.95,77.72 105.77,74.55 105.77,74.5 104.38,73.11 99.22,73.11 98.45,73.88 93.98,73.88 92.53,75.33 89.54,75.33 88.9,74.68 88.9,72.79 88.14,72.79 88.02,72.9 88.02,73.83 87.69,74.16 86.76,74.16 86.11,74.82 86.11,81.29
USB0_VBUS on TOP: 24.63,51.45 14.73,51.45 9.47,46.19 6.07,46.19 5.16,47.11 5.16,53.3 9.52,53.3 10.97,54.75 24.63,54.75
USB1_SHIELD on TOP: 1.02,49.04 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.85,57.18 2.7,57.5 1.02,57.5 1.02,61.53 5.11,61.53 5.61,61.03 5.61,56.58 5.38,56.35 5.38,49.04
USB1_SHIELD on L03_SIG1: 1.02,49.37 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,59.15 5.51,59.15 5.51,49.37
VMAIN on TOP: 148.72,88.41 148.72,93.34 149.63,93.34 151.57,91.4 166.48,91.4 166.48,99.99 173.39,99.99 173.39,88.49 173.31,88.41
VMAIN on TOP: 163.85,78.7 167.35,78.7 167.35,73.73 156.67,73.73 156.67,78.2 160.09,78.2 160.09,84.09 163.85,84.09
VMAIN on BOTTOM: 57.91,22.37 57.91,23.64 57.44,24.11 57.18,24.11 56.77,24.53 56.77,27.59 58.29,27.59 58.29,22.49 58.17,22.37
VMAIN on BOTTOM: 6.99,38.88 11.43,38.88 11.68,38.62 11.68,26.94 11.43,26.68 6.35,26.68 6.35,38.24
VMAIN on L03_SIG1: 151.64,51.96 151.64,79.64 158.75,86.76 170.05,86.76 172.21,84.6 172.21,81.04 173.35,79.9 173.35,49.8 171.83,48.27 155.32,48.27
VMAIN on L06_PWR2: 164.85,97.41 176.78,97.41 176.78,9.16 9.02,9.16 1.52,16.66 1.52,39.11 14.37,39.11 14.37,26.72 22.34,26.72 30.38,18.68 49.15,18.68 51.82,21.35 51.82,26.58 53.7,28.46 63.37,28.46 63.37,21.39 66.71,18.05 147.07,18.05 164.85,35.83
VPP_1V8 on BOTTOM: 138.81,106.19 138.81,102.38 141.35,102.38 142.37,103.39 142.37,106.19
VPP_DDR_2V5 on BOTTOM: 82.85,108.47 82.85,111.15 80.69,111.15 80.69,108.47
VPP_DDR_2V5 on BOTTOM: 90.42,128.09 91.82,128.09 91.82,125.36 92.53,124.66 92.53,123.01 90.42,123.01
XDS_SHIELD on TOP: 172.85,18.68 172.85,21.99 174.75,21.99 174.75,25.29 174.62,25.41 171.04,25.41 171.04,29.22 177.46,29.22 177.46,18.68
XDS_USB_VBUS on TOP: 167.26,11.78 167.26,13.81 164.2,13.81 164.2,12.86 165.28,11.78
XDS_USB_VBUS on L03_SIG1: 142.62,33.42 142.62,30.24 144.02,28.84 161.42,28.84 164.19,26.07 164.19,12.48 166.12,10.56 171.96,10.56 173.1,11.7 173.1,27.57 166.37,34.3 143.51,34.3
N17786037 on TOP: 32.69,115.33 32.69,121.27 39.75,121.27 39.75,118.51 33.53,118.51 33.02,118 33.02,115.33 33.02,115.33
N17839730 on TOP: 5.89,45.81 5.89,41.32 14.33,41.32 14.33,45.81
N18546005 on TOP: 161.13,110.56 171.08,110.56 171.08,100.58 161.13,100.58
N18968753 on TOP: 33.96,52.59 28.27,52.59 28.02,52.85 28.02,54.88 28.14,55.01 33.96,55.01
N19753729 on TOP: 167.58,82.27 171.13,82.27 171.13,65.29 167.77,65.29 167.77,69.83 166.33,71.26 166.33,76.3 167.58,76.3
N19753760 on TOP: 176.76,78.55 176.76,69.64 173.64,69.64 173.64,78.55
N19754201 on TOP: 151.92,64.04 151.92,65.75 150.37,67.31 150.37,71.37 151.92,72.93 151.92,82.13 156.03,82.13 156.03,64.04
N19754522 on TOP: 140.13,76.02 146.11,76.02 147.74,74.4 147.74,64.73 140.13,64.73
N26004036 on TOP: 149.95,93.53 151.71,91.76 157.46,91.76 157.46,94.49 149.9,94.49 149.9,93.53
N26016842 on BOTTOM: 57.77,21.1 58.29,21.1 58.29,13.73 56.36,13.73 56.36,18.25 57.77,19.66
N26733205 on TOP: 19.38,61.23 19.38,55.29 12.32,55.29 12.32,59.28 12.34,59.3 16.76,59.3 17.77,58.3 18.78,58.3 19.05,58.56 19.05,61.23 19.05,61.23
N26735457 on TOP: 98.81,119.29 92.96,119.29 92.96,126.35 95.89,126.35 95.89,119.87 96.14,119.62 98.8,119.62 98.81,119.62
N26735496 on BOTTOM: 134.22,122.17 134.22,118.76 140.76,118.76 140.76,122.17
N26736579 on TOP: 124.36,73.08 124.36,76.74 130.71,76.74 130.71,73.08

Small or netless copper shapes (teardrops, artwork): 1507 on TOP, 1297 on BOTTOM, 467 on L03_SIG1, 11 on L05_PWR1, 7 on L06_PWR2, 407 on L08_SIG2

## Text on the board
Ref Des/Assembly Bottom: A | PROC101E2 ASSEMBLY BOTTOM REV E2
Ref Des/Silkscreen Bottom: PCIE RST SEL | A | PCIE PRSNT SEL | FOR EVALUATION ONLY; | NOT FCC APPROVED FOR RESALE
User.Comments: PROC101E2 | 17 | OF | SHEET | DESCRIPTION: | DATE: 10/08/20 | REV: E2 | AM64x EVM  BOARD | BOARD NAME: | SCALE: 1 | TEXAS INSTRUMENTS
Ref Des/Assembly Top: PROC101E2 ASSEMBLY TOP REV E2
Ref Des/Silkscreen Top: FSI | CPSW PHY | MCAN1 | MCAN0 | HSE | BOOTMODE 0-7 | VDD CORE | GND | JTAG MUX SEL | BOOTMODE 8-15 | I2C0 | MCU PORz | ADC | VDDR CORE | MCU RST | SOC WARM RST | I2C1 | MCU RSTSTATz | 12V IN | OFF | ON | UART | JTAG | A | ICSSG PHY | LATCH IN1 | SYNC OUT2 | LATCH IN0 | SYNC OUT0 | SOC/MCU GPIO | MCU WARM RST | SOC POR RST | RSTSTATz | PORz OUT | SYNC1 OUT | SAFETY | ON/OFF SWITCH | DISPLAY | PCIE | ASSY# | SL# | TMDS64GPEVM | PROC101E2 | AM64x EVM | USB2.0
PAGE_OUTLINE: LAYOUT BY | REVIEWED BY | APPROVED BY | SIGNATURES | AMB | UD | ZA | DATE | 100920 | SCALE: | SIZE | D | NONE | TEXAS INSTRUMENTS | AM64x  EVM  BOARD | SHEET 1 OF 17 | PROC101E2 | Rev | E2
DIMENSION: 18. | 16. | 17. | FOR STACKUP DETAIL PROC101_STACKUP.PDF SHALL BE REFERRED. | ENSURE THAT UL REGISTERED E-FILE NUMBER IS ON THE PCB SILKSCREEN. | VIA ON PAD SHALL BE RESIN FILLED AND CAP-PLATED. | DETAIL-A
User.41: 03 | 04 | 01 | 02 | STRIPLINE | MICROSTRIP | EDGE COUPLED STRIPLINE | EDGE COUPLED MICROSTRIP | L3,L8 | L1,L10 | 3.7 | 4.2 | 5.8 | 9.05 | 3.6 | 6 | 4.4 | NA | 90 | 40 | 50 | L2/L4,L7/L9 | L2,L9
User.45: FIGURE | SIZE | 8.0 | 28.0 | 36.0 | 40.0 | 44.0 | 62.0 | 34.0 | 50.0 | 64.0 | 66.0 | 92.0 | 108.0 | 124.0 | 128.0 | 52.0x24.0 | 52.0x26.0 | 64.0x32.0 | 90.0x40.0 | 98.0x40.0 | 118.0x40.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | +1.0/-1.0 | PLATED | NON-PLATED | QTY | 3036 | 64 | 40 | 29 | 101 | 18 | 6 | 2 | 1 | 4 | 13 | 6 - Provide serial numbers to the assembled boards for identification. | 7 - The assembled board are wrapped in ESD Covers(individual) and packed securely before shipment. | ASSEMBLY NOTES:- | 1 - All MSL components should be baked as per JEDEC standard. | 2 - PCB should be baked at 120 degree for 8 hours. | 3 - Board assembly must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified. | 4 - These assemblies are ESD sensitive, ESD precautions shall be observed. | 5 - These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable. | PROC101 E2 ASSEMBLY TOP | PROC101 E2 ASSEMBLY BOTTOM
