# Allegro board PROC101E2_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_I2C0_SCL_RC: length 7.2
  TOP w0.147: U23.A18 99.84,71.5 100.36,70.98 100.36,70.01 100.85,69.52 100.85,69.04 v1(101.94,67.95)
  BOTTOM w0.147: R598.2 C492.1 v1(101.94,67.95)
SOC_I2C0_SDA: length 126.4
  TOP w0.147: v1(109.47,66.69) 109.8,66.37 112.59,66.37 115.98,69.76 115.98,79.99 113.08,82.9 113.08,88.74 111.89,89.93 111.89,112.56 115.59,116.26 115.59,120.24 113.29,122.54 109.17,122.54 108.22,123.49 108.22,123.56 J5.2 104.77,121.77 U7.5 v1(105.96,120.18) ; J2.E2 v1(73.28,132.35)
  L03_SIG1 w0.091: J5.2 101.98,118.99 94.07,118.99 88.68,124.38 85.76,124.38 83.31,126.83 79.83,126.83 77.28,129.37 77.28,130.5 75.95,131.84 73.79,131.84 v1(73.28,132.35)
  BOTTOM w0.147: R354.2 v1(109.47,66.69) 107.53,66.69 107.29,66.45 R599.1 ; U7.5 v1(105.96,120.18)
SOC_I2C0_SDA_RC: length 11.3
  TOP w0.147: v1(101.87,68.74) 101.29,69.31 101.29,69.46 100.65,70.1 100.65,71.1 99.85,71.9 98.66,71.9 U23.B18
  BOTTOM w0.147: v1(101.87,68.74) 103.2,68.74 103.38,68.56 104.44,68.56 104.76,68.24 104.76,68.03 105.35,67.43 C493.1 R599.2
SOC_I2C1_SCL: length 481.9
  TOP w0.147: U16.5 135.85,102.42 v1(135.76,102.5) ; v1(125.6,103.52) 125.6,104.56 U14.5 ; U11.2 147.57,107.72 147.83,107.98 147.83,108.85 147.46,109.22 U11.5 144.54,109.22 v1(144.53,109.23) ; v1(71.5,100.81) 71.18,100.49 71.18,93.02 71.4,92.8 U18.1 ; U6.5 152.17,118.85 152.25,118.76 v1(152.78,118.76) ; U28.1 139.56,70.1 139.06,69.61 137.79,69.61 137.54,69.86 v1(137.54,70.75) 137.56,70.77 U28.5 ; U29.1 123.38,68.51 123.57,68.7 TP25.1 ; U29.1 123.38,66.75 123.19,66.56 120.8,66.56 120.43,66.93 114.26,66.93 113.03,65.7 104.87,65.7 103.76,66.82 102.36,66.82 100.57,68.61 100.57,69.4 100.08,69.89 100.08,70.86 99.82,71.12 99.47,71.12 99.46,71.1 97.86,71.1 U23.C18 ; U29.1 v1(124.08,67.58) ; U1.5 v1(85.36,127.54) ; v1(44.2,53.23) 44.32,53.35 U34.15 ; v1(59.9,32.65) 59.32,32.07 58.78,32.07 57.46,30.75 53.48,30.75 51.44,28.71 51.44,21.22 49.28,19.06 37.7,19.06 30,26.77 15.79,26.77 13.78,28.78 J27.B5 ; U51.7 v1(66.02,31.47)
  TOP w0.254: R13.1 v1(129.29,119.14)
  TOP w0.305: v1(138.4,103.65) 138.41,103.64 U16.1
  L03_SIG1 w0.091: v1(137.54,70.75) 134.21,67.42 126.71,67.42 126.4,67.1 124.56,67.1 v1(124.08,67.58) ; v1(85.36,127.54) 85.36,126.85 86.09,126.13 90.93,126.13 92.65,124.41 92.65,121.83 95.04,119.44 101.26,119.44 103.66,121.83 103.66,125.39 104.04,125.77 115.02,125.77 120.4,120.4 128.03,120.4 v1(129.29,119.14) 130.45,117.97 151.99,117.97 v1(152.78,118.76) 153.77,117.77 153.77,105.83 152.76,104.82 148.18,104.82 147.8,105.2 147.8,108.57 147.14,109.23 v1(144.53,109.23) 144.15,109.23 138.83,103.91 138.67,103.91 v1(138.4,103.65) ; J27.B5 13.78,30.49 13.71,30.42 13.71,29.88 13.74,29.85 13.74,23.16 10.41,19.83 10.17,19.83 v1(8.49,18.14) ; v1(66.02,31.47) 64.84,32.65 v1(59.9,32.65) 59.51,33.04 59.51,39.93 57.47,41.97 57.47,44.89 50.59,51.77 45.65,51.77 v1(44.2,53.23) 44.2,54.12 49.66,59.58 49.66,69.48 47.62,71.52 47.62,76.72 49.66,78.75 49.66,88.79 v1(50.16,89.3)
  L08_SIG2 w0.091: v1(137.54,70.75) 138.36,71.58 138.36,98.37 139.45,99.46 139.45,102.12 138.4,103.16 v1(138.4,103.65) 136.91,103.65 v1(135.76,102.5) 135,101.74 128.02,101.74 126.24,103.52 v1(125.6,103.52) ; v1(85.36,127.54) 83.08,125.26 81.69,125.26 80.9,124.47 75.24,124.47 71.12,120.35 71.12,106.06 70.66,105.6 70.66,101.65 v1(71.5,100.81)
  BOTTOM w0.147: v1(71.5,100.81) 72.16,100.81 73.3,99.67 73.3,93.5 70.23,90.42 59.56,90.42 57.4,88.27 51.2,88.27 v1(50.16,89.3) ; v1(8.49,18.14) 8.49,17.69 8.09,17.29 6.29,17.29 5.76,17.81 J36.5 ; v1(135.76,102.5) 135.51,102.25 R265.2 ; v1(59.9,32.65) 59.57,32.97 59.5,32.97 59.44,33.03 58.67,33.03 58.55,32.91 U91.29 ; v1(124.08,67.58) 124.62,67.58 124.79,67.41 R353.2
SOC_I2C1_SDA: length 473.8
  TOP w0.147: U6.4 151.12,119.89 151.26,120.03 152.4,120.03 v1(152.78,119.65) ; v1(58.8,32.53) 53.59,32.53 51.05,29.99 51.05,21.99 48.77,19.7 39.1,19.7 31.62,27.18 17.05,27.18 J27.B6 ; v1(66.02,32.48) 66.67,31.83 U51.6 ; v1(146.68,108.72) U11.4 144.47,108.72 144.32,108.57 144.32,107.37 144.47,107.22 U11.1 ; U28.4 138.06,70.57 138.05,70.57 v1(138.05,70.12) 138.94,70.12 139.06,70.24 U28.2 ; v1(72.16,100.15) 72.16,96.85 72.01,96.7 U18.6 ; v1(126.11,102.88) 126.11,103.34 126.12,103.34 U14.4 ; v1(136.91,101.23) 136.91,101.24 U16.4 ; U23.B19 98.37,70.59 98.54,70.59 98.83,70.3 99.26,70.3 100.28,69.28 100.28,68.39 103.26,65.41 113.16,65.41 114.38,66.64 120.31,66.64 120.77,66.18 123.06,66.18 123.38,65.87 U29.6 v1(124.08,64.78) 124.43,64.78 124.44,64.78 TP27.1 ; U1.2 86.86,127.13 86.61,126.89 85.98,126.89 v1(85.85,127.01) 85.85,127.47 85.86,127.47 U1.4 ; U34.2 v1(44.32,50.56)
  TOP w0.254: R12.1 v1(131.7,119.27)
  L03_SIG1 w0.091: v1(66.02,32.48) 66.46,32.04 66.46,31.28 66.2,31.03 65.84,31.03 65.23,31.64 59.69,31.64 v1(58.8,32.53) 59.29,33.01 59.29,39.76 57.15,41.9 57.15,42.32 52.22,47.24 52.22,47.78 50.21,49.79 45.09,49.79 v1(44.32,50.56) 44.32,51.32 43.74,51.91 43.74,53.97 49.44,59.67 49.44,69.39 47.4,71.42 47.4,76.81 49.4,78.81 49.4,89.39 v1(49.94,89.93) ; v1(85.85,127.01) 86.52,126.35 91.02,126.35 92.87,124.5 92.87,121.92 95.13,119.66 101.17,119.66 103.44,121.92 103.44,125.47 103.96,126 115.13,126 120.48,120.65 130.32,120.65 v1(131.7,119.27) 132.54,118.43 151.56,118.43 v1(152.78,119.65) 153.97,118.46 153.97,105.63 152.88,104.54 147.78,104.54 146.41,105.91 146.41,108.45 v1(146.68,108.72) 143.95,108.72 138.84,103.61 138.84,102.66 138.43,102.25 137.92,102.25 v1(136.91,101.23) ; v1(9.51,18.14) 14.78,23.41 J27.B6 ; v1(138.05,70.12) 137.29,69.36 136.46,69.36 131.88,64.78 v1(124.08,64.78)
  L08_SIG2 w0.091: v1(72.16,100.15) 72.16,101.51 72.39,101.74 72.39,120.28 76.4,124.29 80.98,124.29 81.73,125.04 83.88,125.04 v1(85.85,127.01) ; v1(138.05,70.12) 137.54,70.12 136.91,70.75 136.91,81.56 136.02,82.44 136.02,85.61 138.14,87.74 138.14,99.63 136.91,100.86 v1(136.91,101.23) 136.38,101.23 135.49,100.34 128.65,100.34 v1(126.11,102.88)
  BOTTOM w0.147: v1(124.08,64.78) 124.62,64.78 124.79,64.95 R357.2 ; v1(9.51,18.14) 8.33,16.97 6.19,16.97 5.84,17.31 J36.4 ; v1(49.94,89.93) 50.28,89.93 51.56,88.65 57.28,88.65 59.44,90.81 69.98,90.81 72,92.83 72,96.69 72.14,96.83 72.14,99.67 72.16,99.7 v1(72.16,100.15) ; v1(136.91,101.23) 136.46,101.23 136.2,100.98 R270.2 ; v1(58.8,32.53) 58.69,32.41 U91.30
SOC_I2C1_TA_SCL: length 19.5
  TOP w0.147: v1(65.91,15.13) 67.56,16.78 67.56,21.73 68.33,22.49 68.33,26.81 67.44,27.7 66.45,27.7 v1(65.68,26.94) 66.02,26.6 U51.2
  BOTTOM w0.147: R495.2 v1(65.68,26.94) ; J38.36 v1(65.91,15.13)
SOC_I2C1_TA_SDA: length 17.4
  TOP w0.147: v1(64.91,15.13) 65.66,15.88 65.66,20.33 68.03,22.71 68.03,26.56 67.65,26.94 v1(67.01,26.94) 66.67,26.6 U51.3
  BOTTOM w0.147: R494.2 v1(67.01,26.94) ; J38.38 v1(64.91,15.13)
SOC_MAIN_UART0_CTS_3V3: length 55.7
  TOP w0.147: v1(102.79,71.87) 102.23,72.43 101.29,72.43 100.22,73.5 98.66,73.5 U23.B16
  L03_SIG1 w0.091: v1(137.03,52.97) 132.78,52.97 131.9,53.86 110.45,53.86 108.84,55.47 108.84,58.73 107.52,60.04 107.52,64.83 104.66,67.7 104.66,71.25 103.61,72.3 103.22,72.3 v1(102.79,71.87)
  BOTTOM w0.147: U84.9 136.74,52.56 137.03,52.85 v1(137.03,52.97)
SOC_MAIN_UART0_RTS_3V3: length 53
  TOP w0.147: v1(101.78,71.85) 101.27,71.85 100.02,73.1 U23.A16
  L03_SIG1 w0.091: v1(135.64,53.96) 135.21,53.54 132.53,53.54 131.99,54.08 110.54,54.08 109.06,55.57 109.06,58.77 107.71,60.12 107.71,64.91 104.84,67.77 104.84,71.32 104.84,71.32 103.68,72.48 103.58,72.48 103.58,72.48 102.41,72.48 v1(101.78,71.85)
  BOTTOM w0.147: U84.7 135.58,53.91 v1(135.64,53.96)
SOC_MAIN_UART0_RX_3V3: length 62.3
  TOP w0.147: U23.D15 v1(97.06,73.5)
  L03_SIG1 w0.091: v1(97.06,73.5) 96.66,73.9 96.66,76.29 97.22,76.85 102.36,76.85 103.47,75.74 112.16,75.74 115.22,72.68 115.22,67.08 116.72,65.58 116.72,60.62 118.42,58.92 129.81,58.92 131.69,57.04 135.62,57.04 v1(137.02,55.64)
  BOTTOM w0.147: v1(137.02,55.64) 137.02,53.65 136.53,53.16 U84.8
SOC_MAIN_UART0_TX_3V3: length 51.9
  TOP w0.147: U23.C16 v1(97.86,72.7)
  L03_SIG1 w0.091: v1(134.87,53.99) 132.39,53.99 132.08,54.3 112.46,54.3 110.04,56.73 110.04,58.35 107.89,60.5 107.89,65.02 105.79,67.12 105.79,70.63 103.76,72.66 103.66,72.66 98.33,72.66 98.3,72.7 v1(97.86,72.7)
  BOTTOM w0.147: U84.6 135.18,53.68 v1(134.87,53.99)
SOC_MAIN_UART1_RX_3V3: length 80.4
  TOP w0.147: U23.E15 v1(96.26,73.5)
  L03_SIG1 w0.091: v1(109.19,60.04) 109.52,60.37 109.85,60.37 112.72,57.5 112.72,56.47 114.44,54.74 127.09,54.74 128.65,56.3 134.72,56.3 137.89,53.13 137.89,50.92 138.02,50.79 138.59,50.22 138.59,48.3 148.9,37.99 v1(151,37.99)
  L08_SIG2 w0.091: v1(109.19,60.04) 109.19,60.49 107.54,62.15 107.54,68.53 104.93,71.13 100.84,71.13 98.07,73.91 96.66,73.91 v1(96.26,73.5)
  BOTTOM w0.147: U89.8 151.8,38.29 151.5,37.99 v1(151,37.99)
SOC_MAIN_UART1_TX_3V3: length 82.5
  TOP w0.147: U23.E14 v1(96.26,74.3)
  L03_SIG1 w0.091: v1(152.4,37.23) 149.35,37.23 138.37,48.21 138.37,50.12 137.93,50.57 137.67,50.82 137.67,52.97 134.56,56.08 128.74,56.08 127.18,54.52 114.35,54.52 112.49,56.38 112.49,56.91 109.99,59.41 109.99,59.42 v1(109.73,59.68)
  L08_SIG2 w0.091: v1(109.73,59.68) 109.73,60.52 107.76,62.49 107.76,68.57 104.99,71.34 100.92,71.34 98.76,73.5 98.76,74.11 98.16,74.7 96.66,74.7 v1(96.26,74.3)
  BOTTOM w0.147: v1(152.4,37.23) 152.66,37.48 152.66,38.18 152.6,38.24 U89.6
SOC_MAIN_UART3_RX_3V3: length 79.4
  TOP w0.147: U23.D16 v1(97.06,72.7)
  L03_SIG1 w0.091: v1(150.75,39.13) 148.46,39.13 145.23,42.36 145.23,50.24 141.73,53.74 137.92,53.74 134.91,56.75 128.47,56.75 126.91,55.19 114.63,55.19 113.16,56.66 113.16,57.58 108.07,62.66 108.07,65.1 105.97,67.2 105.97,70.71 103.81,72.87 98.6,72.87 98.36,73.1 97.46,73.1 v1(97.06,72.7)
  BOTTOM w0.147: v1(150.75,39.13) 151.04,39.42 U89.9
SOC_MAIN_UART3_TX_3V3: length 80.6
  TOP w0.147: U23.E16 v1(96.26,72.7)
  L03_SIG1 w0.091: v1(152.15,37.99) 151.71,38.42 148.78,38.42 138.81,48.39 138.81,50.31 138.11,51.01 138.11,53.23 134.81,56.52 128.56,56.52 127,54.97 114.54,54.97 112.94,56.57 112.94,57.54 109.68,60.79 108.92,60.79 v1(108.56,60.43)
  L08_SIG2 w0.091: v1(108.56,60.43) 107.31,61.67 107.31,68.49 104.9,70.91 100.46,70.91 98.27,73.1 96.66,73.1 v1(96.26,72.7)
  BOTTOM w0.147: U89.7 152.2,38.04 v1(152.15,37.99)
SOC_MMC0_CLK: length 21
  TOP w0.147: U23.G18 v1(94.66,71.1)
  L03_SIG1 w0.091: v1(104.39,55.77) 104.66,56.03 104.66,57.1 99.53,62.22 99.53,63.58 95.4,67.71 95.4,69.12 95.06,69.47 95.06,70.63 94.84,70.85 94.84,70.92 v1(94.66,71.1)
  BOTTOM w0.147: v1(104.39,55.77) 104.27,55.64 R404.2
SOC_MMC0_CMD: length 59.2
  TOP w0.147: v1(93.47,66.31) 93.47,66.72 92.74,67.46 92.74,68.54 92.66,68.62 U23.J21 ; U44.M5 117.62,35.17 v1(117.49,35.31)
  L03_SIG1 w0.091: v1(93.47,66.31) 93.05,65.88 93.05,65.12 93.3,64.87 93.92,64.87 96.1,62.69 96.1,62.13 102.21,56.03 102.21,50.84 107.44,45.61 108.68,45.61 108.76,45.53 108.76,44.8 108.84,44.72 108.96,44.72 109.04,44.8 109.04,45.53 109.12,45.61 109.23,45.61 109.31,45.53 109.31,44.8 109.39,44.72 109.51,44.72 109.59,44.8 109.59,45.53 109.67,45.61 109.78,45.61 109.86,45.53 109.86,44.8 109.94,44.72 110.06,44.72 110.14,44.8 110.14,45.53 110.22,45.61 111.36,45.61 111.44,45.53 111.44,44.77 111.53,44.69 111.64,44.69 111.72,44.77 111.72,45.53 111.8,45.61 111.91,45.61 111.99,45.53 111.99,44.77 112.07,44.69 112.19,44.69 112.27,44.77 112.27,45.53 112.35,45.61 112.82,45.61 113.84,44.59 113.84,43.32 113.28,42.76 113.28,37.48 115.46,35.31 v1(117.49,35.31)
  BOTTOM w0.147: v1(117.49,35.31) 117.13,34.95 R457.2
SOC_MMC0_DAT0: length 60.2
  TOP w0.147: U44.A3 116.62,40.9 116.34,41.18 116.34,41.53 v1(114.55,43.32) 115.18,43.95 115.18,44.47 115.65,44.95 R161.2 ; U23.K20 92.26,69.5 92.26,68.62 92.45,68.42 92.45,67.33 92.96,66.82 92.96,66.17 93.47,65.67 v1(93.47,65.29)
  L03_SIG1 w0.091: v1(93.47,65.29) 94.03,65.29 96.29,63.04 96.29,62.21 102.43,56.06 102.43,52.06 107.43,47.06 107.65,47.06 107.73,46.98 107.73,46.25 107.81,46.17 107.93,46.17 108.01,46.25 108.01,46.98 108.09,47.06 108.2,47.06 108.28,46.98 108.28,46.25 108.36,46.17 108.47,46.17 108.55,46.25 108.55,46.98 108.63,47.06 108.75,47.06 108.83,46.98 108.83,46.25 108.91,46.17 109.02,46.17 109.1,46.25 109.1,46.98 109.18,47.06 109.3,47.06 109.38,46.98 109.38,46.25 109.46,46.17 109.57,46.17 109.65,46.25 109.65,46.98 109.73,47.06 109.85,47.06 109.93,46.98 109.93,46.25 110.01,46.17 110.12,46.17 110.2,46.25 110.2,46.98 110.28,47.06 110.39,47.06 110.47,46.98 110.47,46.25 110.55,46.17 110.67,46.17 110.75,46.25 110.75,46.98 110.83,47.06 110.94,47.06 111.02,46.98 111.02,46.25 111.1,46.17 111.22,46.17 111.3,46.25 111.3,46.98 111.38,47.06 111.49,47.06 111.57,46.98 111.57,46.25 111.65,46.17 111.77,46.17 111.85,46.25 111.85,46.98 111.93,47.06 112.04,47.06 112.12,46.98 112.12,46.25 112.2,46.17 112.31,46.17 112.39,46.25 112.39,46.98 112.48,47.06 113.61,47.06 114.06,46.61 114.06,43.81 v1(114.55,43.32)
SOC_MMC0_DAT1: length 58.2
  TOP w0.147: R163.2 v1(117.98,44.33) 117.12,43.47 U44.A4 ; v1(93.47,67.32) 93.03,67.77 93.03,68.63 93.06,68.67 93.06,69.5 U23.J20
  L03_SIG1 w0.091: v1(93.47,67.32) 96.47,64.33 96.47,62.29 102.65,56.1 102.65,52.52 107.02,48.15 108.51,48.15 108.59,48.23 108.59,48.62 108.67,48.7 108.78,48.7 108.87,48.62 108.87,48.23 108.95,48.15 109.06,48.15 109.14,48.23 109.14,48.62 109.22,48.7 109.33,48.7 109.41,48.62 109.41,48.23 109.49,48.15 109.61,48.15 109.69,48.23 109.69,48.62 109.77,48.7 109.88,48.7 109.96,48.62 109.96,48.23 110.04,48.15 110.16,48.15 110.24,48.23 110.24,48.62 110.32,48.7 110.43,48.7 110.51,48.62 110.51,48.23 110.59,48.15 110.7,48.15 110.79,48.23 110.79,48.62 110.87,48.7 110.98,48.7 111.06,48.62 111.06,48.23 111.14,48.15 111.25,48.15 111.33,48.23 111.33,48.62 111.41,48.7 111.53,48.7 111.61,48.62 111.61,48.23 111.69,48.15 111.8,48.15 111.88,48.23 111.88,48.62 111.96,48.7 112.08,48.7 112.16,48.62 112.16,48.23 112.24,48.15 112.35,48.15 112.43,48.23 112.43,48.62 112.51,48.7 112.63,48.7 112.71,48.62 112.71,48.23 112.79,48.15 112.9,48.15 112.98,48.23 112.98,48.62 113.06,48.7 113.17,48.7 113.25,48.62 113.25,48.23 113.33,48.15 114.16,48.15 114.38,47.93 114.5,47.93 114.88,48.31 115,48.31 115.08,48.23 115.08,48.12 114.69,47.73 114.69,47.62 114.77,47.54 114.88,47.54 115.27,47.92 115.38,47.92 115.46,47.84 115.46,47.73 115.08,47.34 115.08,47.23 115.16,47.15 115.27,47.15 115.66,47.53 115.77,47.53 115.85,47.45 115.85,47.34 115.47,46.96 115.47,46.84 115.55,46.76 115.66,46.76 116.05,47.15 116.16,47.15 116.24,47.07 116.24,46.95 115.85,46.57 115.85,46.45 v1(117.98,44.33)
SOC_MMC0_DAT2: length 59.7
  TOP w0.147: U44.A5 117.62,41.03 119.13,42.53 v1(119.13,43.5) 119.75,44.13 119.75,44.47 120.23,44.95 R165.2 ; U23.J18 v1(93.06,71.1)
  L03_SIG1 w0.091: v1(119.13,43.5) 118.42,44.22 118.42,45.63 115.1,48.95 112.95,48.95 112.87,49.03 112.87,49.56 112.79,49.64 112.68,49.64 112.6,49.56 112.6,49.03 112.52,48.95 112.4,48.95 112.32,49.03 112.32,49.56 112.24,49.64 112.13,49.64 112.05,49.56 112.05,49.03 111.97,48.95 111.85,48.95 111.77,49.03 111.77,49.56 111.69,49.64 111.58,49.64 111.5,49.56 111.5,49.03 111.42,48.95 111.31,48.95 111.23,49.03 111.23,49.56 111.15,49.64 111.03,49.64 110.95,49.56 110.95,49.03 110.87,48.95 110.76,48.95 110.68,49.03 110.68,49.56 110.6,49.64 110.48,49.64 110.4,49.56 110.4,49.03 110.32,48.95 110.21,48.95 110.13,49.03 110.13,49.56 110.05,49.64 109.93,49.64 109.85,49.56 109.85,49.03 109.77,48.95 109.66,48.95 109.58,49.03 109.58,49.56 109.5,49.64 109.39,49.64 109.31,49.56 109.31,49.03 109.22,48.95 109.11,48.95 109.03,49.03 109.03,49.56 108.95,49.64 108.84,49.64 108.76,49.56 108.76,49.03 108.68,48.95 108.32,48.95 107.54,49.73 105.76,49.73 102.88,52.61 102.88,56.19 96.7,62.37 96.7,64.91 94.34,67.27 94.34,68.24 92.66,69.91 92.66,70.71 v1(93.06,71.1)
SOC_MMC0_DAT3: length 58.5
  TOP w0.094: 115.87,40.6 115.87,40.1 U44.B2
  TOP w0.147: R159.2 v1(113.41,44.33) 113.41,43.07 115.87,40.6 ; U23.J17 v1(93.06,71.9)
  L03_SIG1 w0.091: v1(113.41,44.33) 112.36,44.33 112.28,44.25 112.28,43.26 112.2,43.18 112.09,43.18 112,43.26 112,44.25 111.92,44.33 111.81,44.33 111.73,44.25 111.73,43.26 111.65,43.18 111.54,43.18 111.46,43.26 111.46,44.25 111.38,44.33 111.26,44.33 111.18,44.25 111.18,43.26 111.1,43.18 110.99,43.18 110.91,43.26 110.91,44.25 110.83,44.33 110.71,44.33 110.63,44.25 110.63,43.26 110.55,43.18 110.44,43.18 110.36,43.26 110.36,44.25 110.28,44.33 110.16,44.33 110.08,44.25 110.08,43.26 110,43.18 109.89,43.18 109.81,43.26 109.81,44.25 109.73,44.33 108.45,44.33 101.99,50.79 101.99,55.99 95.92,62.06 95.92,62.54 94.89,63.57 93.28,63.57 92.81,64.04 92.81,69.17 91.86,70.12 91.86,71.28 92.08,71.51 92.66,71.51 v1(93.06,71.9)
SOC_MMC0_DAT4: length 58.3
  TOP w0.094: 116.37,40.6 116.37,40.1 U44.B3
  TOP w0.147: 116.37,40.6 113.92,43.05 113.92,43.7 v1(114.55,44.33) R160.2 ; U23.H17 v1(93.86,71.9)
  L03_SIG1 w0.091: v1(93.86,71.9) 94.26,71.51 94.26,69.65 94.96,68.94 94.96,67.53 99.06,63.43 99.06,62.07 103.54,57.59 103.54,52.88 105.48,50.94 115.1,50.94 119.97,46.06 119.97,43.43 119.36,42.81 116.07,42.81 v1(114.55,44.33)
SOC_MMC0_DAT5: length 58.2
  TOP w0.094: 116.87,40.6 116.87,40.1 U44.B4
  TOP w0.147: 116.87,40.6 116.87,41.08 116.66,41.29 116.66,43.7 116.84,43.87 v1(116.84,44.33) R162.2 ; U23.H19 v1(93.86,70.3)
  L03_SIG1 w0.091: v1(116.84,44.33) 118.1,43.07 119.31,43.07 119.76,43.52 119.76,45.96 115.01,50.72 109.07,50.72 108.99,50.64 108.99,50.25 108.91,50.16 108.79,50.16 108.71,50.25 108.71,50.64 108.63,50.72 108.52,50.72 108.44,50.64 108.44,50.25 108.36,50.16 108.24,50.16 108.16,50.25 108.16,50.64 108.08,50.72 107.97,50.72 107.89,50.64 107.89,50.25 107.81,50.16 107.7,50.16 107.62,50.25 107.62,50.64 107.54,50.72 107.42,50.72 107.34,50.64 107.34,50.25 107.26,50.16 107.15,50.16 107.07,50.25 107.07,50.64 106.99,50.72 106.87,50.72 106.79,50.64 106.79,50.25 106.71,50.16 106.6,50.16 106.52,50.25 106.52,50.64 106.44,50.72 106.32,50.72 106.24,50.64 106.24,50.25 106.16,50.16 106.05,50.16 105.97,50.25 105.97,50.64 105.89,50.72 105.39,50.72 103.32,52.79 103.32,57.5 98.81,62.01 98.81,63.37 94.74,67.43 94.74,68.85 93.86,69.73 v1(93.86,70.3)
SOC_MMC0_DAT6: length 58.3
  TOP w0.094: U44.B5 117.37,40.1 117.37,40.6
  TOP w0.147: R164.2 v1(119.12,44.33) 118.58,43.78 118.58,42.47 117.37,41.26 117.37,40.6 ; U23.H18 v1(93.86,71.1)
  L03_SIG1 w0.091: v1(119.12,44.33) 119.12,45.95 115.14,49.93 113.99,49.93 113.91,50.01 113.91,50.45 113.83,50.53 113.72,50.53 113.64,50.45 113.64,50.01 113.56,49.93 113.45,49.93 113.36,50.01 113.36,50.45 113.28,50.53 113.17,50.53 113.09,50.45 113.09,50.01 113.01,49.93 112.9,49.93 112.82,50.01 112.82,50.45 112.74,50.53 112.62,50.53 112.54,50.45 112.54,50.01 112.46,49.93 112.35,49.93 112.27,50.01 112.27,50.45 112.19,50.53 112.07,50.53 111.99,50.45 111.99,50.01 111.91,49.93 111.8,49.93 111.72,50.01 111.72,50.45 111.64,50.53 111.52,50.53 111.44,50.45 111.44,50.01 111.36,49.93 111.25,49.93 111.17,50.01 111.17,50.45 111.09,50.53 110.98,50.53 110.9,50.45 110.9,50.01 110.82,49.93 110.7,49.93 110.62,50.01 110.62,50.45 110.54,50.53 110.43,50.53 110.35,50.45 110.35,50.01 110.27,49.93 110.15,49.93 110.07,50.01 110.07,50.45 109.99,50.53 109.88,50.53 109.8,50.45 109.8,50.01 109.72,49.93 105.87,49.93 103.1,52.7 103.1,56.43 102.42,57.11 102.42,58.09 101.31,59.2 100.18,59.2 96.9,62.48 96.9,64.99 94.54,67.35 94.54,68.66 93.46,69.74 93.46,70.71 v1(93.86,71.1)
SOC_MMC0_DAT7: length 58.4
  TOP w0.094: 117.87,40.6 117.87,40.1 U44.B6
  TOP w0.147: 117.87,40.6 117.95,40.68 117.95,40.92 119.16,42.14 119.67,42.14 v1(121.77,44.24) 121.41,44.6 R166.2 ; U23.G17 v1(94.66,71.9)
  L03_SIG1 w0.091: v1(94.66,71.9) 95.06,71.5 95.06,70.94 95.29,70.71 95.62,70.71 95.86,70.47 95.86,70.15 95.86,70.14 95.86,67.56 99.76,63.67 99.76,62.31 104.88,57.19 104.88,55.28 108.56,51.6 116.85,51.6 117.32,51.13 117.58,51.13 117.73,50.98 117.73,50.86 117.54,50.67 117.54,50.56 117.62,50.48 117.74,50.48 117.92,50.67 118.04,50.67 118.12,50.59 118.12,50.47 117.93,50.29 117.93,50.17 118.01,50.09 118.12,50.09 118.31,50.28 118.43,50.28 118.51,50.2 118.51,50.09 118.32,49.9 118.32,49.78 118.4,49.7 118.51,49.7 118.7,49.89 118.81,49.89 118.89,49.81 118.89,49.7 118.71,49.51 118.71,49.4 118.79,49.32 118.9,49.32 119.09,49.5 119.2,49.5 119.28,49.42 119.28,49.31 119.09,49.12 119.09,49.01 119.17,48.93 119.29,48.93 119.48,49.12 119.59,49.12 119.67,49.04 119.67,48.92 119.48,48.73 119.48,48.62 119.56,48.54 119.68,48.54 119.86,48.73 119.98,48.73 120.06,48.65 120.06,48.53 119.87,48.35 119.87,48.23 119.95,48.15 120.06,48.15 120.25,48.34 120.37,48.34 120.45,48.26 120.45,48.15 120.26,47.96 120.26,47.84 120.34,47.76 120.45,47.76 120.64,47.95 120.75,47.95 120.83,47.87 120.83,47.76 120.65,47.57 120.65,47.46 120.73,47.38 120.84,47.38 121.03,47.56 121.14,47.56 122.3,46.4 122.3,44.77 v1(121.77,44.24)
SOC_MMC0_DS: length 54.5
  TOP w0.147: U23.G19 v1(94.66,70.3)
  L03_SIG1 w0.091: v1(113.75,37.95) 113.75,40.23 116.15,42.63 119.44,42.63 120.16,43.35 120.16,43.39 120.16,46.19 115.19,51.16 105.58,51.16 103.79,52.94 103.79,57.65 99.31,62.13 99.31,63.49 95.18,67.62 95.18,69.03 94.66,69.56 v1(94.66,70.3)
  BOTTOM w0.147: R446.1 v1(113.75,37.95)
SOC_OSC0: length 0.6
  TOP w0.147: U23.G13 v1(94.66,75.1)
SOC_OSPI_DQ0: length 46.4
  TOP w0.147: U23.M19 v1(89.86,70.3)
  L03_SIG1 w0.091: v1(100.35,36.94) 100.82,37.41 100.82,46.63 99.72,47.73 99.72,48.61 99.9,48.8 99.9,55.12 99.76,55.27 99.65,55.27 99.45,55.07 99.34,55.07 99.26,55.15 99.26,55.26 99.45,55.46 99.45,55.57 99.37,55.66 99.26,55.66 99.06,55.46 98.95,55.46 98.87,55.54 98.87,55.65 99.07,55.85 99.07,55.96 98.98,56.04 98.87,56.04 98.67,55.85 98.56,55.85 98.48,55.93 98.48,56.04 98.68,56.24 98.68,56.35 98.6,56.43 98.48,56.43 98.29,56.23 98.17,56.23 98.09,56.31 98.09,56.43 98.29,56.63 98.29,56.74 98.21,56.82 98.1,56.82 97.9,56.62 97.78,56.62 97.7,56.7 97.7,56.82 97.9,57.01 97.9,57.13 97.82,57.21 97.71,57.21 97.51,57.01 97.4,57.01 97.32,57.09 97.32,57.2 97.51,57.4 97.51,57.51 97.43,57.6 97.32,57.6 97.13,57.4 97.01,57.4 96.93,57.48 96.93,57.6 97.13,57.79 97.13,57.9 96.94,58.09 96.94,59.23 94.9,61.27 91.71,61.27 90.01,62.97 90.01,64.78 90.27,65.04 90.27,65.98 90.16,66.09 90.16,70.01 v1(89.86,70.3)
  BOTTOM w0.147: R440.2 v1(100.35,36.94)
SOC_OSPI_DQ1: length 46.9
  TOP w0.147: U23.M18 v1(89.86,71.1)
  L03_SIG1 w0.091: v1(96.01,40.78) 95.59,41.21 94.68,41.21 94.46,41.43 94.46,42.37 94.38,42.45 94.04,42.45 93.96,42.53 93.96,42.64 94.04,42.72 94.38,42.72 94.46,42.8 94.46,42.92 94.38,43 94.04,43 93.96,43.08 93.96,43.19 94.04,43.27 94.38,43.27 94.46,43.35 94.46,43.46 94.38,43.55 94.04,43.55 93.96,43.63 93.96,43.74 94.04,43.82 94.38,43.82 94.46,43.9 94.46,44.01 94.38,44.09 94.04,44.09 93.96,44.17 93.96,44.29 94.04,44.37 94.38,44.37 94.46,44.45 94.46,44.56 94.38,44.64 94.04,44.64 93.96,44.72 93.96,44.84 94.04,44.92 94.38,44.92 94.46,45 94.46,45.11 94.38,45.19 94.04,45.19 93.96,45.27 93.96,45.38 94.04,45.47 94.38,45.47 94.46,45.55 94.46,45.66 94.38,45.74 94.04,45.74 93.96,45.82 93.96,45.93 94.04,46.01 94.38,46.01 94.46,46.09 94.46,46.21 94.38,46.29 94.04,46.29 93.96,46.37 93.96,46.48 94.04,46.56 94.38,46.56 94.46,46.64 94.46,46.91 95.64,48.09 95.64,58.42 94.1,59.96 91.71,59.96 91.33,60.34 91.33,61.01 89.47,62.87 89.47,64.83 88.65,65.66 88.65,66.65 89.18,67.18 89.18,68.11 89.46,68.39 89.46,70.71 v1(89.86,71.1)
  BOTTOM w0.147: v1(96.01,40.78) 95.42,41.38 93.92,41.38 93.36,40.82 R433.2
SOC_OSPI_DQ2: length 47.5
  TOP w0.147: U23.M20 90.66,69.5 90.66,68.46 90.93,68.19 v1(90.93,67.07)
  L03_SIG1 w0.091: v1(105.66,44.46) 105.66,46.43 104.74,47.35 104.63,47.35 104.04,46.77 103.92,46.77 103.84,46.85 103.84,46.96 104.43,47.55 104.43,47.66 104.35,47.74 104.24,47.74 103.65,47.15 103.54,47.15 103.46,47.24 103.46,47.35 104.04,47.94 104.04,48.05 103.96,48.13 103.85,48.13 103.26,47.54 103.15,47.54 103.07,47.62 103.07,47.74 103.66,48.32 103.66,48.44 103.58,48.52 103.46,48.52 102.87,47.93 102.76,47.93 102.68,48.01 102.68,48.12 103.27,48.71 103.27,48.83 103.19,48.91 103.07,48.91 102.49,48.32 102.37,48.32 102.29,48.4 102.29,48.51 102.88,49.1 102.88,49.21 102.8,49.29 102.69,49.29 102.1,48.71 101.98,48.71 101.9,48.79 101.9,48.9 102.49,49.49 102.49,49.6 102.41,49.68 102.3,49.68 101.71,49.09 101.6,49.09 101.52,49.17 101.52,49.29 102.1,49.88 102.1,49.99 101.55,50.54 101.55,55.91 95.55,61.91 95.55,61.92 95.21,62.26 93.02,62.26 92.38,62.9 92.38,64.81 92.02,65.17 91.83,65.17 91.6,65.4 91.6,66.4 v1(90.93,67.07)
  BOTTOM w0.147: R423.2 v1(105.66,44.46)
SOC_OSPI_DQ3: length 47
  TOP w0.147: v1(91.17,65.79) 90.52,66.44 90.52,68.2 90.26,68.46 U23.M21
  L03_SIG1 w0.091: v1(91.17,65.79) 91.17,65.56 91.74,64.98 91.95,64.98 92.2,64.73 92.2,62.63 92.79,62.04 95.18,62.04 95.37,61.84 95.37,61.83 101.22,55.98 101.22,47.51 101.84,46.89 101.84,46.78 101.33,46.27 101.33,46.16 101.41,46.08 101.53,46.08 102.04,46.58 102.15,46.58 102.23,46.5 102.23,46.39 101.72,45.88 101.72,45.77 101.8,45.69 101.92,45.69 102.42,46.2 102.54,46.2 102.62,46.12 102.62,46 102.11,45.49 102.11,45.38 102.19,45.3 102.3,45.3 102.81,45.81 102.92,45.81 103,45.73 103,45.61 102.5,45.11 102.5,44.99 102.58,44.91 102.69,44.91 103.2,45.42 103.31,45.42 103.39,45.34 103.39,45.23 102.89,44.72 102.89,44.6 102.97,44.52 103.08,44.52 103.59,45.03 103.7,45.03 103.78,44.95 103.78,44.84 103.27,44.33 103.27,44.22 103.35,44.14 103.47,44.14 103.97,44.64 104.09,44.64 104.17,44.56 104.17,44.45 103.66,43.94 103.66,43.83 103.74,43.75 103.85,43.75 104.36,44.26 104.48,44.26 v1(105.66,43.07)
  BOTTOM w0.147: v1(105.66,43.07) 105.15,43.58 104.47,43.58 103.99,43.11 R425.2
SOC_OSPI_DQ4: length 48.3
  TOP w0.147: v1(88.32,67) 88.66,67.34 U23.P21
  L03_SIG1 w0.091: v1(88.32,67) 88.32,66.01 88.24,65.93 87.6,65.93 87.52,65.85 87.52,65.73 87.6,65.65 88.24,65.65 88.32,65.57 88.32,65.46 88.24,65.38 87.5,65.38 87.42,65.3 87.42,65.19 87.5,65.11 88.24,65.11 88.32,65.03 88.32,62.57 91.33,59.56 92.51,59.56 94.61,57.46 94.61,49.95 93.78,49.11 93.78,40.53 94.53,39.78 99.22,39.78 100.2,40.76 v1(100.2,42.05)
  BOTTOM w0.147: R432.2 103.99,41.63 103.44,41.08 101.18,41.08 v1(100.2,42.05)
SOC_OSPI_DQ5: length 46.9
  TOP w0.147: U23.P20 89.06,69.5 89.06,67.09 87.05,65.08 87.05,63.96 v1(87.37,63.64)
  L03_SIG1 w0.091: v1(99.08,36.94) 98.64,37.38 97.59,37.38 96.68,36.46 95.68,36.46 93.48,38.67 93.48,47.99 92.76,48.71 92.76,57.11 91.51,58.36 87.91,58.36 87.37,58.89 87.37,60.38 87.45,60.46 87.61,60.46 87.69,60.54 87.69,60.65 87.61,60.73 87.45,60.73 87.37,60.81 87.37,60.93 87.45,61.01 87.61,61.01 87.69,61.09 87.69,61.2 87.61,61.28 87.45,61.28 87.37,61.36 87.37,61.47 87.45,61.55 87.61,61.55 87.69,61.63 87.69,61.75 87.61,61.83 87.45,61.83 87.37,61.91 87.37,62.02 87.45,62.1 87.61,62.1 87.69,62.18 87.69,62.3 87.61,62.38 87.45,62.38 87.37,62.46 87.37,62.57 87.45,62.65 87.61,62.65 87.69,62.73 87.69,62.85 87.61,62.93 87.45,62.93 87.37,63.01 v1(87.37,63.64)
  BOTTOM w0.147: R441.2 v1(99.08,36.94)
SOC_OSPI_DQ6: length 47.7
  TOP w0.147: U23.N18 v1(89.06,71.1)
  L03_SIG1 w0.091: v1(97.81,36.94) 97.08,36.21 95.68,36.21 93.29,38.59 93.29,47.91 92.54,48.67 92.54,57.07 91.54,58.08 87.86,58.08 87.14,58.79 87.14,62.6 86.91,62.84 86.91,67.85 87.36,68.3 87.47,68.3 87.72,68.05 87.83,68.05 87.91,68.13 87.91,68.25 87.67,68.49 87.67,68.6 87.75,68.69 87.86,68.69 88.11,68.44 88.22,68.44 88.3,68.52 88.3,68.63 88.05,68.88 88.05,68.99 88.13,69.07 88.25,69.07 88.49,68.83 88.61,68.83 88.69,68.91 88.69,69.02 88.44,69.27 88.44,69.38 88.66,69.6 88.66,70.71 v1(89.06,71.1)
  BOTTOM w0.147: R442.2 v1(97.81,36.94)
SOC_OSPI_DQ7: length 48.6
  TOP w0.147: U23.M17 v1(89.86,71.9)
  L03_SIG1 w0.091: v1(89.86,71.9) 90.3,71.47 90.3,70.15 90.36,70.09 90.36,66.36 90.45,66.27 90.45,65.51 91.09,64.86 91.09,62.85 91.61,62.33 91.98,62.33 92.63,61.67 95.01,61.67 100.85,55.83 100.85,54.81 100.09,54.04 100.09,48.72 99.9,48.54 99.9,47.81 101.04,46.67 101.04,37.01 100.53,36.5 100.16,36.5 99.07,37.6 97.19,37.6 v1(96.54,36.94)
  BOTTOM w0.147: R443.2 v1(96.54,36.94)
SOC_POWER_MON_PORZ: length 65.5
  TOP w0.147: U41.1 v1(139.56,39.86)
  L08_SIG2 w0.091: v1(139.56,39.86) 139.56,40.64 140.46,41.54 140.46,65.67 136.65,69.48 136.65,81.29 130.05,87.9 v1(130.05,96.41)
  BOTTOM w0.147: v1(130.05,96.41) 129.9,96.26 R285.2 129.9,95.01 129.58,94.68 U76.4
SOC_SPI0_CLK: length 39.9
  TOP w0.147: U23.D13 v1(97.06,75.1)
  L03_SIG1 w0.091: v1(116.2,59.45) 115.95,59.7 115.95,65.51 114.55,66.91 114.55,72.4 111.88,75.08 103.12,75.08 102.62,75.58 98.93,75.58 98.17,76.34 97.65,76.34 97.46,76.15 97.46,75.5 v1(97.06,75.1)
  BOTTOM w0.147: v1(116.2,59.45) TP77.1 115.37,58.67 115.88,58.16 R395.1 115.88,56.57 116.13,56.32 U83.2
SOC_SPI0_CS0: length 43
  TOP w0.147: U23.D12 v1(97.06,75.9)
  L03_SIG1 w0.091: v1(115.44,56.4) 116.63,57.59 116.63,59.79 116.31,60.1 116.31,65.41 114.77,66.95 114.77,72.5 111.97,75.3 103.21,75.3 102.73,75.78 99.11,75.78 98.3,76.6 97.31,76.6 97.06,76.34 v1(97.06,75.9)
  BOTTOM w0.147: v1(115.44,56.4) 115.48,56.36 U83.1 R399.1 TP80.1
SOC_SPI0_MISO: length 42.7
  TOP w0.147: v1(101.4,73.82) 100.78,74.44 100.51,74.44 100.35,74.59 100.35,74.59 100.24,74.7 U23.A14
  L03_SIG1 w0.091: v1(101.4,73.82) 102.76,73.82 103.12,74.18 109.98,74.18 110.41,73.75 110.41,71.92 112.61,69.73 112.61,66.45 114.09,64.96 114.09,56.5 115.19,55.41 120.24,55.41 v1(120.65,55.81)
  BOTTOM w0.147: U83.4 R398.1 TP79.1 121.03,55.43 v1(120.65,55.81)
SOC_SPI0_MOSI: length 37.6
  TOP w0.147: U23.A13 100.27,75.5 100.28,75.52 101.02,75.52 v1(101.47,75.07)
  L03_SIG1 w0.091: v1(101.47,75.07) 101.91,74.64 102.67,74.64 102.89,74.86 111.6,74.86 113.72,72.74 113.72,66.11 115.77,64.06 115.77,59.13 v1(116.2,58.69)
  BOTTOM w0.147: U83.3 116.78,56.32 117.04,56.57 R394.1 117.04,58.16 117.55,58.67 TP76.1 116.78,58.69 v1(116.2,58.69)
SOC_SPI1_CLK: length 114.2
  TOP w0.147: J2.C1 v1(74.55,129.81) ; U23.C14 v1(97.86,74.3)
  L03_SIG1 w0.091: v1(121.28,109.87) 120.18,109.87 116.18,113.87 96.57,113.87 94.18,116.26 94.18,117.78 88.46,123.5 85.39,123.5 82.95,125.94 79.46,125.94 75.59,129.81 v1(74.55,129.81) ; v1(97.86,74.3) 99.09,73.07 101.56,73.07 101.56,73.07 105.28,73.07 v1(105.61,73.4)
  L08_SIG2 w0.091: v1(105.61,73.4) 105.97,73.04 114.03,73.04 118.02,77.02 118.02,85.96 120.3,88.24 120.3,108.89 v1(121.28,109.87)
SOC_SPI1_CS0: length 108.6
  TOP w0.147: U23.B14 98.66,75.1 99.97,75.1 100,75.07 v1(100.46,75.07) ; J2.D1 v1(74.55,131.08)
  L03_SIG1 w0.091: v1(74.55,131.08) 75.44,131.08 76.84,129.68 76.84,129.19 79.64,126.39 83.13,126.39 85.58,123.94 88.55,123.94 93.86,118.62 114.31,118.62 v1(120.27,112.66)
  L08_SIG2 w0.091: v1(120.27,112.66) 119.64,112.03 119.64,88.53 114.48,83.37 114.48,82.4 113.03,80.95 113.03,77.66 110.89,75.52 100.9,75.52 v1(100.46,75.07)
SOC_SPI1_CS1: length 118.8
  TOP w0.147: U23.D14 v1(97.06,74.3) ; J2.D2 v1(73.28,131.08)
  L03_SIG1 w0.091: v1(73.28,131.08) 73.91,130.44 75.27,130.44 79.55,126.16 83.04,126.16 85.49,123.72 86.85,123.72 86.89,123.68 88.54,123.68 94.36,117.86 94.36,116.34 96.6,114.09 116.58,114.09 120.29,110.39 121.4,110.39 v1(122.05,109.74) ; v1(107.95,72.53) 107.44,73.04 106.6,73.04 105.71,73.93 103.13,73.93 102.59,73.39 99.33,73.39 98.02,74.7 97.46,74.7 v1(97.06,74.3)
  L08_SIG2 w0.091: v1(107.95,72.53) 108.59,72.53 108.91,72.86 114.11,72.86 118.24,76.99 118.24,85.87 120.52,88.15 120.52,107.58 122.05,109.1 v1(122.05,109.74)
SOC_SPI1_MISO: length 89.3
  TOP w0.147: U23.A15 100.23,73.9 101.02,73.11 101.81,73.11 103.76,75.06 103.76,77.48 106.68,80.41 v1(106.68,81.29) ; J2.B1 v1(74.55,128.54)
  L03_SIG1 w0.091: v1(106.68,81.29) 107.38,82 107.38,103.01 97.65,112.74 78.3,112.74 75.39,115.65 74.65,115.65 73,117.29 73,119.27 71.88,120.39 71.88,125.87 v1(74.55,128.54)
SOC_SPI1_MOSI: length 90.5
  TOP w0.147: J2.B2 v1(73.28,128.54) ; v1(105.28,80.64) 105.28,79.43 103.46,77.61 103.46,75.18 101.68,73.4 101.13,73.4 100.23,74.3 98.66,74.3 U23.B15
  L03_SIG1 w0.091: v1(73.28,128.54) 70.89,126.15 70.89,119.29 72.04,118.14 72.04,117.23 73.85,115.42 75.29,115.42 78.2,112.51 97.56,112.51 107.16,102.92 107.16,82.52 v1(105.28,80.64)
SOC_TCK: length 140
  TOP w0.147: v1(125.09,60.85) 125.68,60.27 125.68,57.37 122.2,53.89 111.63,53.89 108.16,50.42 100.85,50.42 99.55,51.72 97.57,51.72 95.95,53.34 R147.2 ; v1(101.6,77.99) 101.11,77.5 100.9,77.5 100.88,77.49 100.54,77.49 100.52,77.5 98.66,77.5 U23.B11
  L03_SIG1 w0.091: v1(125.09,60.85) 124.66,60.42 118.87,60.42 117.34,61.94 117.34,65.78 115.88,67.25 115.88,72.97 111.31,77.55 102.05,77.55 v1(101.6,77.99)
  L08_SIG2 w0.091: v1(125.09,60.85) 124.71,60.47 124.71,59.2 125.26,58.65 125.68,58.65 127.99,56.34 127.99,40.87 137.89,30.97 141.89,30.97 142.29,30.57 146.11,30.57 v1(151.89,24.78)
  BOTTOM w0.147: R506.2 v1(151.89,24.78)
SOC_TDI: length 143.8
  TOP w0.147: U23.C11 v1(97.86,77.5) ; v1(125.22,59.58) 120.12,54.48 111.36,54.48 107.89,51.01 101.09,51.01 99.79,52.31 97.81,52.31 95.93,54.19 86.31,54.19 85.23,53.11 85.23,51.87 85.69,51.41 U37.7
  L03_SIG1 w0.091: v1(97.86,77.5) 98.29,77.07 102.45,77.07 103.56,75.96 112.25,75.96 115.44,72.77 115.44,67.17 116.94,65.67 116.94,61.72 119.56,59.1 124.75,59.1 v1(125.22,59.58)
  L08_SIG2 w0.091: v1(125.22,59.58) 128.22,56.58 128.22,40.95 137.91,31.26 141.86,31.26 142.37,30.75 146.56,30.75 152.33,24.98 152.33,23.35 v1(151.35,22.37)
  BOTTOM w0.147: v1(151.35,22.37) 151.39,22.33 U98.4
SOC_TDO: length 131.8
  TOP w0.147: U46.2 v1(90.48,33.03) ; v1(135,22.37) 134.99,22.37 134.85,22.51 U56.2
  L03_SIG1 w0.091: v1(103.43,71.87) 104.48,70.83 104.48,67.53 107.19,64.82 107.19,57.18 107.62,56.74 107.62,55.9 110.11,53.42 123.19,53.42 125.28,51.32 125.28,27.01 128.65,23.64 134.49,23.64 135,23.13 v1(135,22.37)
  L08_SIG2 w0.091: v1(135,22.37) 133.63,23.74 119.66,23.74 119.56,23.84 119.51,23.84 119.45,23.89 119.4,23.89 111.26,32.02 106.37,32.02 105.28,33.11 95.55,33.11 94.45,34.22 93.53,34.22 93.24,33.92 91.37,33.92 v1(90.48,33.03)
  BOTTOM w0.147: R323.1 102.09,75.32 102,75.22 102,73.76 103.43,72.33 v1(103.43,71.87)
SOC_TMS: length 149.5
  TOP w0.147: U23.C12 v1(97.86,75.9) ; v1(124.33,57.55) 120.97,54.18 111.5,54.18 108.02,50.71 100.97,50.71 99.67,52.01 97.69,52.01 95.81,53.89 86.44,53.89 85.69,53.14 85.69,52.43 86.19,51.93 U37.6
  L03_SIG1 w0.091: v1(124.33,57.55) 119,57.55 117.35,55.89 115.32,55.89 115.02,56.2 115.02,57.22 115.23,57.44 115.23,64.34 113.53,66.04 113.53,72.61 111.51,74.64 102.98,74.64 102.69,74.34 101.89,74.34 101.7,74.53 99.23,74.53 v1(97.86,75.9)
  L08_SIG2 w0.091: v1(152.75,22.62) 153.67,22.62 153.98,22.31 153.98,21.37 153.7,21.1 151,21.1 144.65,27.45 139.45,27.45 127.4,39.5 127.4,56 125.4,57.99 124.78,57.99 v1(124.33,57.55)
  BOTTOM w0.147: v1(152.75,22.62) 152.39,22.26 U98.6
SOC_TRST#: length 149.8
  TOP w0.147: v1(124.13,59.58) 124.64,60.08 124.64,61.04 124.91,61.3 125.28,61.3 125.99,60.6 125.99,57.26 122.29,53.56 111.73,53.56 108.3,50.12 100.73,50.12 99.42,51.42 97.44,51.42 96.04,52.83 87.91,52.83 87.46,52.38 87.46,51.96 87.19,51.69 U37.4 ; U23.D11 v1(97.06,77.5)
  L03_SIG1 w0.091: v1(97.06,77.5) 97.46,77.9 98.26,77.9 98.87,77.29 102.55,77.29 103.65,76.18 112.36,76.18 115.66,72.88 115.66,67.21 117.16,65.71 117.16,61.78 118.7,60.23 123.48,60.23 v1(124.13,59.58)
  L08_SIG2 w0.091: v1(153.54,21.55) 151.05,21.55 141.85,30.75 137.8,30.75 127.79,40.76 127.79,56.23 125.59,58.43 124.84,58.43 124.13,59.14 v1(124.13,59.58)
  BOTTOM w0.147: v1(97.06,77.5) 97.66,76.9 98.29,76.9 98.77,77.38 R322.1 ; U98.7 v1(153.54,21.55)
SOC_USB0_VBUS: length 103.8
  TOP w0.147: U23.T14 v1(86.66,74.3)
  L08_SIG2 w0.091: v1(6.91,41.9) 21.39,56.38 43.28,56.38 46.99,60.09 46.99,62.03 47.35,62.38 47.35,62.57 61.92,77.15 74.95,77.15 76.48,75.63 76.5,75.63 76.56,75.56 80.39,75.56 82.03,73.93 86.28,73.93 v1(86.66,74.3)
  BOTTOM w0.147: v1(6.91,41.9) 6.63,42.18 R427.2 5.95,39.66 7.35,38.26 R436.1
SOC_VSENSE: length 10.4
  TOP w0.147: U23.D21 96.66,64.09 97.29,63.45 TP30.1
SOC_WARM_RESETZ: length 70.7
  TOP w0.147: TP70.1 124.59,29.61 124.59,27.7 v1(124.46,27.58) U50.2 ; U23.E18 v1(96.26,71.1)
  L03_SIG1 w0.091: v1(122.78,52.39) 122.52,52.65 107.89,52.65 105.1,55.44 105.1,57.28 99.98,62.4 99.98,63.76 96.66,67.08 96.66,70.59 96.26,70.99 v1(96.26,71.1)
  L08_SIG2 w0.091: v1(124.46,27.58) 125.09,28.21 125.09,50.45 123.16,52.39 v1(122.78,52.39)
  BOTTOM w0.147: R476.1 125.11,27.58 v1(124.46,27.58)
SUPERVISOR_DEBOUNCE_RSTN: length 37.6
  TOP w0.147: v1(127.64,23.13) 128,23.49 Q9.2 ; v1(136.42,19.01) 136.64,18.8 SW7.2 136.64,16.7 136.09,16.15 136.09,11.29 136.64,10.75 SW7.1 ; U57.2 v1(122,21.55)
  BOTTOM w0.147: R540.1 139.25,17.96 139.21,17.92 C468.2 137.42,17.92 137.31,18.03 D10.2 136.73,18.71 v1(136.42,19.01) 134.98,19.01 133.48,20.51 133.48,23.89 132.33,25.03 129.67,25.03 129.16,24.53 127.89,24.53 127.64,24.27 v1(127.64,23.13) 122.94,23.13 122,22.19 v1(122,21.55)
SUPERVISOR_MR_RSTN: length 76.8
  TOP w0.147: U57.4 v1(122.65,25.63)
  L08_SIG2 w0.091: v1(124.21,91.96) 121.35,89.11 121.35,73.42 121.35,73.24 122.81,71.78 122.81,55.02 125.37,52.46 125.37,51.08 125.57,50.89 125.57,27.79 123.41,25.63 v1(122.65,25.63)
  BOTTOM w0.147: U76.1 127.41,93.14 126.24,91.96 v1(124.21,91.96)
SYNC1_OUT_TP: length 68.8
  TOP w0.147: v1(103.56,70.12) 104.13,69.55 104.13,69.12 105.51,67.73 111.18,67.73 111.48,68.04 113.01,68.04 115.1,70.13 115.1,79.22 v1(114.3,80.02) ; U23.D18 v1(97.06,71.1)
  L03_SIG1 w0.091: v1(103.56,70.12) 103.29,69.86 101.74,69.86 100.49,71.1 v1(97.06,71.1)
  L08_SIG2 w0.091: v1(114.3,80.02) 114.94,80.66 114.94,83.2 120.08,88.35 120.08,111.34 120.96,112.23 120.96,112.47 J12.1
SYS_BOOTMODE0: length 70.4
  TOP w0.147: SW2.1 v1(83.19,20.77)
  L08_SIG2 w0.091: v1(68.81,66.72) 68.81,66.28 70.18,64.92 70.18,60.14 72.39,57.93 72.39,55.49 72.73,55.15 72.73,52.78 73.1,52.41 73.1,46.09 79.35,39.85 79.35,35.28 82.84,31.79 82.84,29.16 83.62,28.38 83.62,21.2 v1(83.19,20.77)
  BOTTOM w0.147: v1(68.81,66.72) 69.31,67.22 U79.3 ; R529.1 v1(83.19,20.77) 85.27,18.68 92.23,18.68 94.6,21.06 U96.1
SYS_BOOTMODE1: length 71.4
  TOP w0.147: SW2.2 v1(84.46,20.77)
  L08_SIG2 w0.091: v1(84.46,20.77) 84.01,20.32 82.99,20.32 82.66,20.66 82.66,31.71 79.16,35.21 79.16,39.77 72.87,46.06 72.87,52.33 71.75,53.45 71.75,54.44 71.91,54.6 71.91,58.1 69.95,60.05 69.95,64.83 68.38,66.41 68.38,67.42 v1(68.81,67.86)
  BOTTOM w0.147: U96.2 94,22.11 93.85,21.97 93.85,20.73 92.1,18.98 86.24,18.98 v1(84.46,20.77) R519.1 ; U79.4 v1(68.81,67.86)
SYS_BOOTMODE2: length 72.3
  TOP w0.147: SW2.3 v1(85.73,20.77)
  L08_SIG2 w0.091: v1(67.81,66.72) 68.16,66.38 68.16,66.31 69.27,65.2 69.27,61.54 68.83,61.1 68.83,58.04 70.61,56.26 70.61,54.27 72.69,52.2 72.69,45.99 78.98,39.69 78.98,35.13 82.47,31.64 82.47,20.56 82.93,20.11 85.06,20.11 v1(85.73,20.77)
  BOTTOM w0.147: U96.3 93.85,22.61 93.56,22.33 93.56,20.85 91.98,19.27 87.22,19.27 v1(85.73,20.77) R514.1 ; v1(67.81,66.72) 68.31,67.22 U79.5
SYS_BOOTMODE3: length 72.9
  TOP w0.147: SW2.4 v1(87,20.77)
  L08_SIG2 w0.091: v1(67.81,67.86) 67.31,67.36 67.31,66.31 68.02,65.6 68.02,64.84 68.89,63.97 68.89,61.54 68.45,61.1 68.45,57.67 69.02,57.11 69.02,55.56 72.47,52.1 72.47,45.89 78.78,39.59 78.78,35.07 82.29,31.56 82.29,20.49 82.86,19.92 86.15,19.92 v1(87,20.77)
  BOTTOM w0.147: U96.4 93.85,23.11 93.26,22.53 93.26,20.97 91.86,19.57 88.19,19.57 v1(87,20.77) R510.1 ; U79.6 v1(67.81,67.86)
SYS_BOOTMODE4: length 73
  TOP w0.147: SW2.5 v1(88.27,20.77)
  L08_SIG2 w0.091: v1(88.27,20.77) 87.24,19.74 82.78,19.74 82.11,20.41 82.11,31.48 78.56,35.04 78.56,39.49 71.45,46.6 71.45,52.27 68.12,55.59 68.12,61.94 67.8,62.27 67.8,65.3 66.81,66.28 v1(66.81,66.72)
  BOTTOM w0.147: R503.1 v1(88.27,20.77) 89.17,19.86 91.74,19.86 92.97,21.09 92.97,22.73 93.85,23.61 U96.5 ; v1(66.81,66.72) 67.31,67.22 U79.7
SYS_BOOTMODE5: length 74.4
  TOP w0.147: SW2.6 v1(89.53,20.77)
  L08_SIG2 w0.091: v1(89.53,20.77) 88.33,19.56 82.7,19.56 81.93,20.34 81.93,31.41 78.33,35 78.33,39.32 71.22,46.43 71.22,51.98 67.84,55.36 67.84,61.12 66.64,62.33 66.64,65.71 66.29,66.05 66.29,67.34 v1(66.81,67.86)
  BOTTOM w0.147: 90.14,20.16 v1(89.53,20.77) ; 90.14,20.16 91.57,20.16 92.67,21.26 92.67,22.94 93.85,24.11 U96.6 ; 90.14,20.16 v1(89.53,20.77) ; v1(89.53,20.77) R498.1 ; U79.8 v1(66.81,67.86)
SYS_BOOTMODE6: length 73.9
  TOP w0.147: SW2.7 v1(90.8,20.77)
  L08_SIG2 w0.091: v1(90.8,20.77) 89.41,19.37 82.63,19.37 81.74,20.26 81.74,31.33 78.11,34.96 78.11,39.23 71,46.34 71,51.88 67.62,55.26 67.62,60.92 66.4,62.13 66.4,65.44 65.81,66.03 v1(65.81,66.72)
  BOTTOM w0.147: U79.9 66.31,67.22 v1(65.81,66.72) ; U96.7 93.43,24.61 92.35,23.54 92.35,21.63 91.49,20.77 v1(90.8,20.77) R489.1
SYS_BOOTMODE7: length 76
  TOP w0.147: SW2.8 92.07,22.98 v1(91.77,23.28)
  L08_SIG2 w0.091: v1(65.81,67.86) 65.38,67.42 65.38,65.96 65.53,65.8 65.53,60.97 66.72,59.79 66.72,57.5 66.6,57.38 66.6,55.97 70.78,51.79 70.78,46.25 77.89,39.14 77.89,34.92 81.56,31.26 81.56,20.18 82.55,19.19 89.94,19.19 91.77,21.02 v1(91.77,23.28)
  BOTTOM w0.147: U96.8 93.35,25.11 91.77,23.54 v1(91.77,23.28) 90.96,23.28 90.83,23.41 90.83,23.41 90.78,23.46 R474.1 ; U79.10 v1(65.81,67.86)
SYS_BOOTMODE8: length 61
  TOP w0.147: SW3.1 v1(102.95,23.13)
  L08_SIG2 w0.091: v1(77.29,51.83) 77.29,48.61 86.03,39.87 86.03,34.84 88.28,32.59 93.48,32.59 v1(102.95,23.13)
  BOTTOM w0.147: U81.3 76.68,53.1 76.83,52.95 76.83,52.29 v1(77.29,51.83) ; U96.9 95.4,26.66 97.35,28.62 100.54,28.62 102.64,26.52 102.64,23.43 v1(102.95,23.13) 103.89,23.13 104.24,23.48 R473.1
SYS_BOOTMODE9: length 66.2
  TOP w0.147: SW3.2 v1(104.22,20.84)
  L08_SIG2 w0.091: v1(104.22,20.84) 102.84,20.84 101.73,21.96 101.73,24.02 93.34,32.4 88.16,32.4 85.81,34.75 85.81,39.78 76.73,48.86 76.73,52.41 v1(76.29,52.85)
  BOTTOM w0.147: U81.4 76.18,52.96 v1(76.29,52.85) ; R488.1 v1(104.22,20.84) 102.93,20.84 102.3,21.47 102.3,26.44 100.42,28.32 97.56,28.32 95.9,26.66 U96.10
SYS_BOOTMODE10: length 69.7
  TOP w0.147: SW3.3 v1(105.49,20.84)
  L08_SIG2 w0.091: v1(105.49,20.84) 104.56,19.92 103.42,19.92 101.54,21.8 101.54,23.94 94.8,30.69 89.56,30.69 85.59,34.66 85.59,39.69 76.28,48.99 76.28,51.38 76.29,51.39 v1(76.29,51.83)
  BOTTOM w0.147: U81.5 75.68,53.22 75.75,53.15 75.75,52.38 v1(76.29,51.83) ; R497.1 v1(105.49,20.84) 104.83,20.18 103.17,20.18 102.01,21.35 102.01,26.32 100.3,28.03 97.76,28.03 96.4,26.67 U96.11
SYS_BOOTMODE11: length 72.3
  TOP w0.147: SW3.4 v1(106.76,20.84)
  L08_SIG2 w0.091: v1(75.29,52.85) 75.73,52.41 75.73,49.23 85.37,39.59 85.37,34.57 89.47,30.46 94.76,30.46 101.36,23.87 101.36,21.72 103.35,19.73 105.65,19.73 v1(106.76,20.84)
  BOTTOM w0.147: R502.1 v1(106.76,20.84) 105.8,19.89 103.05,19.89 101.71,21.23 101.71,26.2 100.18,27.73 97.99,27.73 96.9,26.65 U96.12 ; U81.6 75.18,52.96 v1(75.29,52.85)
SYS_BOOTMODE12: length 75.1
  TOP w0.147: SW3.5 v1(108.03,20.84)
  L08_SIG2 w0.091: v1(75.29,51.83) 75.29,49.36 85.15,39.5 85.15,34.48 89.38,30.24 94.73,30.24 101.06,23.91 101.06,21.39 102.9,19.55 106.73,19.55 v1(108.03,20.84)
  BOTTOM w0.147: U81.7 74.68,53.22 74.75,53.15 74.75,52.38 v1(75.29,51.83) ; R509.1 v1(108.03,20.84) 106.78,19.59 102.93,19.59 101.42,21.11 101.42,26.08 100.06,27.44 98.11,27.44 97.4,26.73 U96.13
SYS_BOOTMODE13: length 77.8
  TOP w0.147: SW3.6 v1(109.3,20.84)
  L08_SIG2 w0.091: v1(109.3,20.84) 107.76,19.3 102.89,19.3 100.87,21.32 100.87,23.84 94.69,30.02 89.29,30.02 84.93,34.38 84.93,39.41 74.73,49.61 74.73,52.41 v1(74.3,52.85)
  BOTTOM w0.147: R513.1 v1(109.3,20.84) 107.75,19.3 102.81,19.3 101.12,20.98 101.12,25.95 99.93,27.14 98.23,27.14 97.9,26.81 U96.14 ; v1(74.3,52.85) 74.18,52.96 U81.8
SYS_BOOTMODE14: length 80.3
  TOP w0.147: SW3.7 v1(110.57,20.84)
  L08_SIG2 w0.091: v1(110.57,20.84) 108.84,19.12 102.74,19.12 100.69,21.17 100.69,23.76 94.65,29.8 89.2,29.8 84.71,34.29 84.71,39.32 74.3,49.73 v1(74.3,51.83)
  BOTTOM w0.147: R518.1 v1(110.57,20.84) 108.73,19 102.64,19 100.83,20.81 100.83,25.83 99.85,26.81 98.63,26.81 98.4,26.58 U96.15 ; U81.9 73.68,52.45 v1(74.3,51.83)
SYS_BOOTMODE15: length 83.1
  TOP w0.147: SW3.8 v1(111.84,20.84)
  L08_SIG2 w0.091: v1(73.15,52.97) 73.35,52.78 73.35,49.09 74.63,47.82 75.95,47.82 84.48,39.28 84.48,34.2 89.11,29.58 94.61,29.58 100.51,23.69 100.51,21 102.57,18.94 110.34,18.94 111.84,20.44 v1(111.84,20.84)
  BOTTOM w0.147: R528.1 v1(111.84,20.84) 111.84,20.81 109.73,18.71 102.51,18.71 100.53,20.69 100.53,25.62 100.24,25.91 U96.16 ; U81.10 73.18,53 v1(73.15,52.97)
SYSBOOT_BUF_ENZ: length 3
  BOTTOM w0.147: R435.1 R434.1 108.98,39.18 108.97,39.16 U90.1
TCA6424_EXP_INT: length 2.3
  BOTTOM w0.147: U96.32 95.4,20 94.97,19.58 R533.1
TEMP_DIODE_P: length 23.8
  TOP w0.147: U23.F12 v1(95.46,75.9)
  L08_SIG2 w0.091: v1(109.65,63.26) 107.98,64.93 107.98,68.61 104.26,72.33 100.33,72.33 98.98,73.67 98.98,74.51 97.97,75.53 95.83,75.53 v1(95.46,75.9)
  BOTTOM w0.147: v1(109.65,63.26) 109.68,63.24 110.11,63.24 110.13,63.26 TP75.1
TEST_GPIO1: length 67.3
  L08_SIG2 w0.091: v1(70.33,18.23) 71.39,19.29 74.3,19.29 79.46,14.13 92.55,14.13 94.4,15.98 105.49,15.98 106.51,17.01 113.35,17.01 116.95,20.61 117.32,20.61 122.54,20.61 123.84,21.9 123.84,22.55 124.15,22.86 126.38,22.86 126.79,22.45 v1(128.46,22.45)
  BOTTOM w0.147: Q17.1 v1(128.46,22.45) ; R523.1 v1(70.33,18.23) R545.1
TEST_GPIO2: length 36.7
  TOP w0.147: v1(51.82,33.94) 57.26,33.94 58.06,33.14 60.09,33.14 60.5,32.74 60.5,32.33 59.88,31.71 59.19,31.71 58.56,31.08 58.56,29.21 59.56,28.21 68.2,28.21 69.19,27.22 v1(69.19,18.23)
  BOTTOM w0.147: U91.14 51.84,33.91 v1(51.82,33.94) ; R546.1 v1(69.19,18.23) R524.1
TEST_GPIO3: length 92
  TOP w0.147: TP41.1 68.05,18.66 v1(68.05,18.23) 68.05,15.48 66.17,13.6 54.74,13.6 53.59,12.46 J30.1
  L03_SIG1 w0.091: v1(68.05,18.23) 69.12,17.16 89.21,17.16 94.33,12.05 102.65,12.05 108.54,17.94 108.54,22.88 111.1,25.44 111.1,29.95 111.79,30.65 111.79,36.05 v1(111,36.84)
  BOTTOM w0.147: U90.2 110.39,37.61 110.41,37.62 R439.2 v1(111,36.84) ; R525.1 v1(68.05,18.23) R547.1
TEST_GPIO4: length 38.8
  TOP w0.147: v1(66.9,18.23) 66.9,18.91 TP40.1
  L08_SIG2 w0.091: v1(66.9,18.23) 68.18,19.51 74.39,19.51 79.55,14.35 92.39,14.35 v1(96.9,18.86)
  BOTTOM w0.147: R526.1 v1(66.9,18.23) R548.1 ; v1(96.9,18.86) 97.4,19.36 U96.28
TEST_LED1: length 71.3
  L08_SIG2 w0.091: v1(52.2,36.58) 51.31,35.69 51.31,34.67 51.56,34.42 51.94,34.42 52.7,33.66 52.7,28.83 53.34,28.19 58.42,28.19 65.53,21.08 78.71,21.08 81.68,18.11 91.61,18.11 94.13,20.62 98.82,20.62 103.02,16.42 v1(103.8,16.42)
  BOTTOM w0.147: v1(103.8,16.42) R549.2 R553.2 ; U91.17 53.49,36.03 52.95,36.58 v1(52.2,36.58)
TEST_LED2: length 279.6
  TOP w0.147: v1(101.96,80.68) 101.57,80.29 99.56,80.29 99.54,80.3 U23.A7
  L03_SIG1 w0.091: v1(156.21,43.96) 149.61,50.56 149.61,57.55 148.46,58.69 148.46,87.26 150.5,89.3 150.5,100.48 154.62,104.61 154.62,119.64 153.36,120.89 147.36,120.89 147.01,121.25 147.01,126.32 J1.7
  L08_SIG2 w0.091: v1(93.95,14.25) 95.38,14.25 95.73,14.59 105.13,14.59 106.81,16.27 113.56,16.27 117.27,12.56 146.2,12.56 147.83,10.94 152.15,10.94 152.65,11.44 152.65,16.27 155.19,18.81 155.19,39.77 156.21,40.78 v1(156.21,43.96) ; J1.7 144.62,123.93 142.15,123.93 140.26,122.05 122.45,122.05 116.79,116.39 116.79,97.37 112.08,92.66 110.94,92.66 108.23,89.94 108.23,86.94 v1(101.96,80.68)
  BOTTOM w0.147: R552.2 R554.2 v1(93.95,14.25)
TEST_PORZN: length 66.2
  TOP w0.147: v1(130.36,22.45) Q9.1
  L08_SIG2 w0.091: v1(130.36,22.45) 129.52,21.6 124.16,21.6 122.72,20.16 117.13,20.16 113.53,16.56 106.7,16.56 104.94,14.81 93.79,14.81 92.67,13.69 79.28,13.69 74.11,18.85 73.23,18.85 v1(72.62,18.23)
  BOTTOM w0.147: R521.1 v1(72.62,18.23) R543.1
TEST_POWERDOWN: length 132.8
  L08_SIG2 w0.091: v1(73.76,18.23) 78.56,13.43 93.43,13.43 93.73,13.73 96.65,13.73 96.9,13.48 104.39,13.48 106.93,16.02 113.41,16.02 117.12,12.31 141.63,12.31 144.27,9.67 152.15,9.67 154.94,12.46 154.94,17.67 156.99,19.71 156.99,35.21 168.91,47.13 168.91,47.64 v1(170.45,49.18)
  BOTTOM w0.147: R412.1 v1(170.45,49.18) ; v1(73.76,18.23) R542.1
TEST_WARMRESETN: length 63.1
  TOP w0.147: Q10.1 v1(126.17,22.42)
  L08_SIG2 w0.091: v1(71.47,18.23) 72.31,19.07 74.2,19.07 79.37,13.91 92.61,13.91 94.46,15.76 105.58,15.76 106.61,16.78 113.44,16.78 117.04,20.39 117.23,20.39 122.63,20.39 124.06,21.81 124.06,21.82 124.16,21.93 125.68,21.93 v1(126.17,22.42)
  BOTTOM w0.147: R522.1 v1(71.47,18.23) R544.1
TM4C129_TCK: length 3.9
  TOP w0.147: TP37.1 157.95,31.33 U59.100
TM4C129_TDI: length 5.3
  TOP w0.147: U59.98 158.75,32.35 TP36.1
TM4C129_TDO: length 2.8
  TOP w0.147: TP38.1 159.68,31.23 159.15,30.7 U59.97
TM4C129_TMS: length 4.6
  TOP w0.147: TP35.1 158.28,33.27 158.35,33.2 U59.99
TMP1_ADD0: length 3.2
  TOP w0.147: U18.5 R72.2 R68.2
TMP1_ADD1: length 3.1
  TOP w0.147: R98.2 R93.2 U18.3
TMP2_ADD0: length 3.1
  TOP w0.147: U29.5 R133.2 R132.1
TMP2_ADD1: length 3.1
  TOP w0.147: U29.3 121.48,68.75 121.41,68.82 R125.2 R124.2
USB0_AB_DM: length 8.5
  TOP w0.107: v1(5.91,53.62) 5.68,53.85 5.14,53.85 4.87,53.58 J24.2
  BOTTOM w0.107: FL22.4 6.95,56.93 6.68,56.66 6.27,56.66 5.95,56.34 5.95,55.55 5.06,54.66 5.06,54.12 5.36,53.82 5.71,53.82 v1(5.91,53.62) 6.18,53.9 6.66,53.9 U38.1
USB0_AB_DP: length 8.5
  TOP w0.107: J24.3 4.87,54.23 5.03,54.07 5.94,54.07 6.04,54.17 6.04,54.38 5.98,54.44 v1(5.91,54.44)
  BOTTOM w0.107: FL22.3 6.95,56.13 6.64,56.44 6.36,56.44 6.17,56.25 6.17,55.46 5.28,54.57 5.28,54.21 5.45,54.04 5.79,54.04 5.91,54.16 v1(5.91,54.44) 6.23,54.12 6.63,54.12 U38.2
USB0_AB_ID: length 112.3
  TOP w0.147: U23.U16 v1(85.86,72.7) ; J24.4 5.64,54.88 5.94,55.18 v1(6.73,55.18)
  L03_SIG1 w0.203: v1(6.73,55.18) 6.73,49.24 6.15,48.66 3.73,48.66 J23.5
  L08_SIG2 w0.091: v1(57.66,55.75) 58.29,55.75 63.16,60.62 63.16,61.66 63.3,61.8 63.3,62.54 63.86,63.11 63.86,67.47 65.55,69.16 69.65,69.16 70.05,68.76 75.16,68.76 75.34,68.58 76.09,68.58 77.22,67.45 80.53,67.45 81.53,68.45 81.53,69.78 82.3,70.55 82.3,70.94 82.29,70.95 82.29,71.26 82.3,71.27 82.3,71.29 82.77,71.77 83.44,71.77 83.97,72.3 85.24,72.3 85.64,72.7 v1(85.86,72.7)
  BOTTOM w0.147: v1(57.66,55.75) 57.2,55.75 53.64,52.19 48.64,52.19 45.62,55.21 35,55.21 32.79,53 10.62,53 8.18,55.44 7.44,55.44 7.19,55.18 v1(6.73,55.18) 6.77,55.14 U38.3
USB0_DM: length 94.3
  TOP w0.14: U23.AA20 v1(82.66,69.5)
  L08_SIG2 w0.094: v1(82.66,69.5) 82.38,69.78 82.16,69.78 81.98,69.6 81.98,67.94 80.76,66.72 76.29,66.72 74.9,68.12 69.71,68.12 69.31,68.52 65.82,68.52 64.5,67.2 64.5,62.09 63.8,61.39 63.8,60.15 60.65,57 60.65,55.41 59.98,54.73 58.8,54.73 v1(58.59,54.53)
  BOTTOM w0.107: FL22.1 10.01,56.93 10.31,56.64 12.11,56.64 14.54,54.21 31.79,54.21 33.67,56.09 55.2,56.09 56.77,57.66 58.44,57.66 59.83,56.26 59.83,55.19 59.37,54.74 58.8,54.74 v1(58.59,54.53)
