# Allegro board PROC101E2_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FSI_TX0_D1: length 73.1
  TOP w0.147: U8.15 v1(60.58,117.87)
  L08_SIG2 w0.091: J7.7 1.88,117.39 1.88,124.68 2.84,125.64 8.74,125.64 12.93,121.45 55.77,121.45 57.27,119.96 59.13,119.96 59.69,119.39 59.69,118.76 v1(60.58,117.87)
FT4232_DO: length 3.7
  TOP w0.147: v1(132.85,28.2) 133.45,28.2 133.62,28.38 R192.2 R191.1
  BOTTOM w0.147: v1(132.85,28.2) 133.03,28.38 U92.4
FT4232_EECLK: length 10.4
  TOP w0.147: R186.1 135.13,30.24 v1(135.38,29.99)
  BOTTOM w0.147: U87.62 137.97,34.48 136.02,32.53 136.02,30.62 v1(135.38,29.99) 135.38,29.82 135.24,29.68 U92.2
FT4232_EECS: length 8.6
  BOTTOM w0.147: U87.63 137.47,34.61 135,32.15 R463.1 134.09,31.56 134.13,31.52 U92.1
FT4232_EEDATA: length 12
  TOP w0.147: R192.1 v1(135.76,28.97)
  BOTTOM w0.147: U92.3 135.26,29.03 135.31,28.97 v1(135.76,28.97) 136.4,29.61 136.4,32.4 138.47,34.47 U87.61
FT4232_MCU_UART0_CTS_3V3: length 6.2
  TOP w0.147: v1(142.47,49.52) 143.48,49.52 144.02,50.05 v1(144.02,52.47)
  BOTTOM w0.147: U82.12 143.86,52.63 v1(144.02,52.47) ; U87.28 v1(142.47,49.52)
FT4232_MCU_UART0_RTS_3V3: length 3.8
  BOTTOM w0.147: U87.29 142.97,49.73 142.57,50.13 142.57,52.03
FT4232_MCU_UART0_RX_3V3: length 4.8
  TOP w0.147: v1(143.13,51.2) 142.75,50.81 141.99,50.81 141.47,50.29 v1(141.47,49.52)
  BOTTOM w0.147: v1(143.13,51.2) 142.97,51.36 U82.13 ; U87.26 v1(141.47,49.52)
FT4232_MCU_UART0_TX_3V3: length 3.7
  BOTTOM w0.147: U82.15 142.17,49.98 141.97,49.78 U87.27
FT4232_REF: length 2.8
  TOP w0.147: R175.2 v1(136.38,41.65)
  BOTTOM w0.147: U87.6 136.16,41.44 v1(136.38,41.65)
FT4232_RESET: length 8.4
  BOTTOM w0.254: R417.1 129.54,46.75 130.18,47.39 132.93,47.39 133.08,47.24 C416.2 133.48,46.5 133.73,46.24 133.73,45.61 133.9,45.44 U87.14
FT4232_UART0_CTS_3V3: length 3.9
  TOP w0.147: v1(137.47,49.52) 137.47,50.76 v1(137.03,51.2)
  BOTTOM w0.147: v1(137.03,51.2) 136.87,51.36 U84.12 ; U87.18 v1(137.47,49.52)
FT4232_UART0_RTS_3V3: length 4.5
  BOTTOM w0.147: U87.19 137.97,49.75 137.67,50.05 135.73,50.05 135.58,50.2 U84.14
FT4232_UART0_RX_3V3: length 5.4
  TOP w0.147: v1(135,47.26) 135,49.06 v1(136.53,50.58)
  BOTTOM w0.147: v1(135,47.26) 135,46.45 U87.16 ; U84.13 136.04,50.81 136.29,50.81 v1(136.53,50.58)
FT4232_UART0_TX_3V3: length 3.7
  BOTTOM w0.147: U84.15 135.18,50.13 135.64,49.67 136.7,49.67 136.97,49.41 U87.17
FT4232_UART1_RX_3V3: length 6.8
  BOTTOM w0.147: U89.13 151.8,41.42 151.5,41.72 151.5,41.93 149.5,43.94 148.52,43.94 148.51,43.93 147.65,43.93 147.64,43.94 U87.38
FT4232_UART1_TX_3V3: length 7.9
  TOP w0.147: v1(152.53,42.69) 151.78,43.44 v1(147.56,43.44)
  BOTTOM w0.147: v1(152.53,42.69) 152.53,42.26 152.6,42.18 U89.15 ; U87.39 v1(147.56,43.44)
FT4232_UART3_RX_3V3: length 5.9
  BOTTOM w0.147: U89.12 150.21,40.62 148.52,38.94 U87.48
FT4232_UART3_TX_3V3: length 12.9
  TOP w0.147: v1(152.02,42.18) 151.56,42.18 150.17,40.78 147.7,40.78 145.49,38.57 v1(143.38,38.57)
  BOTTOM w0.147: U89.14 152.2,42 v1(152.02,42.18) ; v1(143.38,38.57) 142.97,38.16 U87.52
FT4232_USB_DM: length 52.1
  TOP w0.107: J26.2 173.05,41.43 172.83,41.21 172.55,41.21 v1(172.25,41.52) 171.89,41.16 171.7,41.16 171.39,40.85 171.39,40.59 171.22,40.42 171.06,40.42 170.95,40.53 U42.5
  L03_SIG1 w0.094: v1(137.43,41.78) 137.22,41.99 136.89,41.99 136.49,42.39 136.49,43.32 136.76,43.59 137.84,43.59 138.64,42.79 138.64,39.42 140.11,37.95 147.57,37.95 149.61,35.91 159.39,35.91 164.32,40.84 170.75,40.84 171.23,41.32 172.05,41.32 v1(172.25,41.52)
  BOTTOM w0.107: U87.7 135.99,41.94 136.15,42.09 137.11,42.09 v1(137.43,41.78)
FT4232_USB_DP: length 52.1
  TOP w0.107: J26.3 173.04,40.78 172.83,40.99 172.54,40.99 v1(172.25,40.7) 172,40.94 171.79,40.94 171.61,40.76 171.61,40.5 171.31,40.2 171.06,40.2 170.89,40.03 U42.4
  L03_SIG1 w0.094: v1(137.43,42.6) 137.43,42.34 137.32,42.23 137,42.23 136.74,42.49 136.74,43.22 136.86,43.34 137.74,43.34 138.39,42.68 138.39,39.32 140.01,37.7 147.47,37.7 149.51,35.67 159.49,35.67 164.42,40.6 170.85,40.6 171.33,41.08 172.37,41.08 172.47,40.98 172.47,40.8 172.37,40.7 v1(172.25,40.7)
  BOTTOM w0.107: U87.8 135.99,42.44 136.12,42.31 137.14,42.31 v1(137.43,42.6)
FT4232_USB_VBUS: length 4.5
  TOP w0.254: U42.6 170.5,41.42 v1(170.63,41.54) ; U43.4 v1(166.38,39.37) ; U43.6 v1(165.09,39.37) ; J26.1 172.5,42.08 172.15,42.43 C154.2
  vias: v1(171.51,45.99) v1(172.02,44.97)
FT_PWREN#: length 6.6
  BOTTOM w0.147: U87.60 138.97,32.64 138.2,31.87 R464.1
GPIO1_43_INTN: length 71.2
  TOP w0.147: U23.C13 v1(97.86,75.1)
  L03_SIG1 w0.091: v1(97.86,75.1) 98.3,75.1 99.09,74.31 101.61,74.31 101.8,74.12 102.78,74.12 103.06,74.4 110.07,74.4 110.63,73.85 110.63,72.05 112.84,69.84 112.84,66.47 114.27,65.04 114.27,56.63 115.26,55.64 119.31,55.64 v1(120.78,57.11)
  L08_SIG2 w0.091: v1(120.78,57.11) 121.39,56.5 121.39,52.9 122.66,51.63 123.52,51.63 124.08,51.07 v1(124.08,28.84)
  BOTTOM w0.147: v1(124.08,28.84) 123.96,28.73 R471.2
GPIO_CPSW1_RST: length 100.6
  L03_SIG1 w0.091: v1(56,28.86) 56,41.12 48.53,48.58 44.95,48.58 42.62,50.91 42.62,56.03 46.83,60.24 46.83,63.93 46.61,64.15 46.61,64.22 46.48,64.35 46.48,77.3 46.77,77.59 46.77,92.38 43.63,95.52 43.63,96.65 43.05,97.23 43.05,101.47 44.83,103.25 v1(44.83,106.57)
  BOTTOM w0.147: U91.3 v1(56,28.86) ; v1(44.83,106.57) 48.9,106.57 49.78,107.46 R241.1 R242.1 47.88,108.36 47.86,108.34 U69.1
GPIO_EMMC_RSTN: length 70.8
  TOP w0.147: v1(115.46,21.24) R196.1 115.46,22.7 115.51,22.75 U54.1
  L08_SIG2 w0.091: v1(115.46,21.24) 113.92,19.7 113.28,19.7 111.64,18.06 102.08,18.06 99.34,20.8 94.05,20.8 91.64,18.4 81.75,18.4 78.87,21.28 65.98,21.28 58.4,28.86 v1(57,28.86)
  BOTTOM w0.147: U91.1 v1(57,28.86)
GPIO_OLED_RESETN: length 62.2
  L08_SIG2 w0.091: v1(50.95,34.41) 51.39,33.97 51.39,33.7 51.5,33.59 51.5,33.23 51.39,33.12 51.39,32.7 51.5,32.59 51.5,32.23 51.39,32.12 51.39,31.7 51.5,31.59 51.5,28.19 51.31,28 51.31,24 48.64,21.34 10.27,21.34 v1(8.64,19.7)
  BOTTOM w0.147: v1(8.64,19.7) R531.2 8.04,18.34 8.04,18.34 8.04,18.33 8.04,18.08 7.93,17.98 7.93,17.95 7.66,17.69 6.31,17.69 6.04,17.95 6.04,17.97 5.96,18.05 5.96,18.06 5.7,18.31 J36.6 ; U91.15 v1(50.95,34.41)
GPIO_OSPI_RSTN: length 43.5
  TOP w0.147: U23.K17 v1(92.26,71.9)
  L08_SIG2 w0.091: v1(92.26,71.9) 91.89,72.28 91.3,72.28 91.09,72.06 91.09,69.82 93.2,67.71 95.2,67.71 99.48,63.43 99.48,51.66 107.64,43.5 107.64,42.13 v1(107.99,41.79)
  BOTTOM w0.147: v1(107.99,41.79) 108.26,42.05 R429.1 U85.1
GPIO_PCIE_RST_OUT: length 30.3
  L03_SIG1 w0.091: v1(36.45,42.05) 37.71,42.05 41.68,38.08 43.84,38.08 49.7,32.22 49.7,31.13 52.5,28.34 54.1,28.34 54.47,28.7 v1(54.47,29.73)
  BOTTOM w0.147: U88.1 36.6,42.82 36.23,43.19 R424.2 R430.1 36.32,41.92 v1(36.45,42.05) ; U91.6 54.49,29.76 v1(54.47,29.73)
GPIO_RGMII1_RST: length 91.7
  TOP w0.147: U19.1 v1(25.4,90.06)
  L03_SIG1 w0.091: v1(25.4,90.06) 24.97,89.63 24.97,88.72 29.12,84.57 29.12,64.42 27.76,63.05 27.76,58.36 27.51,58.11 27.51,45.16 28.65,44.02 29.84,44.02 30.54,43.32 30.54,42.91 35.23,38.23 38.34,38.23 39.24,37.32 43.7,37.32 47.62,33.39 47.62,32.17 47.46,32 47.46,31.65 47.71,31.4 48.52,31.4 52.37,27.55 v1(56.01,27.55)
  BOTTOM w0.147: v1(56.01,27.55) 55.5,28.06 U91.4 ; R301.1 26.48,89.48 26.5,89.51 R300.1 25.44,90.1 v1(25.4,90.06)
GPIO_RGMII2_RST: length 49.9
  TOP w0.147: U31.1 30.61,58.56 v1(30.97,58.2)
  L03_SIG1 w0.091: v1(30.97,58.2) 30.97,50.75 30.98,50.74 30.98,50.38 30.86,50.26 30.86,45.38 33.58,42.66 34.92,42.66 39.73,37.86 43.75,37.86 49.48,32.12 49.48,31.04 52.44,28.08 54.21,28.08 v1(54.99,28.86)
  BOTTOM w0.147: v1(30.97,58.2) R380.1 R371.1 ; U91.5 v1(54.99,28.86)
GPIO_SOC/MCU: length 3.4
  TOP w0.147: v1(121.41,28.84) 121.68,28.58 U50.5
  BOTTOM w0.147: R470.1 122.4,29.35 122.41,29.34 R471.1 121.53,28.73 v1(121.41,28.84)
GPMC0_AD0: length 60.3
  TOP w0.147: RA1.9 67.79,80.14 67.8,80.15 v1(67.82,80.15) ; J2.E14 v1(58.04,132.35)
  L03_SIG1 w0.091: v1(67.82,80.15) 67.82,88.41 70.68,91.27 70.68,96.08 67.56,99.2 67.56,105.64 66.13,107.07 66.13,111.4 65.22,112.31 65.22,119.38 58.65,125.95 58.65,131.73 v1(58.04,132.35)
GPMC0_AD1: length 59.1
  TOP w0.147: RA1.10 v1(67.2,80) ; J2.D14 v1(58.04,131.08)
  L03_SIG1 w0.091: v1(67.2,80) 67.2,88.1 70.46,91.36 70.46,95.99 67.34,99.11 67.34,105.55 65.91,106.98 65.91,111.31 65.26,111.96 65,112.22 65,119.35 58.47,125.87 58.47,130.65 v1(58.04,131.08)
GPMC0_AD2: length 57.9
  TOP w0.147: v1(66.67,80.79) 66.67,80.16 66.7,80.14 RA1.11 ; J2.C14 v1(58.04,129.81)
  L03_SIG1 w0.091: v1(66.67,80.79) 66.67,87.89 70.23,91.45 70.23,95.9 67.12,99.01 67.12,105.46 64.78,107.8 64.78,119.26 58.04,126 v1(58.04,129.81)
GPMC0_AD3: length 59.2
  TOP w0.147: J2.E15 v1(56.77,132.35) ; RA1.12 v1(66.2,80)
  L03_SIG1 w0.091: v1(56.77,132.35) 57.38,131.74 57.38,126.3 64.56,119.13 64.56,107.71 66.9,105.37 66.9,98.33 67.94,97.28 67.94,89.47 66.2,87.73 66.2,80.97 66.21,80.97 66.21,80.61 66.2,80.6 v1(66.2,80)
GPMC0_AD4: length 58
  TOP w0.147: v1(65.77,80.79) 65.77,80.21 65.7,80.14 RA1.13 ; J2.D15 v1(56.77,131.08)
  L03_SIG1 w0.091: v1(65.77,80.79) 65.77,87.61 67.72,89.56 67.72,97.19 65.61,99.3 65.61,106.34 64.33,107.62 64.33,119.04 57.2,126.18 57.2,130.65 v1(56.77,131.08)
GPMC0_AD5: length 56.7
  TOP w0.147: J2.C15 v1(56.77,129.81) ; RA1.14 v1(65.2,80)
  L03_SIG1 w0.091: v1(65.2,80) 65.2,80.6 65.21,80.61 65.21,87.36 67.46,89.62 67.46,97.13 65.39,99.21 65.39,106.25 64.11,107.53 64.11,118.96 56.77,126.3 v1(56.77,129.81)
GPMC0_AD6: length 62.7
  TOP w0.147: J2.E17 v1(54.23,132.35) ; v1(64.77,80.79) 64.77,80.21 64.7,80.14 RA1.15
  L03_SIG1 w0.091: v1(64.77,80.79) 64.77,87.23 67.24,89.71 67.24,97.04 65.17,99.12 65.17,106.16 63.98,107.35 63.98,107.4 63.93,107.45 63.93,118.85 60.07,122.71 55.99,122.71 54.66,124.05 54.66,131.92 v1(54.23,132.35)
GPMC0_AD7: length 61.8
  TOP w0.147: RA1.16 v1(64.11,80) ; J2.D17 v1(54.23,131.08)
  L03_SIG1 w0.091: v1(64.11,80) 64.11,86.89 67.02,89.8 67.02,96.95 64.95,99.02 64.95,106.07 63.67,107.34 63.67,117.73 58.88,122.53 55.06,122.53 53.67,123.92 53.67,130.52 v1(54.23,131.08)
GPMC0_AD8: length 14
  TOP w0.147: J2.A22 47.24,124.6 50.57,121.27 56.57,121.27 57.04,120.81 U8.23
GPMC0_AD8/FSI_RX0_CLK: length 75.6
  TOP w0.147: v1(75.17,64.53) 75.15,64.52 RA3.9 ; U8.1 v1(54.99,119.37)
  L03_SIG1 w0.091: v1(54.99,119.37) 54.04,119.37 52.83,118.17 52.83,114.72 55.21,112.34 55.21,100.44 55.72,99.93 55.72,96.44 54.98,95.7 54.98,79.02 61.9,72.1 65.97,72.1 67.13,70.94 67.13,70.3 69.41,68.02 69.41,65.97 69.18,65.74 69.18,64.31 70.71,62.78 73.87,62.78 75.17,64.08 v1(75.17,64.53)
GPMC0_AD9: length 13.3
  TOP w0.147: J2.A21 48.51,124.82 51.77,121.57 57.11,121.57 57.54,121.14 U8.22
GPMC0_AD9/FSI_RX0_D0: length 78.3
  TOP w0.147: v1(75.17,65.55) 74.62,65 74.62,64.34 74.57,64.29 RA3.10 ; U8.3 v1(55,118.37)
  L03_SIG1 w0.091: v1(55,118.37) 54.55,118.82 53.79,118.82 53.05,118.07 53.05,114.81 55.63,112.23 55.63,108.09 56.55,107.16 56.55,101.92 57.66,100.81 57.66,97.68 57.02,97.04 57.02,92.22 57.79,91.45 57.79,87.95 56.74,86.91 56.74,77.6 62.03,72.32 67.27,72.32 68.14,71.44 68.14,70.17 69.63,68.69 69.63,65.87 69.4,65.65 69.4,64.4 70.8,63 73.65,63 74.6,63.95 74.6,64.98 v1(75.17,65.55)
GPMC0_AD10: length 15.2
  TOP w0.147: U8.20 58.53,121.24 57.91,121.86 52.22,121.86 49.12,124.96 49.12,127.29 J2.B21
GPMC0_AD10/FSI_RX0_D1: length 73.6
  TOP w0.147: v1(53.98,118.38) 54.48,117.87 U8.4 ; v1(74.17,64.53) 74.07,64.43 RA3.11
  L03_SIG1 w0.091: v1(74.17,64.53) 74.17,64.09 73.3,63.22 71.16,63.22 69.62,64.76 69.62,65.56 69.85,65.78 69.85,69.61 69.09,70.37 69.09,71.52 68.07,72.54 62.12,72.54 56.96,77.69 56.96,86.81 58.01,87.86 58.01,100.77 56.77,102.01 56.77,111.4 53.7,114.47 53.7,116.26 53.98,116.53 v1(53.98,118.38)
GPMC0_AD11: length 94.1
  TOP w0.147: J2.E21 v1(49.15,132.35) ; v1(74.17,65.55) 73.61,64.99 73.61,64.34 73.57,64.3 RA3.12
  L03_SIG1 w0.091: v1(74.17,65.55) 74.6,65.98 75.35,65.98 75.6,65.73 75.6,64.19 73.97,62.56 70.51,62.56 70.08,62.99 70.08,63.01 68.96,64.13 68.96,65.8 68.33,66.44 68.33,68.09 65.97,70.44 65.97,71.46 65.55,71.87 61.81,71.87 54.76,78.93 54.76,95.8 55.5,96.53 55.5,99.84 54.99,100.35 54.99,100.53 54.99,112.24 52.31,114.92 52.31,120.7 48.34,124.68 48.34,131.54 v1(49.15,132.35)
GPMC0_AD12: length 87.9
  TOP w0.147: J2.C21 v1(49.15,129.81) ; RA3.13 73.07,64.44 v1(73.15,64.53)
  L03_SIG1 w0.091: v1(49.15,129.81) 49.15,124.47 52.17,121.46 54.15,121.46 56.01,119.6 56.01,117.74 54.81,116.55 54.81,113.99 57.22,111.58 57.22,102.19 58.71,100.7 58.71,99.24 60.96,96.98 60.96,96.8 60.96,90.18 57.41,86.63 57.41,77.87 62.3,72.98 68.31,72.98 70.31,70.97 70.31,66.69 70.96,66.04 70.96,64.36 71.66,63.66 72.72,63.66 73.15,64.09 v1(73.15,64.53)
GPMC0_AD13: length 93.5
  TOP w0.147: v1(73.15,65.55) 72.58,64.97 72.58,64.3 72.57,64.29 RA3.14 ; J2.D21 v1(49.15,131.08)
  L03_SIG1 w0.091: v1(49.15,131.08) 48.52,130.45 48.52,124.83 52.07,121.27 54.08,121.27 55.5,119.85 55.5,117.74 53.92,116.16 53.92,114.57 57,111.49 57,102.1 58.49,100.61 58.49,99.15 60.74,96.89 60.74,90.28 57.19,86.72 57.19,77.78 62.21,72.76 68.17,72.76 70.07,70.86 70.07,66.56 70.69,65.94 70.69,64.07 71.32,63.44 73.2,63.44 73.59,63.83 73.59,65.11 v1(73.15,65.55)
GPMC0_AD14: length 15.8
  TOP w0.147: J2.B20 50.47,127.22 50.47,125.12 53.14,122.45 58.44,122.45 59.83,121.05 U8.18
GPMC0_AD14/FSI_TX0_D0: length 67.8
  TOP w0.147: U8.6 55.74,116.46 v1(55.24,115.97) ; v1(72.12,64.41) 72.12,64.39 72.07,64.33 RA3.15
  L03_SIG1 w0.091: v1(72.12,64.41) 72.43,64.72 72.43,65.63 70.69,67.37 70.69,71.17 68.48,73.38 68.32,73.38 64.68,73.38 64.64,73.42 62.48,73.42 58.58,77.33 57.85,78.06 57.85,86.45 61.4,90 61.4,96.62 61.4,97.36 60.02,98.75 60.02,100.02 57.66,102.38 57.66,111.79 56.97,112.48 56.97,114.13 56.97,114.13 56.97,115.51 56.52,115.97 v1(55.24,115.97)
GPMC0_AD15: length 19.1
  TOP w0.147: J2.A19 51.05,125.26 53.57,122.75 60.12,122.75 62.47,120.4 62.47,118.95 61.89,118.37 U8.16
GPMC0_AD15/FSI_TX0_D1: length 65.5
  TOP w0.147: U8.7 v1(56.54,115.33) ; RA3.16 71.48,64.29 71.63,64.44 v1(71.63,65.04)
  L03_SIG1 w0.091: v1(56.54,115.33) 56.1,114.89 56.1,113.04 57.44,111.7 57.44,102.29 59.79,99.93 59.79,98.66 61.18,97.27 61.18,97.08 61.18,96.71 61.18,96.71 61.18,90.09 57.63,86.54 57.63,77.97 62.39,73.2 68.4,73.2 70.51,71.09 70.51,66.85 71.19,66.17 71.19,65.48 v1(71.63,65.04)
GPMC0_ADVN_ALE: length 56.8
  TOP w0.147: U23.P16 v1(88.26,72.7)
  L08_SIG2 w0.091: v1(88.26,72.7) 87.86,72.31 87.86,69.37 87.73,69.24 87.55,69.24 87.46,69.15 87.46,68.95 87.55,68.86 88.38,68.86 88.47,68.76 88.47,68.6 88.38,68.51 87.04,68.51 86.95,68.42 86.95,68.26 87.04,68.17 88.38,68.17 88.47,68.07 88.47,67.91 88.38,67.82 87.92,67.82 87.83,67.73 87.83,66.92 87.73,66.83 87.57,66.83 87.48,66.92 87.48,67.73 87.39,67.82 87.04,67.82 86.95,67.73 86.95,67.2 86.86,67.11 85.6,67.11 85.51,67.02 85.51,66.86 85.6,66.76 86.86,66.76 86.95,66.67 86.95,66.51 86.86,66.42 85.6,66.42 85.51,66.33 85.51,66.16 85.6,66.07 86.86,66.07 86.95,65.98 86.95,65.76 87.04,65.67 87.27,65.67 87.35,65.75 87.35,66.21 87.43,66.29 87.54,66.29 87.62,66.21 87.62,65.75 87.7,65.67 88.24,65.67 88.33,65.58 88.33,65.34 88.24,65.25 86.94,65.25 86.85,65.16 86.85,65 86.94,64.91 88.24,64.91 88.36,64.78 88.36,64.29 87.8,63.73 87.8,63.22 87.59,63.02 85.22,63.02 85.13,62.92 85.13,62.76 85.22,62.67 87.59,62.67 87.69,62.58 87.69,62.42 87.59,62.33 85.22,62.33 85.13,62.23 85.13,62.07 85.22,61.98 87.59,61.98 87.69,61.89 87.69,61.73 87.59,61.63 85.22,61.63 85.13,61.54 85.13,61.38 85.22,61.29 87.59,61.29 87.69,61.2 87.69,61.1 87.54,60.95 86.12,60.95 85.48,60.31 84.68,60.31 84.22,59.85 84.22,58.64 83.83,58.25 82.65,58.25 82.23,58.66 82.23,59.45 82.49,59.7 v1(83.31,59.7)
  BOTTOM w0.147: RA6.2 83.31,59.18 v1(83.31,59.7) 83.31,61.47 RA5.7
GPMC0_BE0N_CLE: length 56.9
  TOP w0.147: U23.P17 v1(88.26,71.9)
  L08_SIG2 w0.091: v1(84.86,59.88) 84.78,59.88 84.49,59.59 84.49,58.13 84.58,58.04 84.89,58.04 84.98,58.13 84.98,58.99 85.07,59.09 85.24,59.09 85.33,58.99 85.33,58.13 85.42,58.04 86.12,58.04 86.21,58.13 86.21,58.52 86.01,58.72 85.89,58.72 85.79,58.62 85.66,58.62 85.55,58.74 85.55,58.87 85.64,58.96 85.64,59.09 85.42,59.31 85.42,59.86 85.43,59.87 85.43,59.89 86.17,60.64 87.51,60.64 87.64,60.52 87.64,60.37 87.55,60.28 87.29,60.28 87.2,60.19 87.2,60.03 87.29,59.93 87.55,59.93 87.78,59.7 88.61,59.7 88.7,59.79 88.7,60.96 88.61,61.05 88.07,61.05 87.98,61.14 87.98,61.29 88.07,61.38 88.46,61.38 88.56,61.49 88.56,61.86 88.66,61.95 88.77,61.95 88.86,61.86 88.86,61.43 88.96,61.34 89.12,61.34 89.21,61.43 89.21,61.86 89.3,61.95 89.46,61.95 89.55,61.86 89.55,61.43 89.65,61.34 89.81,61.34 89.9,61.43 89.9,61.86 89.99,61.95 90.42,61.95 90.51,62.04 90.51,62.2 90.42,62.29 88.27,62.29 88.18,62.39 88.18,62.55 88.27,62.64 90.67,62.64 90.76,62.73 90.76,62.89 90.67,62.98 88.27,62.98 88.18,63.08 88.18,63.24 88.27,63.33 91.18,63.33 91.29,63.44 91.29,63.57 91.18,63.68 90.16,63.68 90.07,63.77 90.07,65.23 89.97,65.32 89.81,65.32 89.72,65.23 89.72,63.77 89.63,63.68 88.66,63.68 88.56,63.77 88.56,65.11 88.66,65.2 89.35,65.2 89.44,65.29 89.44,65.46 89.35,65.55 88.66,65.55 88.56,65.64 88.56,66.47 88.73,66.63 88.73,67.14 88.82,67.23 89.42,67.23 89.51,67.32 89.51,67.45 89.39,67.57 88.82,67.57 88.73,67.66 88.73,67.88 88.82,67.97 89.32,67.97 89.41,68.07 89.41,68.23 89.32,68.32 88.76,68.32 88.67,68.41 88.67,68.56 88.76,68.65 89.59,68.65 89.68,68.74 89.68,68.9 89.59,68.99 88.78,68.99 88.67,69.1 88.67,69.25 88.76,69.34 89.59,69.34 89.68,69.43 89.68,69.59 89.59,69.68 88.78,69.68 88.67,69.79 88.67,71.49 v1(88.26,71.9)
  BOTTOM w0.147: RA5.4 84.83,60.96 84.83,60.96 84.83,60.37 84.86,60.34 v1(84.86,59.88) 84.83,59.85 84.83,59.16 RA6.5
GPMC0_BE1N: length 56.9
  TOP w0.147: U23.T19 v1(86.66,70.3)
  L08_SIG2 w0.091: v1(86.66,70.3) 86.66,69.46 80.43,63.23 80.43,58.8 84.52,54.71 88.63,54.71 89.78,55.87 93.18,55.87 93.66,56.34 93.66,59.63 93.35,59.94 92,59.94 91.91,59.85 91.91,59.69 91.82,59.6 91.66,59.6 91.57,59.69 91.57,59.85 91.48,59.94 90.72,59.94 90.36,59.58 90.36,58.71 89.29,57.64 82.74,57.64 81.76,58.62 81.76,59.9 82.38,60.52 82.38,60.77 82.63,61.02 83.27,61.02 83.36,60.92 83.36,60.29 83.64,60.01 84.07,60.01 84.61,60.54 85.04,60.54 v1(85.34,60.85)
  BOTTOM w0.147: RA6.6 85.34,59.17 v1(85.34,60.85) 85.34,61.48 RA5.3
GPMC0_CLK: length 56.8
  TOP w0.147: U23.R17 v1(87.46,71.9)
  L08_SIG2 w0.091: v1(87.46,71.9) 87.46,71.63 87.03,71.2 87.03,70.96 86.99,70.92 86.99,70.86 86.81,70.68 86.5,70.68 86.23,70.4 86.23,70.15 86.05,69.97 86.05,69.17 80.25,63.36 80.25,58.72 84.44,54.53 88.71,54.53 89.87,55.69 93.62,55.69 94.28,56.35 94.28,60.02 93.15,61.15 93.02,61.15 91.99,60.12 90.64,60.12 90.18,59.66 90.18,58.8 89.22,57.84 82.79,57.84 81.94,58.7 81.94,59.73 v1(82.8,60.59)
  BOTTOM w0.147: RA6.1 82.75,60.08 82.8,60.14 v1(82.8,60.59) 82.78,60.62 82.78,61.46 RA5.8
GPMC0_CSN0: length 54.5
  TOP w0.147: U23.R19 v1(87.46,70.3)
  L08_SIG2 w0.091: v1(92.08,58.55) 91.44,59.18 91.06,59.18 90.81,58.93 90.81,57.83 88.73,55.75 87.79,55.75 87.41,56.13 87.41,56.94 87.33,57.02 87.22,57.02 87.14,56.94 87.14,56.04 87.06,55.96 85.65,55.96 85.45,55.75 83.99,55.75 83.9,55.84 83.9,55.96 84.21,56.26 84.21,56.38 84.13,56.46 84.02,56.46 83.71,56.15 83.59,56.15 83.51,56.23 83.51,56.34 83.82,56.65 83.82,56.77 83.74,56.85 83.63,56.85 83.32,56.54 83.21,56.54 83.13,56.62 83.13,56.73 83.43,57.04 83.43,57.15 83.35,57.23 83.24,57.23 82.93,56.93 82.82,56.93 81.39,58.35 81.39,60.8 81.47,60.88 81.47,61.23 80.8,61.9 80.8,63.02 80.94,63.16 81.05,63.16 81.95,62.26 82.07,62.26 82.15,62.34 82.15,62.45 81.24,63.36 81.24,63.47 81.32,63.55 81.44,63.55 82.34,62.64 82.46,62.64 82.54,62.72 82.54,62.84 81.63,63.74 81.63,63.86 81.71,63.94 81.82,63.94 82.73,63.03 82.84,63.03 82.92,63.11 82.92,63.23 82.02,64.13 82.02,64.25 83.07,65.3 83.18,65.3 83.77,64.71 83.89,64.71 83.97,64.79 83.97,64.9 83.38,65.49 83.38,65.61 83.46,65.69 83.57,65.69 84.16,65.1 84.27,65.1 84.36,65.18 84.36,65.29 83.77,65.88 83.77,65.99 83.85,66.07 83.96,66.07 84.55,65.49 84.66,65.49 84.74,65.57 84.74,65.68 84.17,66.25 84.17,66.37 84.39,66.59 84.51,66.59 85.02,66.08 85.13,66.08 85.21,66.16 85.21,66.28 84.7,66.79 84.7,66.9 85.61,67.81 85.72,67.81 86.17,67.36 86.29,67.36 86.37,67.44 86.37,67.56 85.92,68.01 85.92,68.12 86,68.2 86.11,68.2 86.56,67.75 86.67,67.75 86.75,67.83 86.75,67.95 86.31,68.39 86.31,68.51 87.46,69.66 v1(87.46,70.3)
  BOTTOM w0.147: R391.1 R390.1 91.94,58.41 v1(92.08,58.55)
GPMC0_CSN1: length 103.4
  TOP w0.147: U23.R20 88.26,69.5 88.26,67.83 86.42,65.99 v1(86.42,65.19) ; J2.E19 v1(51.69,132.35)
  L03_SIG1 w0.091: v1(86.42,65.19) 86.42,65.85 85.36,66.91 76.48,66.91 75.19,68.2 74.09,68.2 72.85,69.44 72.85,72.92 71.27,74.5 63.2,74.5 61.54,76.16 61.54,85.25 64.28,88 64.28,105.79 63.01,107.07 63.01,117.58 58.7,121.89 54.46,121.89 52.15,124.2 52.15,131.89 v1(51.69,132.35)
GPMC0_CSN2: length 97.7
  TOP w0.147: U23.P19 v1(88.26,70.3) ; J2.D18 v1(52.96,131.08)
  L03_SIG1 w0.091: v1(88.26,70.3) 88.26,69.87 85.53,67.13 78.56,67.13 78.52,67.17 76.48,67.17 73.94,69.71 73.94,72.11 71.33,74.72 63.43,74.72 62.59,75.56 62.59,85.99 64.51,87.91 64.51,105.89 63.23,107.16 63.23,117.66 58.72,122.16 54.44,122.16 52.33,124.28 52.33,130.45 v1(52.96,131.08)
GPMC0_CSN3: length 101.5
  TOP w0.147: v1(85.33,65.42) 87.86,67.95 U23.R21 ; J2.D19 v1(51.69,131.08)
  L03_SIG1 w0.091: v1(51.69,131.08) 50.85,130.24 50.85,123.97 53.11,121.71 58.62,121.71 61.98,118.35 61.98,107.79 64.06,105.7 64.06,88.09 61.32,85.35 61.32,76.07 63.11,74.28 70.8,74.28 72.62,72.46 72.62,68.65 73.26,68.01 75.12,68.01 76.44,66.69 84.06,66.69 v1(85.33,65.42)
GPMC0_DIR: length 99.8
  TOP w0.147: J2.E18 v1(52.96,132.35) ; U23.N17 v1(89.06,71.9)
  L03_SIG1 w0.091: v1(52.96,132.35) 53.42,131.89 53.42,123.84 54.91,122.35 58.8,122.35 63.45,117.7 63.45,107.25 64.73,105.98 64.73,87.82 62.81,85.9 62.81,75.65 63.52,74.94 71.44,74.94 74.14,72.24 74.14,69.77 76.55,67.36 85.07,67.36 87.86,70.14 87.86,71.27 88.09,71.5 88.66,71.5 v1(89.06,71.9)
GPMC0_OEN_REN: length 56.9
  TOP w0.147: U23.R18 v1(87.46,71.1)
  L08_SIG2 w0.091: v1(87.46,71.1) 87.2,70.84 87.2,70.75 87.09,70.64 87.09,69.57 80.61,63.1 80.61,58.87 84.56,54.92 86.67,54.92 86.76,55.02 86.76,55.49 86.85,55.58 87.01,55.58 87.11,55.49 87.11,55.02 87.2,54.92 87.36,54.92 87.45,55.02 87.45,55.49 87.54,55.58 87.7,55.58 87.8,55.49 87.8,55.02 87.89,54.92 88.58,54.92 91.13,57.47 92.65,57.47 92.74,57.56 92.74,59.18 92.51,59.42 91.04,59.42 90.54,58.92 90.54,58.28 89.69,57.43 82.69,57.43 81.57,58.54 81.57,60.36 82.23,61.02 82.23,62.04 82.68,62.48 83.36,62.48 83.82,62.03 v1(83.82,60.47)
  BOTTOM w0.147: RA6.3 83.82,59.17 v1(83.82,60.47) 83.82,61.48 RA5.6
GPMC0_WAIT0: length 56.9
  TOP w0.147: U23.W19 v1(84.26,70.3)
  L08_SIG2 w0.091: v1(85.85,59.72) 85.85,59.14 86.34,58.64 89.61,58.64 89.95,58.99 89.95,60.66 90.36,61.07 92.35,61.07 92.99,61.71 94.03,61.71 94.97,60.77 94.97,59.98 95.22,59.73 96.02,59.73 97.07,58.67 97.07,57.54 93.88,54.35 92.62,54.35 92.53,54.44 92.53,54.58 92.44,54.68 92.28,54.68 92.19,54.58 92.19,54.44 92.1,54.35 91.93,54.35 91.84,54.44 91.84,54.58 91.75,54.68 91.59,54.68 91.5,54.58 91.5,54.44 91.4,54.35 91.24,54.35 91.15,54.44 91.15,54.58 91.06,54.68 90.9,54.68 90.8,54.58 90.8,54.44 90.71,54.35 84.36,54.35 80.04,58.67 80.04,64.62 81.2,65.78 82.29,65.78 85.47,68.96 85.47,69.72 85.26,69.93 84.63,69.93 v1(84.26,70.3)
  BOTTOM w0.147: RA6.7 85.85,59.18 v1(85.85,59.72) 85.85,61.47 RA5.2
GPMC0_WAIT1: length 56.7
  TOP w0.147: U23.Y18 v1(83.46,71.1)
  L08_SIG2 w0.091: v1(83.46,71.1) 83.89,70.68 83.89,70.15 84.31,69.73 84.7,69.73 84.96,69.47 84.96,68.96 81.99,65.98 81.14,65.98 79.86,64.69 79.86,58.59 84.29,54.16 93.96,54.16 97.52,57.72 97.52,58.68 94.31,61.89 92.92,61.89 92.31,61.29 90.31,61.29 89.77,60.75 89.77,59.07 89.53,58.83 86.78,58.83 86.49,59.12 v1(86.49,60.21)
  BOTTOM w0.147: RA5.1 86.42,60.96 86.49,60.9 v1(86.49,60.21) 86.49,59.7 86.42,59.64 RA6.8
GPMC0_WEN: length 56.6
  TOP w0.147: v1(84.33,60.9) 84.33,58.76 84.18,58.61 82.74,58.61 82.62,58.49 82.62,58.33 82.74,58.21 84.21,58.21 84.33,58.09 84.33,57.93 84.21,57.81 82.74,57.81 82.62,57.69 82.62,57.53 82.74,57.41 84.21,57.41 84.33,57.29 84.33,57.12 84.21,57.01 82.74,57.01 82.62,56.89 82.62,56.72 82.74,56.61 84.21,56.61 84.33,56.49 84.33,56.32 84.21,56.2 82.74,56.2 82.62,56.09 82.62,55.92 82.74,55.8 84.21,55.8 84.33,55.69 84.33,55.52 84.21,55.4 82.74,55.4 82.62,55.28 82.62,55.12 82.74,55 84.21,55 84.33,54.88 84.33,54.72 84.21,54.6 82.74,54.6 82.62,54.48 82.62,54.32 82.74,54.2 84.21,54.2 84.33,54.08 84.33,53.34 83.41,52.42 79.68,52.42 78.59,53.52 78.59,59.14 79.27,59.82 79.27,64.03 80.14,64.89 83.92,64.89 87.06,68.02 U23.T21
  BOTTOM w0.147: RA6.4 84.33,60.39 84.33,60.39 v1(84.33,60.9) 84.33,60.9 84.33,61.49 RA5.5
GPMC0_WPN: length 54.4
  TOP w0.147: U23.N16 v1(89.06,72.7)
  L08_SIG2 w0.091: v1(88.11,59.25) 88.81,59.25 88.91,59.35 88.91,60.77 89.16,61.02 89.79,61.02 91.4,62.63 92.15,62.63 92.23,62.71 92.23,63.8 92.31,63.88 92.43,63.88 92.51,63.8 92.51,62.71 92.59,62.63 92.7,62.63 92.78,62.71 92.78,63.8 92.86,63.88 92.98,63.88 93.06,63.8 93.06,62.71 93.14,62.63 93.4,62.63 93.48,62.71 93.48,63.67 93.56,63.75 93.68,63.75 93.76,63.67 93.76,62.71 93.84,62.63 94.04,62.63 94.12,62.71 94.12,64.18 94.2,64.26 94.31,64.26 94.39,64.18 94.39,62.71 94.47,62.63 95.03,62.63 95.12,62.72 95.12,64.39 94.94,64.58 92.36,64.58 92.27,64.67 92.27,64.8 92.33,64.87 92.64,64.87 92.72,64.95 92.72,65.71 92.8,65.79 92.91,65.79 92.99,65.71 92.99,64.95 93.07,64.87 93.92,64.87 94,64.95 94,65.58 94.08,65.66 94.19,65.66 94.27,65.58 94.27,64.95 94.35,64.87 94.47,64.87 94.55,64.95 94.55,65.58 94.63,65.66 94.74,65.66 94.82,65.58 94.82,64.95 94.9,64.87 95.03,64.87 95.12,64.96 95.12,65.79 94.62,66.29 94.06,66.29 93.65,65.88 93.3,65.88 93.05,66.13 93.05,66.57 92.38,67.24 92.26,67.24 91.24,66.22 91.13,66.22 91.05,66.3 91.05,66.42 92.07,67.44 92.07,67.55 91.92,67.7 91.81,67.7 91.42,67.32 91.31,67.32 91.23,67.4 91.23,67.51 91.61,67.89 91.61,68.01 91.53,68.09 91.42,68.09 91.03,67.7 90.92,67.7 90.84,67.78 90.84,67.9 91.22,68.28 91.22,68.4 90.99,68.63 90.88,68.63 89.86,67.61 89.75,67.61 89.67,67.69 89.67,67.8 90.69,68.82 90.69,68.93 89.47,70.15 89.46,70.15 89.46,72.31 v1(89.06,72.7)
  BOTTOM w0.147: v1(88.11,59.25) R393.1 R392.1
HSE_DETECT: length 55.8
  TOP w0.147: J2.E4 v1(70.74,132.35)
  L03_SIG1 w0.091: v1(115.13,118.81) 94,118.81 88.64,124.16 85.67,124.16 83.22,126.61 79.74,126.61 77.06,129.28 77.06,129.94 75.48,131.52 71.57,131.52 v1(70.74,132.35)
  BOTTOM w0.147: v1(115.13,118.81) 115.02,118.7 R224.1 112.26,118.7 112.08,118.88 U66.4
HSE_GPIO0_31: length 93.6
  TOP w0.147: J2.B22 v1(47.88,128.54)
  L03_SIG1 w0.091: v1(83.27,64.38) 82.11,63.22 81.15,63.22 79.38,61.45 69.34,61.45 67.73,63.06 67.73,63.98 54.54,77.18 54.54,112.38 52.08,114.84 52.08,120.67 47.88,124.87 v1(47.88,128.54)
  BOTTOM w0.147: RA5.9 82.74,63.86 v1(83.27,64.38)
HSE_GPIO0_32: length 94.3
  TOP w0.147: J2.C22 v1(47.88,129.81)
  L03_SIG1 w0.091: v1(47.88,129.81) 47.4,129.33 47.4,125.09 51.87,120.62 51.87,114.74 54.32,112.29 54.32,77.08 54.45,76.95 67.51,63.89 67.51,62.94 69.21,61.23 79.47,61.23 81.24,63 82.82,63 v1(83.33,63.51)
  BOTTOM w0.147: RA5.10 v1(83.33,63.51)
HSE_GPIO0_33: length 100.4
  TOP w0.147: J2.D22 v1(47.88,131.08)
  L03_SIG1 w0.091: v1(84.36,64.38) 83.9,63.92 83.9,63.19 83.49,62.78 81.34,62.78 78.76,60.21 68.59,60.21 66.6,62.19 66.6,64.49 54.36,76.73 54.1,76.99 54.1,112.2 51.69,114.61 51.69,120.55 47.22,125.02 47.22,130.42 v1(47.88,131.08)
  BOTTOM w0.147: v1(84.36,64.38) 83.83,63.86 RA5.11
HSE_GPIO0_34: length 98.6
  TOP w0.147: J2.C23 v1(46.61,129.81)
  L03_SIG1 w0.091: v1(84.33,63.51) 84.33,63.08 83.81,62.56 81.43,62.56 78.85,59.99 67.17,59.99 65.53,61.63 65.53,65.24 54.26,76.51 53.88,76.9 53.88,102.48 52.83,103.52 52.83,113.21 51.51,114.53 51.51,120.47 47.04,124.94 47.04,129.38 v1(46.61,129.81)
  BOTTOM w0.147: v1(84.33,63.51) RA5.12
HSE_GPIO0_35: length 102
  TOP w0.147: J2.B24 v1(45.34,128.54)
  L03_SIG1 w0.091: v1(45.34,128.54) 45.77,128.11 45.77,124.75 49.66,120.87 49.66,115.21 51.76,113.11 51.76,102.33 52.02,102.06 52.76,102.06 53.65,101.17 53.65,76.81 54.17,76.29 64.39,66.07 64.39,61.99 66.61,59.77 78.95,59.77 81.52,62.34 84.79,62.34 84.9,62.45 84.9,63.92 v1(85.36,64.38)
  BOTTOM w0.147: RA5.13 84.83,63.86 v1(85.36,64.38)
HSE_GPIO0_36: length 13.3
  TOP w0.147: J2.A20 49.78,125.28 52.91,122.16 58.12,122.16 59.03,121.24 U8.19
HSE_GPIO0_36/FSI_TX0_CLK: length 91
  TOP w0.147: U8.9 57.54,115.22 57.55,115.2 57.55,114.75 57.53,114.73 57.53,114.57 55.45,112.49 51.55,112.49 v1(51.23,112.81)
  L03_SIG1 w0.091: v1(85.33,63.51) 85.33,62.36 84.96,61.99 83.27,61.99 80.83,59.54 64.91,59.54 63.12,61.34 63.12,67.03 54.08,76.07 53.43,76.72 53.43,100 52.26,101.17 52.26,101.42 51.23,102.46 v1(51.23,112.81)
  BOTTOM w0.147: RA5.14 v1(85.33,63.51)
HSE_GPIO0_37: length 106.1
  TOP w0.147: J2.C24 v1(45.34,129.81)
  L03_SIG1 w0.091: v1(45.34,129.81) 44.91,129.38 44.91,125.26 49.4,120.77 49.4,113.78 51.01,112.18 51.01,101.85 53.21,99.64 53.21,76.63 53.99,75.85 62.89,66.95 62.89,61.25 64.82,59.32 80.92,59.32 83.3,61.7 85.41,61.7 85.98,62.28 85.98,64.01 v1(86.36,64.38)
  BOTTOM w0.147: v1(86.36,64.38) 85.83,63.86 RA5.15
HSE_GPIO0_38: length 110.2
  TOP w0.147: J2.E26 v1(42.8,132.35)
  L03_SIG1 w0.091: v1(42.8,132.35) 43.41,131.74 43.41,124.58 47.06,120.93 47.06,116.78 48.51,115.33 48.51,114.36 50.79,112.09 50.79,101.76 50.95,101.59 52.99,99.55 52.99,76.53 53.9,75.63 62.67,66.85 62.67,61.16 64.76,59.07 86.23,59.07 86.92,59.76 86.92,62 86.42,62.5 v1(86.42,63.51)
  BOTTOM w0.147: RA5.16 v1(86.42,63.51)
HSE_GPIO0_39: length 106.5
  TOP w0.147: J2.C26 v1(42.8,129.81)
  L03_SIG1 w0.091: v1(42.8,129.81) 42.34,129.35 42.34,123.64 42.9,123.08 44.32,123.08 46.61,120.8 46.61,115.58 50.34,111.85 50.34,101.09 51.77,99.67 51.77,92.08 52.48,91.36 52.48,76.42 52.55,76.35 62.23,66.67 62.23,60.98 64.58,58.63 86.45,58.63 v1(88.11,56.97)
HSE_GPIO0_41: length 110.2
  TOP w0.147: J2.D26 v1(42.8,131.08)
  L03_SIG1 w0.091: v1(42.8,131.08) 43.23,130.65 43.23,124.51 46.84,120.89 46.84,115.66 50.56,111.94 50.56,101.18 51.99,99.76 51.99,92.17 52.7,91.45 52.7,76.51 52.77,76.44 62.45,66.76 62.45,61.07 64.67,58.85 86.54,58.85 87.84,57.55 91.35,57.55 v1(91.94,56.97)
HSE_MCAN0_RX/UART4_TXD: length 17.3
  TOP w0.147: J2.E24 v1(45.34,132.35)
  L03_SIG1 w0.091: v1(47.74,118.91) 47.74,120.6 44.5,123.85 44.5,131.51 v1(45.34,132.35)
  BOTTOM w0.147: U67.3 47.83,119 v1(47.74,118.91)
HSE_MCAN0_TX/UART4_RXD: length 18.1
  TOP w0.147: J2.D24 v1(45.34,131.08)
  L03_SIG1 w0.091: v1(47.74,117.01) 48.17,117.44 48.17,120.55 44.68,124.04 44.68,130.42 v1(45.34,131.08)
  BOTTOM w0.147: U67.6 47.78,117.05 v1(47.74,117.01)
HSE_MCAN1_RX/I2C3_SDA: length 17
  TOP w0.147: J2.C29 v1(38.99,129.81)
  L03_SIG1 w0.091: v1(38.99,129.81) 38.53,129.35 38.53,121.33 41.66,118.2 v1(41.66,116.6)
  BOTTOM w0.147: v1(41.66,116.6) 41.86,116.4 U67.10
HSE_MCAN1_TX/I2C3_SCL: length 18.3
  TOP w0.147: J2.D29 v1(38.99,131.08)
  L03_SIG1 w0.091: v1(40.5,117.7) 40.5,118.77 38.18,121.1 38.18,121.23 38.18,130.27 v1(38.99,131.08)
  BOTTOM w0.147: U67.13 41.15,118.35 v1(40.5,117.7)
HSE_PRG0_PRU0_GPO9: length 42.3
  TOP w0.147: J2.D28 v1(40.26,131.08)
  L03_SIG1 w0.091: v1(40.26,131.08) 39.83,130.65 39.83,125.98 41.13,124.69 41.13,122.21 42.17,121.17 44.48,121.17 44.49,121.18 45.34,120.33 45.34,115.29 46.74,113.9 46.74,98.53 47.28,97.99 48.95,97.99 v1(49.02,98.06)
  BOTTOM w0.147: U75.33 49.92,97.53 49.39,98.06 v1(49.02,98.06)
HSE_PRG0_PRU0_GPO10: length 40.8
  TOP w0.147: J2.B29 v1(38.99,128.54)
  L03_SIG1 w0.091: v1(38.99,128.54) 38.99,126.15 40.03,125.11 40.03,122.54 41.61,120.97 44.44,120.97 45.12,120.29 45.12,115.2 46.55,113.77 46.55,98.46 47.97,97.04 v1(49.02,97.04)
  BOTTOM w0.147: v1(49.02,97.04) 49.54,96.53 U75.31
HSE_PRG0_PRU1_GPO7: length 34.6
  TOP w0.147: J2.D23 v1(46.61,131.08)
  L03_SIG1 w0.091: v1(53.2,102.5) 52.42,103.28 52.42,113.36 51.32,114.46 51.32,120.4 46.14,125.58 46.14,130.61 v1(46.61,131.08)
  BOTTOM w0.147: U75.42 v1(53.2,102.5)
HSE_PRG0_PRU1_GPO9: length 35.6
  TOP w0.147: J2.E23 v1(46.61,132.35)
  L03_SIG1 w0.091: v1(46.61,132.35) 45.95,131.69 45.95,124.98 49.91,121.02 49.91,115.26 52.2,112.97 v1(52.2,102.5)
  BOTTOM w0.147: 52.2,100.48 v1(52.2,102.5)
HSE_PRG0_PRU1_GPO10: length 40.1
  TOP w0.147: J2.E27 v1(41.53,132.35)
  L03_SIG1 w0.091: v1(49.04,100.09) 49.04,101.85 47.16,103.73 47.16,114.1 45.79,115.46 45.79,120.44 44.53,121.71 42.16,121.71 41.5,122.37 41.5,124.83 40.87,125.46 40.87,131.69 v1(41.53,132.35)
  BOTTOM w0.147: U75.37 50.06,99.53 50.04,99.55 49.58,99.55 v1(49.04,100.09)
HSE_PRG0_PRU1_GPO17: length 39.1
  TOP w0.147: J2.C28 v1(40.26,129.81)
  L03_SIG1 w0.091: v1(40.26,129.81) 40.69,129.38 40.69,125.39 41.31,124.76 41.31,122.29 42.17,121.43 44.5,121.43 45.57,120.36 45.57,115.37 46.98,113.97 46.98,103.28 47.9,102.36 47.9,99.37 48.19,99.07 v1(49.02,99.07)
  BOTTOM w0.147: v1(49.02,99.07) 49.26,99.07 49.81,98.53 U75.35
HSE_PRG0_PRU1_GPO18: length 68.2
  TOP w0.147: J2.D27 v1(41.53,131.08)
  L03_SIG1 w0.091: v1(41.53,131.08) 41.05,130.6 41.05,125.54 41.73,124.86 41.73,122.47 42.28,121.92 44.57,121.92 46.04,120.45 46.04,115.53 49.06,112.51 49.06,107.26 49.47,106.84 49.47,99.89 49.71,99.65 50.47,99.65 50.93,99.2 50.93,77.36 49.78,76.21 49.78,75.07 v1(48.13,73.42)
  BOTTOM w0.147: U78.3 47.62,73.93 v1(48.13,73.42)
HSE_PRG0_PRU1_GPO19: length 62.9
  TOP w0.147: J2.C27 v1(41.53,129.81)
  L03_SIG1 w0.091: v1(41.53,129.81) 41.96,129.38 41.96,123.56 42.62,122.9 44.25,122.9 46.35,120.79 46.35,115.53 49.28,112.61 49.28,107.35 50.12,106.5 50.12,101 51.54,99.58 51.54,91.54 52.26,90.82 52.26,76.69 52.26,76.69 52.26,76.41 52.07,76.21 v1(52.07,75.96)
  BOTTOM w0.147: v1(52.07,75.96) 51.44,75.33 51.44,74.76 51.1,74.43 U78.7
IFORCE: length 5.3
  TOP w0.147: U23.H16 v1(93.86,72.7)
  BOTTOM w0.114: v1(93.86,72.7) 94.26,72.3 94.26,70.14 95.26,69.14 TP71.1
IN_SEL0: length 2.6
  TOP w0.147: R40.2 v1(55.88,106.95)
  BOTTOM w0.147: U70.30 56.45,107.06 56.33,106.95 v1(55.88,106.95) R40.2
IN_SEL1: length 3.2
  TOP w0.147: R45.1 v1(55.88,105.68)
  BOTTOM w0.147: U70.29 56.31,106.56 55.88,106.13 v1(55.88,105.68) R45.1
INA_ALERT: length 142.2
  TOP w0.147: 142.95,115.64 142.95,108.73 143,108.73 v1(143.79,107.94) 142.95,107.1 142.95,106.51 142.37,105.93 137.72,105.93 137.41,105.63 R48.2 R47.1 134.51,105.15 132.63,107.04 125.73,107.04 125.62,106.93 R43.2 ; 142.95,115.64 136.78,121.81 J4.4 ; 142.95,115.64 143.89,116.58 149.5,116.58 149.97,116.11 R28.2 ; R1.2 v1(86.36,132.22) ; R122.2 v1(137.56,74.55)
  L03_SIG1 w0.091: v1(143.79,107.94) 143.79,107.48 144.12,107.15 144.12,96.5 138.3,90.68 138.3,75.29 v1(137.56,74.55) ; J4.4 134.67,126.84 96.24,126.84 91.36,131.71 90.17,131.71 89.61,132.28 86.85,132.28 86.79,132.22 v1(86.36,132.22)
  BOTTOM w0.147: v1(143.79,107.94) 144.24,107.94 144.4,108.09 R244.2
IO_EXP_INTN_SDIO: length 72.2
  TOP w0.147: v1(98.3,63.26) 98.3,64.18 97.06,65.41 97.06,69.5 U23.C20 ; v1(59.45,29.75) 59.98,29.22 60.83,29.22 62.36,30.75 62.36,32.91 63.25,33.8 78.11,33.8 91.44,47.13 92.46,47.13 93.8,48.47 93.8,49.36 93.47,49.68 93.47,51.12 93.6,51.25 v1(93.6,51.7)
  L08_SIG2 w0.091: v1(98.3,63.26) 99.06,62.5 99.06,56.39 94.38,51.7 v1(93.6,51.7)
  BOTTOM w0.147: v1(59.45,29.75) R465.1 58.9,30.37 58.74,30.53 58.74,31.21 58.54,31.41 U91.32
JTAG_CTI_RTCK: length 31.4
  TOP w0.147: v1(70.1,50.18) 70.61,49.67 J25.9
  L08_SIG2 w0.091: v1(70.1,50.18) 70.48,49.8 70.48,46.17 77.64,39.02 77.64,34.82 81.05,31.41 v1(81.05,27.83)
  BOTTOM w0.147: R491.1 v1(81.05,27.83)
JTAG_CTI_TCK: length 34.6
  TOP w0.147: v1(70,49.04) 69.68,48.72 69.56,48.72 69.34,48.5 J25.11 ; U53.2 R190.1 R188.1 v1(76.16,29.48)
  L03_SIG1 w0.091: v1(70,49.04) 70,48.6 69.98,48.58 69.98,46.62 70.48,46.12 70.48,31.64 72.64,29.48 v1(76.16,29.48)
  BOTTOM w0.147: U53.2 78.26,28.82 77.59,29.48 v1(76.16,29.48)
JTAG_DIR: length 3.2
  TOP w0.147: U37.3 87.69,51.62 R148.2 88.16,51.49 88.19,51.46 U37.2
JTAG_EMU0: length 53.6
  TOP w0.147: U48.8 96.37,30.89 v1(96.63,31.15) ; v1(96.63,34.7) 96.37,34.44 U45.8 ; v1(69.09,49.04) 68.58,49.04 68.07,48.53 J25.13
  L03_SIG1 w0.091: v1(69.09,49.04) 69.53,49.48 70.29,49.48 72.7,47.08 72.7,36.98 75.75,33.92 77.7,33.92 80.75,30.88 91.13,30.88 92.66,32.4 93.47,32.4 95.78,34.7 v1(96.63,34.7)
  BOTTOM w0.147: v1(96.63,34.7) 96.17,34.7 96.11,34.76 R455.2 95.41,32.36 v1(96.63,31.15)
JTAG_EMU1: length 45.1
  TOP w0.147: U48.1 98.2,30.89 v1(97.94,31.15) ; v1(97.79,34.56) 98.2,34.56 98.31,34.44 U45.1 ; v1(72.26,37.1) 69.33,37.1 68.18,38.26 68.18,39.57 68.07,39.68 J25.14
  L03_SIG1 w0.091: v1(97.79,34.56) 93.75,30.52 80.79,30.52 77.84,33.48 75.89,33.48 v1(72.26,37.1)
  BOTTOM w0.147: v1(97.94,31.15) 99.06,32.27 99.06,34.32 R458.2 98.32,34.48 98.24,34.56 v1(97.79,34.56)
JTAG_EMU_RSTN: length 142.1
  TOP w0.147: v1(65.53,35.64) 62.68,38.5 62.68,48.97 63.89,50.18 66.06,50.18 66.66,49.58 R150.2 66.66,48.95 66.8,48.81 J25.15 ; v1(113.64,27.6) 113.64,28.44 115.24,30.04 124.11,30.04 125.6,31.54 125.6,42.18 130.68,47.26 134.11,47.26 134.75,46.62 137.97,46.62 139.56,45.03 U41.6
  L03_SIG1 w0.091: v1(113.64,27.6) 108.76,22.72 108.76,17.72 102.87,11.83 94.23,11.83 89.92,16.14 79.61,16.14 79.36,16.4 69.11,16.4 67.61,17.9 67.61,33.57 v1(65.53,35.64)
  BOTTOM w0.147: R449.1 v1(65.53,35.64)
JTAG_MIPI_EMU0: length 35
  TOP w0.147: U48.5 96.37,32.39 v1(96.63,32.13)
  L03_SIG1 w0.091: v1(72.14,38.24) 71.83,37.93 71.83,36.27 74.84,33.26 77.75,33.26 80.7,30.3 94.8,30.3 v1(96.63,32.13)
  BOTTOM w0.147: R461.2 v1(96.63,32.13) ; v1(72.14,38.24) 71.72,38.66 71.72,39.19 71.71,39.2 71.71,39.57 71.72,39.58 J33.38
JTAG_MIPI_EMU1: length 37.1
  TOP w0.147: U48.4 98.2,32.39 v1(97.94,32.13)
  L03_SIG1 w0.091: v1(72.17,39.38) 71.61,38.82 71.61,36.17 74.74,33.03 77.66,33.03 80.61,30.08 96.49,30.08 97.5,31.1 97.5,31.69 v1(97.94,32.13)
  BOTTOM w0.147: R460.2 v1(97.94,32.13) ; J33.40 72.26,41.17 72.26,39.48 v1(72.17,39.38)
JTAG_MIPI_RTCK: length 33.9
  L08_SIG2 w0.091: v1(75.31,27.7) 75.18,27.83 73.41,27.83 71.25,29.99 64.8,29.99 63.25,31.54 63.25,33.92 63.63,34.3 63.63,36.21 64.14,36.72 v1(64.14,48.78)
  BOTTOM w0.147: R492.1 75.31,27.17 v1(75.31,27.7) ; J33.7 64.22,48.7 v1(64.14,48.78)
JTAG_MIPI_TCK: length 35.8
  TOP w0.147: v1(70.58,29.48) R187.1 R189.1 U52.2
  L08_SIG2 w0.091: v1(63.14,48.78) 63.14,37.37 62.48,36.72 62.48,31.64 64.64,29.48 v1(70.58,29.48)
  BOTTOM w0.147: J33.3 63.22,48.7 v1(63.14,48.78) ; v1(70.58,29.48) 71.8,29.48 72.67,28.62 U52.2
JTAG_MUX_SEL: length 15.4
  TOP w0.147: U60.1 v1(98.2,14.08)
  BOTTOM w0.147: J29.2 100.06,12.21 v1(98.2,14.08)
JTAG_TCK: length 52.3
  TOP w0.147: U37.12 v1(86.69,46.28) ; v1(97.18,12.78) 97.83,12.13 U60.4
  L03_SIG1 w0.091: v1(86.69,46.28) 87.16,46.75 88.14,46.75 90.08,44.81 90.08,41.08 95.36,35.8 97.44,35.8 97.88,35.36 100.04,35.36 102.42,32.98 102.42,31.95 102.68,31.69 103.2,31.69 103.38,31.51 103.38,25.47 101.78,23.87 101.78,15.31 98.81,12.34 97.62,12.34 v1(97.18,12.78)
JTAG_TDI: length 28.9
  TOP w0.147: 75.06,49.16 75.06,50.05 74.17,50.94 64.26,50.94 v1(63.37,51.83) ; 75.06,49.16 74.42,48.53 J25.3 ; 75.06,49.16 81.66,49.16 84.33,46.5 85.34,46.5 85.69,46.84 U37.10
  BOTTOM w0.147: R410.2 v1(63.37,51.83)
JTAG_TDIS: length 2.9
  TOP w0.147: J25.4 R177.2
JTAG_TDO: length 58.5
  TOP w0.147: U46.7 90.48,36.39 90.72,36.63 91.36,36.63 91.82,37.09 91.82,38.11 91.44,38.5 v1(83.82,38.5) ; J25.7 v1(71.88,49.29)
  L03_SIG1 w0.091: v1(64.26,35.64) 64.83,36.21 68.6,36.21 69.6,37.2 69.6,39.89 68.55,40.94 68.55,49.1 69.19,49.74 71.43,49.74 v1(71.88,49.29)
  BOTTOM w0.147: v1(83.82,38.5) 81.62,36.29 71.2,36.29 69.88,34.98 64.93,34.98 v1(64.26,35.64) R450.1
JTAG_TMS: length 52.7
  TOP w0.147: J25.1 83.15,46.66 84.54,45.26 v1(85.69,45.26) 85.69,45.32 86.19,45.82 U37.11
  L03_SIG1 w0.091: v1(85.69,45.26) 80.23,50.73 69.87,50.73 68.33,49.18 68.33,40.91 68.36,40.87 68.36,40.87 69.38,39.85 69.38,37.64 68.2,36.46 63.81,36.46 v1(62.99,35.64)
  BOTTOM w0.147: R451.1 v1(62.99,35.64)
JTAG_TRST#: length 30.8
  TOP w0.147: v1(66.8,35.64) 67.26,35.19 74.8,35.19 75.69,36.08 J25.2 75.69,42.71 76.94,43.96 85.38,43.96 87.19,45.76 U37.13
  BOTTOM w0.147: R448.1 v1(66.8,35.64)
LED1: length 3
  TOP w0.147: U34.3 45.59,47.47 45.09,46.96 LD16.1
LED2: length 2.9
  TOP w0.147: U34.4 46.86,47.21 47.12,46.96 LD17.1
LED3: length 3.3
  TOP w0.147: U34.5 48.13,47.77 48.58,47.32 48.78,47.32 49.15,46.96 LD18.1
LED4: length 4.1
  TOP w0.147: U34.6 49.4,47.64 49.78,47.26 50.8,47.26 51.18,46.88 LD19.1
LED5: length 3.4
  TOP w0.147: LD14.1 50.42,56.96 49.4,55.94 U34.11
LED6: length 3.1
  TOP w0.147: LD13.1 48.39,56.03 48.13,55.78 U34.12
LED7: length 3.2
  TOP w0.147: U34.13 46.86,56.02 46.35,56.53 LD12.1
LED8: length 3.9
  TOP w0.147: LD11.1 44.32,56.66 44.58,56.4 45.21,56.4 45.59,56.02 U34.14
LM5140_COMP1: length 6.8
  TOP w0.147: C135.1 154.03,57.94 R142.2 154.03,59.16 154.44,59.58 155.58,59.58 156.2,58.96 157.81,58.96 158.34,59.48 U30.29
LM5140_COMP2: length 4
  TOP w0.147: U30.2 166.63,59.48 166.94,59.16 R141.2 168.18,59.16 168.2,59.14 C130.1
MCAN0_H: length 7.8
  TOP w0.104: J31.1 22.48,129.43 22.48,128.16 R4.1 22.48,127.4 22.48,126.99 22.37,126.88 22.07,126.88 21.97,126.78 U4.7
MCAN0_L: length 7.8
  TOP w0.104: U4.6 23.24,126.78 23.13,126.88 22.83,126.88 22.73,126.99 22.73,127.4 R5.2 22.73,128.16 22.73,129.42 J31.3
MCAN0_RX: length 41.8
  L08_SIG2 w0.091: J9.1 27.1,117.16 27.1,117.98 28.31,119.19 40.29,119.19 41.09,118.4 41.82,118.4 45.13,115.09 50.05,115.09 51.31,116.35 51.31,118.52 v1(50.66,119.17)
  BOTTOM w0.147: J9.1 24.51,115.7 24.13,116.08 24.13,118.12 24.51,118.5 R220.1 ; U67.2 50.18,119.65 v1(50.66,119.17)
MCAN0_RX/HSE: length 123.1
  TOP w0.147: v1(72.9,115.2) 78.36,115.2 79.37,114.18 97.49,114.18 107.49,104.18 107.49,92.29 112.49,87.3 112.49,82.65 115.39,79.74 115.39,70.01 113.13,67.75 111.6,67.75 111.3,67.44 105.28,67.44 103.83,68.88 103.83,69.16 103.38,69.61 101.99,69.61 101.25,70.35 101.25,71.31 99.86,72.7 98.66,72.7 U23.B17
  BOTTOM w0.147: v1(72.9,115.2) 71.87,116.22 60.96,116.22 59.69,117.49 54.22,117.49 53.36,118.35 U67.4
MCAN0_STB_3V3: length 119.8
  TOP w0.381: v1(19.05,126.51) 19.05,126.5 R9.2 U4.8
  L03_SIG1 w0.091: v1(51.07,31.41) 50.7,31.41 50.37,31.75 50.37,32.49 46.34,36.52 46.34,40.63 46.34,40.63 46.34,44.68 39.88,51.14 39.88,63.01 39.63,63.26 39.63,69.93 38.73,70.82 38.73,77.92 37.97,78.69 37.97,87.48 37.03,88.43 37.03,91.89 33.78,95.14 33.78,108.8 34.67,109.68 34.67,113.55 35.69,114.57 35.69,119.54 30.88,124.35 21.21,124.35 v1(19.05,126.51)
  BOTTOM w0.147: U91.9 v1(51.07,31.41)
MCAN0_T: length 8
  TOP w0.147: R5.1 v1(24.89,127.78) ; R4.2 C2.1 v1(19.92,128.52)
  BOTTOM w0.147: v1(24.89,127.78) 20.66,127.78 v1(19.92,128.52)
MCAN0_TX: length 41.5
  L08_SIG2 w0.091: J9.2 24.82,117.42 25.21,117.42 27.23,119.43 40.62,119.43 41.33,118.73 41.82,118.73 45.23,115.31 49.89,115.31 50.79,116.21 v1(50.79,117.14)
  BOTTOM w0.147: v1(50.79,117.14) 50.23,117.7 U67.5 ; J9.2 21.97,116.47 20.7,117.74 R221.1
MCAN0_TX/HSE: length 122.2
  TOP w0.147: v1(71.63,115.71) 73.28,115.71 73.41,115.58 78.38,115.58 79.49,114.48 97.61,114.48 108.08,104.01 108.08,92.12 112.78,87.42 112.78,82.77 115.69,79.87 115.69,69.89 113.26,67.45 111.73,67.45 111.42,67.14 105.06,67.14 102.94,69.27 101.91,69.27 100.97,70.22 100.97,71.19 99.85,72.3 U23.A17
  BOTTOM w0.147: v1(71.63,115.71) 56.9,115.71 56.01,116.6 54.48,116.6 54.28,116.4 U67.7
MCAN1_H: length 7.8
  TOP w0.104: U3.7 12.07,126.78 12.17,126.88 12.47,126.88 12.57,126.99 12.57,127.4 R2.1 12.57,128.15 12.57,129.43 J32.1
MCAN1_L: length 7.8
  TOP w0.104: 13.34,125.78 13.34,126.78 13.23,126.88 12.93,126.88 12.83,126.99 12.83,127.4 R3.2 12.82,128.16 12.82,129.42 J32.3
MCAN1_RX: length 40.7
  L08_SIG2 w0.091: v1(44.15,117.05) 42.09,119.11 41.41,119.11 40.79,119.73 19.39,119.73 J10.1
  BOTTOM w0.147: U67.11 v1(44.15,117.05) ; J10.1 13.84,115.44 14.6,116.2 R222.1
MCAN1_RX/HSE: length 90.4
  TOP w0.147: U23.D17 v1(97.06,71.9)
  L03_SIG1 w0.091: v1(77.53,96.34) 78.93,94.95 78.93,84.73 81.66,82 81.66,81.16 84.11,78.71 89.18,78.71 89.43,78.46 89.43,75.75 89.2,75.52 88.95,75.52 88.69,75.26 88.69,72.55 88.93,72.31 96.58,72.31 96.98,71.9 v1(97.06,71.9)
  BOTTOM w0.147: U67.9 45.55,115.75 46.99,114.31 54.23,114.31 55.24,113.3 71.5,113.3 77.09,107.71 77.09,96.79 v1(77.53,96.34)
MCAN1_STB_3V3: length 131.1
  TOP w0.381: U3.8 R8.2 9.14,126.5 v1(9.15,126.51)
  L03_SIG1 w0.091: v1(9.15,126.51) 11.56,124.09 29.73,124.09 35.45,118.38 35.45,114.97 33.73,113.24 33.73,111.58 34.36,110.94 34.36,109.69 33.56,108.89 33.56,94.98 36.03,92.51 36.03,88.43 36.56,87.9 37.08,87.9 37.75,87.23 37.75,78.59 38.51,77.83 38.51,63.74 39.66,62.59 39.66,51.05 42.18,48.53 42.18,45.07 43.69,43.56 43.69,39.37 44.58,38.48 44.58,37.97 50.14,32.41 50.14,31.41 50.68,30.88 51.31,30.88 51.69,31.26 51.69,31.81 v1(51.82,31.94)
  BOTTOM w0.147: U91.10 51.84,31.91 v1(51.82,31.94)
MCAN1_T: length 8
  TOP w0.147: R3.1 v1(14.99,127.78) ; R2.2 C1.1 v1(10.01,128.52)
  BOTTOM w0.147: v1(10.01,128.52) 10.76,127.78 v1(14.99,127.78)
MCAN1_TX: length 43.4
  L08_SIG2 w0.091: J10.2 17.2,120.09 43.14,120.09 v1(44.44,118.79)
  BOTTOM w0.147: U67.14 44.23,119 v1(44.44,118.79) ; R223.1 10.8,115.95 11.3,115.44 J10.2
MCAN1_TX/HSE: length 93.6
  TOP w0.147: U23.C17 v1(97.86,71.9)
  L03_SIG1 w0.091: v1(77.54,97.42) 79.15,95.82 79.15,84.82 82.04,81.93 82.04,81.58 84.11,79.52 89.99,79.52 90.27,79.23 90.27,75.78 89.98,75.49 89.7,75.49 89.48,75.26 89.48,73.27 89.64,73.11 96.4,73.11 96.66,72.85 96.66,72.57 96.92,72.31 97.46,72.31 v1(97.86,71.9)
  BOTTOM w0.147: U67.12 45.51,117.7 46.23,116.98 46.23,115.58 46.99,114.82 54.36,114.82 55.5,113.68 57.4,113.68 58.17,114.44 70.99,114.44 77.54,107.89 v1(77.54,97.42)
MCU_GPIO0_6: length 161.9
  TOP w0.147: v1(101.22,80.7) 100.76,80.7 100.72,80.66 99.27,80.66 99.22,80.7 98.66,80.7 U23.B7 ; v1(116.87,76.82) 122.06,71.63 123.44,71.63 124.84,70.23 124.84,66.94 125.75,66.03 125.75,62.22 126.87,61.1 126.87,58.69 131.44,54.12 131.44,49.93 123.38,41.86 v1(123.38,30.69)
  L03_SIG1 w0.091: v1(101.22,80.7) 101.67,81.15 103.92,81.15 106.2,78.87 116.47,78.87 116.87,78.48 v1(116.87,76.82)
  L08_SIG2 w0.091: v1(101.22,80.7) 101.62,81.11 102.13,81.11 108,86.98 108,90.03 110.85,92.88 111.99,92.88 116.57,97.46 116.57,116.48 122.42,122.33 140.24,122.33 142.06,124.15 144.21,124.15 147.96,127.9 147.96,129.81 J1.8
  BOTTOM w0.147: R470.2 v1(123.38,30.69)
MCU_GPIO0_7: length 89.3
  TOP w0.147: U23.D7 v1(97.06,80.7)
  L08_SIG2 w0.091: v1(97.06,80.7) 97.46,80.3 98.34,80.3 98.44,80.2 105.45,80.2 106.17,80.93 106.17,82.62 106.26,82.71 106.26,84.46 108.59,86.79 108.59,88.51 117.24,97.16 117.24,115.33 122.78,120.88 140.44,120.88 141.3,121.74 144.96,121.74 J1.9
MCU_GPIO0_8: length 83.2
  TOP w0.147: U23.C7 v1(97.86,80.7)
  L08_SIG2 w0.091: v1(97.86,80.7) 98.84,80.7 99.14,80.41 100.39,80.41 101.28,81.29 102.05,81.29 107.78,87.02 107.78,90.13 110.76,93.1 111.9,93.1 116.35,97.55 116.35,116.58 122.33,122.55 140.15,122.55 142.95,125.36 143,125.36 144.53,125.36 146.18,127.01 146.18,128.03 J1.5
MCU_GPIO0_9: length 93.3
  TOP w0.147: U23.C8 v1(97.86,79.9)
  L08_SIG2 w0.091: J1.12 153.16,129.94 153.16,128.37 152.35,127.56 151.08,127.56 144.22,120.7 122.88,120.7 117.46,115.28 117.46,97.12 108.77,88.44 108.77,86.72 107.19,85.14 107.19,81.18 105.99,79.98 100.6,79.98 100.53,79.9 v1(97.86,79.9)
MCU_I2C0_SCL: length 91.5
  L08_SIG2 w0.091: J1.20 163.19,129.81 163.19,127.53 153.21,117.54 123.46,117.54 119.19,113.26 119.19,88.35 114.54,83.71 113.74,83.71 113.1,83.07 v1(111.76,83.07)
  BOTTOM w0.147: v1(111.76,83.07) R311.2 112.41,82.52 112.51,82.42 113.25,82.42 113.39,82.28 R593.1
MCU_I2C0_SCL_RC: length 23.2
  TOP w0.147: U23.E9 v1(96.26,79.1)
  L08_SIG2 w0.091: v1(96.26,79.1) 96.33,79.1 96.73,78.71 97.2,78.71 97.48,78.43 97.48,78.15 97.7,77.92 97.98,77.92 100.14,75.76 110.47,75.76 112.41,77.71 v1(112.41,79.68)
  BOTTOM w0.147: R593.2 C487.1 v1(112.41,79.68)
MCU_I2C0_SDA: length 85.7
  L08_SIG2 w0.091: v1(111.76,84.34) 119,91.59 119,113.39 123.37,117.76 153.17,117.76 162.05,126.64 J1.17
  BOTTOM w0.147: R309.2 v1(111.76,84.34) 111.76,84.84 110.81,85.79 R594.1
MCU_I2C0_SDA_RC: length 23.9
  TOP w0.147: U23.A10 v1(100.71,77.9)
  L08_SIG2 w0.091: v1(110.89,84.81) 111.25,84.45 111.25,82.06 111.81,81.5 111.81,77.36 110.39,75.95 102.67,75.95 v1(100.71,77.9)
  BOTTOM w0.147: C488.1 R594.2 v1(110.89,84.81)
MCU_I2C1_SCL: length 105.4
  TOP w0.147: U23.A11 101.85,77.1 v1(102.74,77.99)
  L08_SIG2 w0.091: v1(102.74,77.99) 103.42,77.32 108.76,77.32 109.65,78.2 109.65,84.19 111.07,85.61 v1(111.76,85.61) 112.73,85.61 118.78,91.67 118.78,113.48 123.28,117.98 153.02,117.98 159.89,124.86 159.89,126 160.61,126.72 160.61,129.77 J1.18
  BOTTOM w0.147: R306.2 v1(111.76,85.61)
MCU_I2C1_SDA: length 98.6
  TOP w0.147: v1(102.74,79.14) 102.05,78.45 101.41,78.45 101.34,78.37 100.59,78.37 100.52,78.3 98.66,78.3 U23.B10
  L08_SIG2 w0.091: J1.14 156.72,131.21 155.57,130.06 155.57,128.03 154.43,126.89 151.01,126.89 144.46,120.33 124.38,120.33 117.9,113.85 117.9,96.91 113.36,92.37 113.36,88.48 v1(111.76,86.88) 109.72,86.88 107.74,84.91 107.74,79.99 105.85,78.1 104.15,78.1 103.12,79.14 v1(102.74,79.14)
  BOTTOM w0.147: R303.2 v1(111.76,86.88)
MCU_OSC0_XI: length 9
  TOP w0.147: R138.2 99.19,63.99 97.46,65.73 U23.C21
MCU_OSC0_XO: length 11.3
  TOP w0.147: R139.2 101.28,60.77 100.36,61.69 100.36,64.31 98.42,66.25 98.42,68.29 97.86,68.86 97.86,69.5 U23.B20
MCU_PORZ: length 340.4
  TOP w0.147: U23.B21 98.37,68.99 98.37,68.75 98.77,68.35 98.77,66.93 100.88,64.82 113.96,64.82 115.3,66.16 116.46,66.16 120.52,62.09 120.52,61.08 120.85,60.75 123.22,60.75 124.36,61.89 125.53,61.89 126.58,60.84 126.58,56.74 124.57,54.73 R575.2 ; J2.E30 v1(37.72,132.35) ; TP33.1 122.64,50.18 122.76,50.3 v1(123.33,50.3) 123.78,50.3 123.99,50.51 R575.2 ; U35.4 R575.2
  L03_SIG1 w0.091: v1(37.72,132.35) 36.52,131.14 36.52,129.27 34.49,127.25 27.79,127.25 25.28,124.74 21.36,124.74 20.7,125.4 20.7,126.31 19.76,127.25 17.3,127.25 14.59,124.54 11.84,124.54 9.32,127.05 8.81,127.05 8.5,126.74 8.5,125.64 10.33,123.81 23.72,123.81 28.42,119.1 28.42,117.71 28.18,117.47 27.64,117.47 26.36,118.75 23.32,118.75 20.77,116.2 20.77,93.98 24.71,90.05 24.71,88.51 28.93,84.29 28.93,64.83 26.62,62.53 26.62,45.34 28.96,43.01 29.92,43.01 35.83,37.1 43.61,37.1 47.4,33.31 47.4,32.2 47.27,32.08 47.27,31.57 47.63,31.22 48.43,31.22 52.32,27.32 55.5,27.32 66.93,15.89 78.36,15.89 79.33,14.92 90.51,14.92 94.05,11.38 103.05,11.38 108.07,16.4 112.9,16.4 118.36,21.86 118.36,28.02 123.33,32.99 v1(123.33,50.3)
