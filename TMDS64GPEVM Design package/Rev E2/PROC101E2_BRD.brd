# Allegro board PROC101E2_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PRG0_PRU1GPO11: length 58.7
  TOP w0.147: U23.W4 v1(84.26,83.1) ; J2.D11 v1(61.85,131.08)
  L03_SIG1 w0.091: v1(84.26,83.1) 83.91,83.45 83.91,85.2 80.03,89.08 80.03,102.54 66.4,116.17 66.4,120.17 62.28,124.29 62.28,130.65 v1(61.85,131.08)
PRG0_PRU1GPO12: length 64.1
  TOP w0.147: J2.B15 56.74,127.29 56.74,124.53 57.34,123.93 60.61,123.93 63.65,120.89 63.65,111.98 69.31,106.32 69.31,98.12 67.67,96.48 67.67,92.26 72.88,87.05 78.51,87.05 81.05,84.51 81.32,84.51 81.65,84.19 81.66,84.19 81.9,83.94 81.9,83.56 82.36,83.1 83.46,83.1 U23.Y4
PRG0_PRU1GPO13: length 63.3
  TOP w0.147: J2.D5 v1(69.47,131.08) ; U23.T6 v1(86.66,81.5)
  L03_SIG1 w0.091: v1(86.66,81.5) 87.06,81.11 89.22,81.11 89.46,81.34 89.46,84.83 89.18,85.1 88.89,85.1 84.68,89.32 84.68,92.52 83.49,93.71 83.49,102.18 69.4,116.28 69.4,123.93 70.13,124.66 70.13,130.42 v1(69.47,131.08)
PRG0_PRU1GPO14: length 64.4
  TOP w0.147: U23.U6 v1(85.86,81.5) ; J2.E12 v1(60.58,132.35)
  L03_SIG1 w0.091: v1(60.58,132.35) 61.3,131.63 61.3,124.75 65.99,120.06 65.99,116.06 79.59,102.46 79.59,88 83.47,84.11 83.47,81.64 84.01,81.11 85.46,81.11 v1(85.86,81.5)
PRG0_PRU1GPO15: length 60.6
  TOP w0.147: U23.U5 v1(85.86,82.3) ; J2.C11 v1(61.85,129.81)
  L03_SIG1 w0.091: v1(61.85,129.81) 61.85,124.46 66.18,120.13 66.18,116.14 79.81,102.5 79.81,88.99 83.69,85.1 83.69,82.18 83.97,81.91 85.46,81.91 v1(85.86,82.3)
PRG0_PRU1GPO16: length 58.9
  TOP w0.147: U23.AA4 82.09,82.7 81.48,83.31 v1(81.48,83.77) ; J2.A15 v1(55.5,126)
  L08_SIG2 w0.091: v1(81.48,83.77) 77.77,87.48 77.76,87.48 77.74,87.5 75.66,87.5 73.58,89.59 73.58,96.52 69.13,100.97 69.13,103.38 63.37,109.14 63.37,120.7 59.36,124.71 56.78,124.71 v1(55.5,126)
PRG1_ETH2_D0M: length 25.3
  BOTTOM w0.108: J21.B3 17.84,72.22 17.73,72.33 16.87,72.33 16.66,72.12 16.66,71.99 16.76,71.9 16.85,71.9 16.95,71.8 16.95,71.66 16.85,71.57 16.76,71.57 16.66,71.47 16.66,71.24 18.47,69.43 18.47,68.26 22.84,63.89 34.86,63.89 34.96,64 U80.2
PRG1_ETH2_D0P: length 25.3
  BOTTOM w0.108: J21.B2 16.57,72.52 16.37,72.32 16.37,71.12 18.18,69.31 18.18,68.14 22.72,63.6 34.77,63.6 34.88,63.5 U80.1
PRG1_ETH2_D1M: length 25.4
  TOP w0.108: v1(27.86,65.59) 27.41,65.59 27,66 27,66.14 27.29,66.43 27.29,66.8 27.02,67.07 26.64,67.07 26.36,66.78 26.22,66.78 26.13,66.88 26.13,67.01 26.41,67.3 26.41,67.68 26.15,67.94 25.77,67.94 25.48,67.66 25.35,67.66 25.25,67.75 25.25,67.89 25.54,68.18 25.54,68.55 25.27,68.82 24.89,68.82 24.61,68.53 24.47,68.53 24.12,68.88 21.46,68.88 20.64,69.71 20.64,70.8 21.07,71.23 21.71,71.23 21.9,71.42 21.9,71.58 21.82,71.65 21.73,71.65 21.62,71.77 21.62,71.96 21.75,72.09 J21.B7
  BOTTOM w0.108: U80.5 35.06,65.5 34.95,65.39 32.01,65.39 31.48,64.86 28.14,64.86 27.86,65.15 v1(27.86,65.59)
PRG1_ETH2_D1P: length 25.4
  TOP w0.108: v1(27.21,64.94) 27.21,65.39 26.71,65.88 26.71,66.26 27,66.55 27,66.68 26.9,66.78 26.76,66.78 26.48,66.49 26.1,66.49 25.84,66.76 25.84,67.13 26.12,67.42 26.12,67.56 26.03,67.65 25.89,67.65 25.6,67.37 25.23,67.37 24.96,67.63 24.96,68.01 25.25,68.3 25.25,68.43 25.15,68.53 25.01,68.53 24.73,68.24 24.35,68.24 24,68.59 21.34,68.59 20.35,69.59 20.35,70.63 19.11,71.87 J21.B4
  BOTTOM w0.108: U80.4 35.05,65 34.95,65.1 32.13,65.1 31.6,64.57 28.02,64.57 27.65,64.94 v1(27.21,64.94)
PRG1_ETH2_D2M: length 25.2
  BOTTOM w0.108: U80.8 34.82,67 34.72,66.89 29.65,66.89 29.55,66.99 29.55,68.05 29.29,68.31 28.91,68.31 28.65,68.05 28.65,66.99 28.55,66.89 28.41,66.89 28.32,66.99 28.32,68.05 28.05,68.31 27.68,68.31 27.41,68.05 27.41,66.99 27.31,66.89 27.18,66.89 27.08,66.99 27.08,68.05 26.81,68.31 26.44,68.31 26.11,67.99 26.11,66.99 26.01,66.89 25.71,66.89 21.81,70.79 21.81,71.74 21.65,71.9 J21.B6
PRG1_ETH2_D2P: length 25.2
  BOTTOM w0.108: J21.B5 21.05,72.09 21.52,71.62 21.52,70.67 25.59,66.61 26.13,66.61 26.4,66.87 26.4,67.87 26.56,68.02 26.7,68.02 26.79,67.93 26.79,66.87 27.06,66.61 27.43,66.61 27.7,66.87 27.7,67.93 27.8,68.02 27.93,68.02 28.03,67.93 28.03,66.87 28.29,66.61 28.67,66.61 28.94,66.87 28.94,67.93 29.03,68.02 29.17,68.02 29.27,67.93 29.27,66.87 29.53,66.61 34.71,66.61 34.82,66.5 U80.7
PRG1_ETH2_D3M: length 25.3
  BOTTOM w0.108: J21.B9 25.46,72.34 25.35,72.45 24.75,72.45 24.31,72.02 24.31,71.67 24.41,71.58 24.46,71.58 24.56,71.48 24.56,71.34 24.46,71.25 24.41,71.25 24.31,71.15 24.31,70.72 25.95,69.08 26.62,69.08 26.71,69.18 26.71,70.28 26.98,70.54 27.36,70.54 27.62,70.28 27.62,69.18 27.72,69.08 27.85,69.08 27.95,69.18 27.95,70.28 28.22,70.54 28.59,70.54 28.86,70.28 28.86,69.18 28.96,69.08 29.09,69.08 29.19,69.18 29.19,70.28 29.45,70.54 29.83,70.54 30.1,70.28 30.1,69.18 30.19,69.08 30.33,69.08 30.43,69.18 30.43,70.28 30.69,70.54 31.07,70.54 31.33,70.28 31.33,69.18 31.43,69.08 31.83,69.08 32.52,68.39 34.65,68.39 34.75,68.5 U80.11
PRG1_ETH2_D3P: length 25.3
  BOTTOM w0.108: U80.10 34.85,68 34.74,68.1 32.4,68.1 31.71,68.79 31.31,68.79 31.04,69.06 31.04,70.16 30.95,70.25 30.81,70.25 30.71,70.16 30.71,69.06 30.45,68.79 30.07,68.79 29.81,69.06 29.81,70.16 29.71,70.25 29.57,70.25 29.48,70.16 29.48,69.06 29.21,68.79 28.84,68.79 28.57,69.06 28.57,70.16 28.47,70.25 28.34,70.25 28.24,70.16 28.24,69.06 27.97,68.79 27.6,68.79 27.33,69.06 27.33,70.16 27.24,70.25 27.1,70.25 27,70.16 27,69.06 26.74,68.79 25.83,68.79 24.02,70.6 24.02,72.49 24.19,72.65 J21.B8
PRG1_ETH2_GPIO_1: length 2.5
  BOTTOM w0.147: R340.2 R341.1 40.74,70.61 U80.22
PRG1_ETH2_LED1: length 10
  BOTTOM w0.147: Q14.3 4.88,78.27 4.99,78.37 9.53,78.37 10.48,77.42 12.39,77.42 J21.B13
PRG1_ETH2_LED3: length 10.6
  BOTTOM w0.147: J21.B12 12.39,75.39 8.57,75.39 7.75,74.56 7.75,72.79 6.81,71.85 Q16.3
PRG1_ETH2_LED_1000/RX_ER: length 116.9
  TOP w0.147: U23.AA13 82.83,75.5 81.19,73.87 76.01,73.87 75.54,73.39 73.98,73.39 71.92,75.46 71.92,76.97 67.85,81.03 67.16,81.03 66.53,81.66 62.73,81.66 56.29,75.23 56.29,71.28 45.61,60.59 43.44,60.59 41.72,58.87 36.07,58.87 v1(35.31,59.64)
  L08_SIG2 w0.091: v1(35.31,59.64) 34.55,59.64 30.61,63.57 20.75,63.57 19.05,61.86 13.59,61.86 12.63,62.82 4.63,62.82 2.41,65.04 v1(2.41,72.8)
  BOTTOM w0.147: R386.1 36.25,58.61 R388.2 v1(35.31,59.64) 35.31,61.1 35.84,61.64 36.47,61.64 36.54,61.7 36.57,61.7 36.71,61.83 36.87,61.83 37.24,62.2 U80.46 ; R343.2 v1(2.41,72.8)
PRG1_ETH2_LED_ACT: length 53.9
  L08_SIG2 w0.091: v1(3.62,76.02) 3.62,66.24 6.83,63.04 12.73,63.04 13.68,62.08 18.96,62.08 20.62,63.74 20.67,63.74 20.68,63.75 30.69,63.75 30.7,63.74 30.75,63.74 34.41,60.09 35.74,60.09 v1(36.34,59.48)
  BOTTOM w0.147: R387.2 37.41,58.61 R385.1 37.31,58.68 36.75,59.23 36.59,59.23 v1(36.34,59.48) 36.02,59.8 36.02,60.69 36.21,60.88 36.21,60.88 36.47,61.14 36.48,61.14 36.87,61.54 37,61.54 37.67,62.21 37.67,62.34 37.74,62.41 U80.45 ; R324.1 v1(3.62,76.02)
PRG1_ETH2_LED_LINK: length 73.5
  TOP w0.147: U23.U12 v1(85.86,75.9)
  L08_SIG2 w0.091: v1(85.86,75.9) 85.46,75.51 83.29,75.51 83.06,75.74 83.06,76.07 82.53,76.6 81.48,76.6 81.01,76.13 76.8,76.13 75.22,77.71 61.71,77.71 61.6,77.6 46.8,62.8 46.8,62.61 46.1,61.91 46.1,61.37 45.57,60.85 43.2,60.85 42.62,61.43 42.62,61.79 42.87,62.05 43.11,62.05 43.7,62.64 43.7,63.82 43.45,64.08 42.58,64.08 40.37,61.86 35.37,61.86 v1(34.67,61.17)
  BOTTOM w0.147: U80.47 36.74,62.28 36.45,61.99 35.5,61.99 v1(34.67,61.17) 34.04,60.53 R563.1 R562.2
PRG1_ETH3_D0M: length 24.7
  TOP w0.108: U20.2 35.07,84.12 34.96,84.24 33.23,84.24 32.01,85.45 22.51,85.45 16.65,79.59 16.65,79.39 16.74,79.3 16.87,79.3 16.96,79.2 16.96,79.07 16.87,78.97 16.74,78.97 16.65,78.87 16.65,78.58 16.76,78.47 17.61,78.47 J21.A3
PRG1_ETH3_D0P: length 24.7
  TOP w0.108: U20.1 35.02,84.62 34.92,84.52 33.35,84.52 32.13,85.74 22.39,85.74 16.36,79.71 16.36,78.46 16.58,78.23 16.58,77.44 J21.A2
PRG1_ETH3_D1M: length 24.7
  TOP w0.108: v1(29.97,83.14) 30.29,83.45 31.5,83.45 32.21,82.74 34.96,82.74 35.07,82.62 U20.5
  BOTTOM w0.108: J21.A7 22.17,79.44 21.95,79.44 21.86,79.34 21.86,79.1 21.76,79 21.63,79 21.53,79.1 21.53,79.34 21.43,79.44 21.16,79.44 20.57,80.02 20.57,81.17 21.21,81.8 22.25,81.8 22.34,81.71 22.34,81 22.61,80.73 22.99,80.73 23.25,81 23.25,81.71 23.35,81.8 23.48,81.8 23.58,81.71 23.58,81 23.85,80.73 24.22,80.73 24.49,81 24.49,81.71 24.59,81.8 27.05,81.8 28.7,83.45 29.66,83.45 v1(29.97,83.14)
PRG1_ETH3_D1P: length 24.7
  TOP w0.108: U20.4 35.02,83.12 34.92,83.02 32.33,83.02 31.62,83.74 30.29,83.74 v1(29.97,84.06)
  BOTTOM w0.108: v1(29.97,84.06) 29.66,83.74 28.58,83.74 26.93,82.09 24.47,82.09 24.2,81.83 24.2,81.12 24.1,81.02 23.97,81.02 23.87,81.12 23.87,81.83 23.6,82.09 23.23,82.09 22.96,81.83 22.96,81.12 22.87,81.02 22.73,81.02 22.63,81.12 22.63,81.83 22.37,82.09 21.09,82.09 20.28,81.29 20.28,80.28 19.32,79.31 19.32,78.18 19.11,77.96 J21.A4
PRG1_ETH3_D2M: length 24.6
  TOP w0.108: J21.A6 21.65,78.86 21.81,79.02 21.81,80.26 22.33,80.79 23.39,80.79 23.66,81.05 23.66,81.85 23.75,81.94 23.89,81.94 23.99,81.85 23.99,81.05 24.25,80.79 24.63,80.79 24.89,81.05 24.89,81.85 24.99,81.94 25.13,81.94 25.22,81.85 25.22,81.05 25.49,80.79 26.01,80.79 26.27,81.05 26.27,81.85 26.37,81.94 26.51,81.94 26.6,81.85 26.6,81.09 26.9,80.79 27.28,80.79 27.63,81.14 27.63,81.81 27.73,81.91 27.87,81.91 27.96,81.81 27.96,81.05 28.23,80.79 29.84,80.79 30.3,81.24 34.76,81.24 34.88,81.12 U20.8
PRG1_ETH3_D2P: length 24.6
  TOP w0.108: J21.A5 21.07,78.69 21.52,79.14 21.52,80.38 22.21,81.08 23.27,81.08 23.37,81.17 23.37,81.97 23.63,82.23 24.01,82.23 24.27,81.97 24.27,81.17 24.37,81.08 24.51,81.08 24.6,81.17 24.6,81.97 24.87,82.23 25.25,82.23 25.51,81.97 25.51,81.17 25.61,81.08 25.89,81.08 25.98,81.17 25.98,81.97 26.25,82.23 26.62,82.23 26.89,81.97 26.89,81.21 27.02,81.08 27.16,81.08 27.34,81.26 27.34,81.93 27.61,82.2 27.99,82.2 28.25,81.93 28.25,81.17 28.35,81.08 29.73,81.08 30.18,81.53 34.75,81.53 34.84,81.62 U20.7
PRG1_ETH3_D3M: length 24.8
  TOP w0.108: J21.A9 25.21,78.44 24.47,78.44 24.27,78.64 24.27,78.78 24.37,78.88 24.48,78.88 24.58,78.97 24.58,79.11 24.48,79.21 24.37,79.21 24.27,79.3 24.27,79.65 24.56,79.94 25.89,79.94 26.15,79.68 26.53,79.68 26.63,79.79 26.77,79.79 26.87,79.69 26.87,79.55 26.76,79.45 26.76,79.07 27.19,78.64 27.71,78.64 27.81,78.55 27.81,77.21 28.07,76.94 28.45,76.94 28.72,77.21 28.72,78.55 28.81,78.64 28.95,78.64 29.04,78.55 29.04,77.21 29.31,76.94 29.69,76.94 29.95,77.21 29.95,78.55 30.05,78.64 30.19,78.64 30.28,78.55 30.28,77.21 30.55,76.94 30.92,76.94 31.19,77.21 31.19,78.55 31.29,78.64 31.52,78.64 32.61,79.74 34.96,79.74 35.07,79.62 U20.11
PRG1_ETH3_D3P: length 24.8
  TOP w0.108: U20.10 35.02,80.12 34.92,80.02 32.49,80.02 31.4,78.93 31.17,78.93 30.9,78.66 30.9,77.33 30.8,77.23 30.67,77.23 30.57,77.33 30.57,78.66 30.31,78.93 29.93,78.93 29.66,78.66 29.66,77.33 29.57,77.23 29.43,77.23 29.33,77.33 29.33,78.66 29.07,78.93 28.69,78.93 28.43,78.66 28.43,77.33 28.33,77.23 28.19,77.23 28.1,77.33 28.1,78.66 27.83,78.93 27.31,78.93 27.05,79.19 27.05,79.33 27.16,79.43 27.16,79.81 26.89,80.08 26.51,80.08 26.41,79.97 26.27,79.97 26.01,80.22 24.44,80.22 23.98,79.77 23.98,78.52 24.19,78.32 J21.A8
PRG1_ETH3_GPIO_1: length 2.6
  TOP w0.147: R115.1 R114.2 40.87,77.58 U20.22
PRG1_ETH3_LED1: length 2.9
  BOTTOM w0.147: J21.A13 10.53,76.41 10.37,76.57 Q15.3
PRG1_ETH3_LED3: length 14.9
  TOP w0.147: J21.A12 8.13,77.85 8.13,82.18 11.6,85.66 Q4.3
PRG1_ETH3_LED_1000/RX_ER: length 91.5
  TOP w0.147: R96.1 36.38,89.51 R94.2 v1(35.43,88.48) 35.43,87.01 35.96,86.49 36.77,86.49 36.97,86.28 37.05,86.28 37.37,85.97 U20.46 ; U23.V13 v1(85.06,75.1) ; R99.2 v1(14.95,87.71)
  L03_SIG1 w0.091: v1(73.15,90.18) 73.15,87.64 75.92,84.88 75.92,82.79 81.96,76.75 82.35,76.75 83.04,76.06 83.04,75.71 83.22,75.52 84.64,75.52 v1(85.06,75.1)
  BOTTOM w0.147: v1(14.95,87.71) 30.92,87.71 31.7,88.48 v1(35.43,88.48) 35.43,88.03 37.17,86.29 42.54,86.29 43,86.76 57.4,86.76 60.71,90.06 70.99,90.06 72.14,91.2 72.9,91.2 73.15,90.95 v1(73.15,90.18)
PRG1_ETH3_LED_ACT: length 48.4
  TOP w0.147: R95.2 37.53,89.51 R97.1 37.44,89.44 36.88,88.88 36.8,88.88 36.55,88.63 v1(36.47,88.63) 36.15,88.32 36.15,87.18 36.45,86.88 36.79,86.88 37.1,86.58 37.22,86.58 37.87,85.94 U20.45
  L08_SIG2 w0.091: v1(5.84,74.94) 5.84,75.83 7.37,77.36 7.37,82.56 11.56,86.76 28.7,86.76 31.75,89.8 35.3,89.8 v1(36.47,88.63)
  BOTTOM w0.147: R334.1 v1(5.84,74.94)
PRG1_ETH3_LED_LINK: length 69.4
  TOP w0.147: U23.W13 v1(84.26,75.1) ; R564.2 R565.1 34.16,87.59 v1(34.8,86.95) 35.63,86.12 36.7,86.12 36.87,85.96 U20.47
  L03_SIG1 w0.091: v1(84.26,75.1) 84.14,75.22 82.8,75.22 82.28,75.75 82.28,76.07 75.65,82.7 75.65,84.76 72.64,87.77 v1(72.64,90.69)
  BOTTOM w0.147: v1(34.8,86.95) 36,86.95 36.96,85.99 42.66,85.99 43.13,86.46 57.53,86.46 60.83,89.76 71.71,89.76 v1(72.64,90.69)
PRG1_IEP0_EDC_LATCH_IN0: length 30.1
  TOP w0.147: U23.V7 v1(85.06,80.7)
  L08_SIG2 w0.091: v1(85.06,80.7) 84.66,81.1 81.88,81.1 78.09,84.89 78,84.89 77.93,84.96 75.26,84.96 74.86,85.37 70.31,89.92 70.31,89.96 70.23,90.04 70.23,90.35 70.23,90.35 70.23,95.82 69.55,96.5 67.02,96.5 J17.1
PRG1_IEP0_EDC_LATCH_IN1: length 61.4
  TOP w0.147: U23.U13 v1(85.86,75.1)
  L08_SIG2 w0.091: J15.1 58.17,95.39 57.91,95.65 55.43,95.65 53.75,97.32 53.75,99.05 54.73,100.02 56.7,100.02 58.34,98.39 70.02,98.39 71.96,96.45 71.96,90.62 75.44,87.14 77.59,87.14 81.34,83.39 82.47,83.39 82.85,83.77 84.58,83.77 84.84,83.52 85.27,83.52 85.43,83.35 85.43,82.89 85.59,82.73 86.03,82.73 86.26,82.5 86.26,78.87 86.41,78.71 86.85,78.71 87.06,78.51 87.06,77.37 86.28,76.6 86.28,75.53 v1(85.86,75.1)
PRG1_IEP0_EDC_SYNC_OUT0: length 25.7
  TOP w0.147: U23.W7 v1(84.26,80.7)
  L08_SIG2 w0.091: v1(84.26,80.7) 81.99,80.7 77.98,84.71 74.93,84.71 67.82,91.82 67.82,94.12 J18.1
PRG1_IEP0_EDC_SYNC_OUT2: length 57.2
  TOP w0.147: U23.U7 v1(85.86,80.7)
  L08_SIG2 w0.091: J16.1 61.63,96.5 58.39,96.5 57.72,95.84 55.55,95.84 53.97,97.41 53.97,98.96 54.82,99.8 56.61,99.8 58.21,98.2 69.94,98.2 71.77,96.37 71.77,90.53 75.42,86.88 77.48,86.88 77.53,86.83 77.61,86.83 81.36,83.08 82.7,83.08 83.12,83.5 84.42,83.5 84.63,83.29 84.63,82.93 84.84,82.73 85.16,82.73 85.46,82.43 85.46,81.11 v1(85.86,80.7)
PRG1_MDIO_MDC: length 77.4
  TOP w0.147: v1(41.4,74.82) 42.24,74.82 43.72,76.3 46.96,76.3 49.33,73.93 U27.8 ; v1(71.91,84.42) 77.87,84.42 78.44,83.85 79.62,82.66 80.19,82.66 81.35,81.5 83.46,81.5 U23.Y6 ; U20.42 39.37,85.9 38.71,86.55 R104.2 39.1,87.11 v1(39.32,86.89)
  L03_SIG1 w0.091: v1(39.32,86.89) 40.08,87.64 40.8,87.64 41.12,87.33 41.12,84.64 40.48,84 40.48,78.47 40.92,78.03 40.92,76.29 40.84,76.21 40.84,74.94 40.97,74.82 v1(41.4,74.82)
  L08_SIG2 w0.091: v1(39.32,86.89) 41.09,88.66 45.59,88.66 47.75,86.5 61.33,86.5 63.41,84.42 v1(71.91,84.42)
PRG1_MDIO_MDIO: length 72.8
  TOP w0.147: U20.41 39.87,86.37 40.04,86.55 R103.1 40.06,87.11 40.61,87.11 40.64,87.14 v1(40.67,87.14) ; U27.2 47.25,74.43 47.4,74.58 47.4,75.45 46.84,76.01 43.86,76.01 41.98,74.12 41.72,74.12 v1(41.4,73.8) ; v1(70.52,83.75) 71.08,83.2 74.68,83.2 75.06,83.58 78.29,83.58 78.31,83.56 79.5,82.37 80.07,82.37 81.34,81.1 U23.AA6
  L03_SIG1 w0.091: v1(41.4,73.8) 40.53,74.68 40.53,76.21 40.7,76.38 40.7,77.94 40.26,78.37 40.26,84.09 40.67,84.5 v1(40.67,87.14)
  L08_SIG2 w0.091: v1(70.52,83.75) 70.2,84.07 63.12,84.07 61.21,85.98 52.67,85.98 50.89,84.2 49.04,84.2 46.74,86.5 41.3,86.5 v1(40.67,87.14)
PRG1_PRU1GPO18: length 79.5
  TOP w0.147: U23.Y13 83.46,75.1 82.84,75.1 81.31,73.57 76.23,73.57 75.75,73.1 73.86,73.1 71.37,75.58 v1(71.37,76.72) ; J2.E13 v1(59.31,132.35)
  L03_SIG1 w0.091: v1(59.31,132.35) 59.74,131.92 59.74,125.32 65.44,119.61 65.44,112.41 66.35,111.49 66.35,107.16 67.78,105.74 67.78,99.29 70.9,96.17 70.9,91.17 68.07,88.35 68.07,83.02 71.37,79.72 v1(71.37,76.72)
PRG1_PRU1GPO19: length 66.6
  TOP w0.147: J2.C12 v1(60.58,129.81) ; U23.V12 v1(85.06,75.9)
  L03_SIG1 w0.091: v1(60.58,129.81) 60.58,124.73 65.63,119.69 65.63,114.35 73.79,106.19 73.79,87.5 76.33,84.96 76.33,82.82 81.81,77.33 82.12,77.33 83.17,76.29 84.68,76.29 v1(85.06,75.9)
PRG1_RGMII1_ETH3_CLK: length 51.7
  TOP w0.147: v1(40.26,77.24) 39.87,77.63 U20.20
  L08_SIG2 w0.091: v1(59.94,112.79) 57.78,110.63 54.36,110.63 48.12,104.39 43.56,104.39 40.26,101.09 40.26,96.14 39.38,95.26 39.38,88.76 38.61,87.99 38.61,85.27 39.21,84.67 39.21,78.28 v1(40.26,77.24)
  BOTTOM w0.147: R237.2 v1(59.94,112.79)
PRG1_RGMII1_ETH3_CLK_OUT: length 4.9
  TOP w0.147: TP17.1 40.77,88.66 40.95,88.47 41.15,88.28 41.15,86.89 40.37,86.11 U20.40
PRG1_RGMII1_ETH3_RBIAS: length 1.3
  TOP w0.147: U20.12 R110.2
PRG1_RGMII1_RD0: length 48.6
  TOP w0.147: U23.Y7 83.46,80.7 81.22,80.7 80.52,81.41 79.5,81.41 78.75,82.16 78.75,82.45 77.94,83.26 75.86,83.26 75.37,83.26 74.53,82.42 70.63,82.42 69.08,83.97 68.4,83.97 66.76,85.62 52.63,85.62 52.52,85.74 52.52,85.86 52.4,85.98 52.23,85.98 52.11,85.86 52.11,85.74 52,85.62 51.83,85.62 51.71,85.74 51.71,86.2 51.6,86.32 51.43,86.32 51.31,86.2 51.31,85.74 51.19,85.62 50.55,85.62 47.58,82.65 45.85,82.65 45.74,82.76 R108.1 v1(45.09,83.45) 44.76,83.12 U20.33
  BOTTOM w0.147: R108.1 v1(45.09,83.45)
PRG1_RGMII1_RD1: length 49.8
  TOP w0.147: U20.34 44.11,83.62 v1(45.09,84.59) R107.1 ; U23.U8 v1(85.86,79.9)
  L08_SIG2 w0.091: v1(45.09,84.59) 45.09,84.97 45.54,85.42 47.42,85.42 49.02,83.82 50.93,83.82 52.7,85.6 61.09,85.6 62.87,83.82 69.78,83.82 70.28,83.32 79.09,83.32 82.11,80.3 85.46,80.3 v1(85.86,79.9)
  BOTTOM w0.147: R107.1 v1(45.09,84.59)
PRG1_RGMII1_RD2: length 48.3
  TOP w0.147: U20.35 43.21,84.12 v1(43.43,84.35) ; U23.W8 v1(84.26,79.9)
  L08_SIG2 w0.091: v1(43.43,84.35) 43.82,83.96 44.05,83.96 44.14,84.05 44.14,84.79 44.23,84.88 44.4,84.88 44.49,84.79 44.49,84.05 44.58,83.96 45.59,83.96 45.68,84.05 45.68,84.52 45.77,84.62 45.93,84.62 46.02,84.52 46.02,84.05 46.11,83.96 46.28,83.96 46.37,84.05 46.37,84.52 46.46,84.62 46.62,84.62 46.71,84.52 46.71,84.05 46.8,83.96 47.64,83.96 48.72,82.89 69.68,82.89 69.98,82.59 78.3,82.59 78.98,81.92 78.98,81.3 80.37,79.9 v1(84.26,79.9)
PRG1_RGMII1_RD3: length 48.2
  TOP w0.147: v1(43.69,85.49) 43.36,85.16 42.75,85.16 42.62,85.02 U20.36 ; U23.V8 v1(85.06,79.9)
  L08_SIG2 w0.091: v1(43.69,85.49) 42.93,84.73 42.93,83.96 44.09,82.8 46.74,82.8 47.02,82.52 69.53,82.52 69.82,82.22 76.27,82.22 77.06,81.43 78.23,81.43 80.16,79.51 84.66,79.51 v1(85.06,79.9)
PRG1_RGMII1_RESETN: length 14.7
  TOP w0.147: v1(31.11,87.01) 31.11,87.88 R102.1 29.74,87.9 U19.4 ; U20.43 38.87,85.86 38.1,86.63 38.1,88.41 v1(38.48,88.79)
  L08_SIG2 w0.091: v1(38.48,88.79) 37.59,87.9 34.87,87.9 33.99,87.01 v1(31.11,87.01)
PRG1_RGMII1_RX_CTL: length 48.5
  TOP w0.147: U23.Y8 83.46,79.9 81.53,79.9 81.43,79.8 80.6,79.8 78.46,81.94 78.46,82.32 78.11,82.67 75.62,82.67 74.99,82.04 70.17,82.04 68.83,83.39 68.14,83.39 66.69,84.84 v1(50.42,84.84) ; U20.38 41.37,85.85 41.77,86.25 42.33,86.25 43.43,87.36 R100.1 R101.2 44.77,87.99 v1(45.3,87.99)
  L08_SIG2 w0.091: v1(50.42,84.84) 49.29,84.84 48.51,85.61 48.12,85.61 45.74,87.99 v1(45.3,87.99)
PRG1_RGMII1_RXC: length 48.2
  TOP w0.147: v1(48.9,83.31) 48.57,82.99 48.52,82.99 47.76,82.23 44.79,82.23 44.39,82.62 U20.32 ; v1(80.26,80.9) 80.91,80.25 82.52,80.25 82.58,80.3 U23.AA7
  L08_SIG2 w0.091: v1(80.26,80.9) 79.34,81.82 79.34,82.07 78.45,82.96 70.13,82.96 69.77,83.31 62.61,83.31 62.1,83.82 56.26,83.82 56.17,83.91 56.17,84.36 56.08,84.45 55.9,84.45 55.8,84.36 55.8,83.91 55.71,83.82 55.53,83.82 55.44,83.91 55.44,84.36 55.35,84.45 55.16,84.45 55.07,84.36 55.07,83.91 54.98,83.82 54.8,83.82 54.71,83.91 54.71,84.36 54.62,84.45 54.43,84.45 54.34,84.36 54.34,83.91 54.25,83.82 54.07,83.82 53.98,83.91 53.98,84.36 53.88,84.45 53.7,84.45 53.61,84.36 53.61,83.91 53.52,83.82 53.34,83.82 53.24,83.91 53.24,84.36 53.15,84.45 52.97,84.45 52.88,84.36 52.88,83.91 52.79,83.82 52.45,83.82 51.94,83.31 v1(48.9,83.31)
PRG1_RGMII1_TD0: length 55.2
  TOP w0.147: U20.28 43.2,80.62 43.37,80.46 43.87,80.46 43.98,80.36 43.98,80.22 44.07,80.13 44.07,78.74 44.45,78.36 46.35,78.36 46.74,78.74 46.74,80.99 46.94,81.19 47.94,81.19 48.69,81.94 48.85,81.94 49.41,81.38 49.58,81.38 49.7,81.5 49.7,81.67 49.14,82.23 49.14,82.39 49.25,82.51 49.42,82.51 49.98,81.95 50.15,81.95 50.26,82.07 50.26,82.23 49.7,82.79 49.7,82.96 50.47,83.73 51.16,83.73 51.27,83.61 51.27,82.85 51.39,82.73 51.56,82.73 51.67,82.85 51.67,83.61 51.79,83.73 51.96,83.73 52.08,83.61 52.08,82.85 52.19,82.73 52.36,82.73 52.48,82.85 52.48,83.61 52.59,83.73 67.38,83.73 68.02,83.09 68.71,83.09 70.35,81.45 74.81,81.45 75.59,82.23 76.9,82.23 77.72,81.41 77.97,81.41 79.87,79.5 U23.AA8
PRG1_RGMII1_TD1: length 55.3
  TOP w0.147: U23.U9 v1(85.86,79.1) ; v1(43.58,80) 43.45,80.12 U20.27
  BOTTOM w0.114: 83.35,79.91 83.76,79.5 85.46,79.5 v1(85.86,79.1)
  BOTTOM w0.147: 83.35,79.91 78.93,84.33 73.91,84.33 73.31,84.93 71.04,84.93 68.51,82.4 52.54,82.4 52.31,82.17 52.31,81.43 52.19,81.31 52.03,81.31 51.91,81.43 51.91,82.28 51.79,82.4 51.63,82.4 51.51,82.28 51.51,81.91 51.39,81.79 51.22,81.79 51.11,81.91 51.11,82.28 50.99,82.4 50.82,82.4 50.7,82.28 50.7,81.43 50.59,81.31 50.42,81.31 50.3,81.43 50.3,82.28 50.19,82.4 50.02,82.4 49.9,82.28 49.9,81.43 49.78,81.31 49.62,81.31 49.5,81.43 49.5,82.21 49.32,82.4 45.17,82.4 44.32,81.55 44.32,80.74 v1(43.58,80)
PRG1_RGMII1_TD2: length 55.2
  TOP w0.147: U23.W9 v1(84.26,79.1) ; v1(43.59,78.18) 43.59,79.36 43.41,79.54 43.39,79.54 43.31,79.62 U20.26
  L08_SIG2 w0.091: v1(43.59,78.18) 43.14,78.63 43.14,81.59 43.24,81.68 43.6,81.68 43.69,81.77 43.69,81.95 43.6,82.05 43.24,82.05 43.14,82.14 43.14,82.26 43.43,82.55 44.26,82.55 44.35,82.46 44.35,82.11 44.44,82.02 44.61,82.02 44.7,82.11 44.7,82.49 44.79,82.58 44.95,82.58 45.04,82.49 45.04,81.89 45.13,81.8 45.3,81.8 45.39,81.89 45.39,82.49 45.48,82.58 45.64,82.58 45.73,82.49 45.73,81.89 45.83,81.8 45.99,81.8 46.08,81.89 46.08,82.49 46.17,82.58 46.33,82.58 46.42,82.49 46.42,81.89 46.52,81.8 46.68,81.8 46.77,81.89 46.77,82.2 46.86,82.3 69.49,82.3 69.75,82.04 76.1,82.04 76.89,81.25 78.15,81.25 80.1,79.3 82.24,79.3 82.44,79.1 v1(84.26,79.1)
PRG1_RGMII1_TD3: length 55.1
  TOP w0.147: U20.25 42.62,78.25 44.27,76.6 47.32,76.6 48.56,77.84 48.73,77.84 49.25,77.33 49.42,77.33 49.53,77.44 49.53,77.61 49.01,78.13 49.01,78.29 49.13,78.41 49.3,78.41 49.82,77.89 49.98,77.89 50.1,78.01 50.1,78.18 49.58,78.7 49.58,78.86 49.7,78.98 49.87,78.98 50.38,78.46 50.55,78.46 50.67,78.58 50.67,78.74 50.15,79.26 50.15,79.43 50.27,79.55 50.43,79.55 50.95,79.03 51.12,79.03 51.24,79.15 51.24,79.31 50.72,79.83 50.72,80 50.83,80.11 51,80.11 51.52,79.6 51.69,79.6 51.8,79.71 51.8,79.88 51.28,80.4 51.28,80.56 53.86,83.14 66.85,83.14 67.69,82.3 68.67,82.3 69.93,81.03 70.11,80.86 75.06,80.86 75.35,81.16 77.14,81.16 77.48,80.82 77.72,80.82 79.73,78.81 81.37,78.81 81.48,78.7 U23.AA9
PRG1_RGMII1_TX_CTL: length 55.4
  TOP w0.147: U20.37 42.55,85.37 42.63,85.45 42.64,85.45 42.93,85.74 v1(43.05,85.74) ; U23.Y9 83.46,79.1 79.85,79.1 77.85,81.11 77.6,81.11 77.26,81.45 75.23,81.45 74.93,81.16 70.23,81.16 68.71,82.68 67.82,82.68 67.06,83.43 53.73,83.43 48.14,77.84 45.31,77.84 v1(44.58,77.1)
  L08_SIG2 w0.091: v1(43.05,85.74) 42.67,85.36 42.67,78.37 43.94,77.1 v1(44.58,77.1)
PRG1_RGMII1_TXC: length 55.3
  TOP w0.147: U23.V9 v1(85.06,79.1) ; v1(43.81,80.91) 43.52,80.91 43.31,81.12 U20.29
  L08_SIG2 w0.091: v1(85.06,79.1) 84.66,78.71 83.6,78.71 83.46,78.84 80.04,78.84 78,80.88 76.74,80.88 75.94,81.68 69.6,81.68 69.36,81.92 53.2,81.92 53.11,81.82 53.11,80.86 53,80.75 52.87,80.75 52.75,80.86 52.75,81.84 52.66,81.93 52.47,81.93 52.38,81.84 52.38,80.86 52.29,80.77 52.11,80.77 52.02,80.86 52.02,81.84 51.92,81.93 51.74,81.93 51.65,81.84 51.65,80.86 51.56,80.77 51.38,80.77 51.28,80.86 51.28,81.84 51.19,81.93 51.01,81.93 50.92,81.84 50.92,80.86 50.83,80.77 50.64,80.77 50.55,80.86 50.55,81.84 50.46,81.93 50.28,81.93 50.19,81.84 50.19,80.99 50.1,80.9 49.91,80.9 49.82,80.99 49.82,81.84 49.73,81.93 48.56,81.93 47.96,81.33 44.6,81.33 44.19,80.91 v1(43.81,80.91)
PRG1_RGMII2_ETH2_CLK: length 57.8
  L08_SIG2 w0.091: v1(40.13,70.88) 40.13,72.02 38.99,73.17 38.99,84.58 38.32,85.24 38.32,88.02 39.16,88.85 39.16,95.42 40.01,96.27 40.01,101.35 43.31,104.65 47.97,104.65 54.24,110.92 57.67,110.92 58.67,111.92 v1(58.67,112.79)
  BOTTOM w0.147: v1(40.13,70.88) 39.74,70.49 U80.20 ; R238.2 v1(58.67,112.79)
PRG1_RGMII2_ETH2_CLK_OUT: length 5.1
  BOTTOM w0.147: U80.40 40.24,62.01 40.64,61.61 40.89,61.61 41.09,61.42 41.09,58.76 TP78.1
PRG1_RGMII2_ETH2_RBIAS: length 1.3
  BOTTOM w0.147: U80.12 R349.2
PRG1_RGMII2_FET_ENN: length 1.8
  TOP w0.147: U27.9 51.57,74.43 51.58,74.42 R121.1
PRG1_RGMII2_FET_SEL: length 50.9
  TOP w0.147: U27.1 44.69,74.93 44.69,74.93 R120.1 v1(43.45,74.93)
  L03_SIG1 w0.091: v1(43.45,74.93) 43.84,74.54 43.84,63.14 43.76,63.07 43.76,58.12 42.21,56.57 42.21,50.07 48.1,44.19 49.12,44.19 50.42,42.89 50.42,33.69 50.7,33.41 v1(51.07,33.41)
  BOTTOM w0.147: U91.13 v1(51.07,33.41)
PRG1_RGMII2_MDC: length 22.9
  TOP w0.147: U27.6 49.29,72.93 47.5,71.13 42.04,71.13 39.88,68.98 39.88,64.28 39.19,63.59 v1(39.19,61.23)
  BOTTOM w0.147: v1(39.19,61.23) 39.19,61.11 39.09,61.01 R369.2 38.58,61.56 39.24,62.22 U80.42
PRG1_RGMII2_MDIO: length 24.8
  TOP w0.147: U27.4 46.93,73.43 47.37,72.99 47.37,72.15 46.74,71.52 42,71.52 39.58,69.1 39.58,64.4 38.73,63.55 38.73,60.97 39.12,60.59 40.06,60.59 v1(40.62,61.15)
  BOTTOM w0.147: v1(40.62,61.15) 40.62,61.15 40.48,61.01 39.92,61.01 R370.1 39.92,61.57 39.74,61.75 U80.41
PRG1_RGMII2_RD0: length 63.3
  TOP w0.147: U23.W11 v1(84.26,77.5) ; R126.2 44.09,65.26 44.37,65.55 v1(44.83,65.55)
  L08_SIG2 w0.091: v1(44.83,65.55) 44.07,64.78 43.35,64.78 42.29,65.84 42.29,66.55 41.98,66.86 41.7,66.86 41.61,66.95 41.61,67.11 41.7,67.2 42.2,67.2 42.29,67.3 42.29,67.44 42.2,67.53 41.67,67.53 41.58,67.62 41.58,67.79 41.67,67.88 41.95,67.88 42.18,68.11 42.18,70.51 44.42,72.75 51.41,72.75 59.94,81.28 69.22,81.28 69.37,81.13 75.72,81.13 76.58,80.26 77.84,80.26 79.83,78.28 82.77,78.28 83.55,77.5 v1(84.26,77.5)
  BOTTOM w0.147: v1(44.83,65.55) 44.37,65.55 44.09,65.26 R126.2 43.53,64.67 43.2,65 U80.33
PRG1_RGMII2_RD1: length 62.7
  TOP w0.147: v1(44.2,62.88) 44.09,62.99 R128.2 ; U23.V11 v1(85.06,77.5)
  L08_SIG2 w0.091: v1(85.06,77.5) 84.66,77.9 83.46,77.9 82.89,78.48 79.89,78.48 77.85,80.52 76.59,80.52 75.79,81.31 69.45,81.31 69.22,81.53 59.82,81.53 51.28,72.99 44.29,72.99 41.15,69.85 41.15,66.69 44.2,63.64 v1(44.2,62.88)
  BOTTOM w0.147: U80.34 43.22,64.5 43.61,64.1 43.62,64.1 43.89,63.83 43.89,63.82 44.09,63.62 R128.2 44.09,63.24 44.2,63.13 v1(44.2,62.88)
PRG1_RGMII2_RD2: length 62
  TOP w0.147: U23.AA12 v1(82.66,75.9)
  L08_SIG2 w0.091: v1(43.27,63.13) 43.27,63.52 43.18,63.61 42.44,63.61 41.69,62.86 41.69,62.64 41.78,62.55 42.13,62.55 42.22,62.46 42.22,62.3 42.13,62.21 41.78,62.21 41.69,62.11 41.69,60.75 41.81,60.62 42.77,60.62 42.86,60.53 42.86,59.97 42.95,59.88 43.12,59.88 43.21,59.97 43.21,60.53 43.3,60.62 43.46,60.62 43.55,60.53 43.55,59.97 43.64,59.88 43.81,59.88 43.9,59.97 43.9,60.53 43.99,60.62 44.15,60.62 44.24,60.53 44.24,59.97 44.34,59.88 44.5,59.88 44.59,59.97 44.59,60.53 44.68,60.62 44.84,60.62 44.93,60.53 44.93,59.97 45.03,59.88 45.19,59.88 45.28,59.97 45.28,60.53 45.37,60.62 45.66,60.62 46.32,61.28 46.32,61.88 46.98,62.54 46.98,62.73 61.78,77.53 75.15,77.53 76.73,75.95 81.14,75.95 81.57,76.38 82.19,76.38 v1(82.66,75.9)
  BOTTOM w0.147: U80.35 43.08,64 43.27,63.81 v1(43.27,63.13)
PRG1_RGMII2_RD3: length 61.5
  TOP w0.147: U23.Y12 v1(83.46,75.9)
  L08_SIG2 w0.091: v1(83.46,75.9) 83.28,76.09 83.28,76.16 82.62,76.82 81.39,76.82 80.89,76.33 76.86,76.33 75.3,77.89 61.48,77.89 48.99,65.4 47.4,65.4 47.31,65.31 47.31,65.03 47.4,64.94 48.16,64.94 48.26,64.85 48.26,64.69 48.16,64.6 47.4,64.6 47.31,64.5 47.31,63.93 47.21,63.83 47.05,63.83 46.96,63.93 46.96,65.31 46.87,65.4 46.71,65.4 46.62,65.31 46.62,63.93 46.52,63.83 46.36,63.83 46.27,63.93 46.27,65.31 46.18,65.4 45.67,65.4 44.9,64.64 44.9,62.94 45.13,62.71 45.92,62.71 46,62.79 v1(46.37,62.79)
  BOTTOM w0.147: v1(46.37,62.79) 44.99,62.79 44.83,62.63 44.7,62.63 44.38,62.3 43.26,62.3 42.49,63.07 U80.36
PRG1_RGMII2_RESETN: length 18.3
  TOP w0.147: v1(28.3,61.85) 27.81,61.35 U31.4
  L08_SIG2 w0.091: v1(38.35,59.32) 37.47,58.43 35.43,58.43 31.5,62.37 28.83,62.37 v1(28.3,61.85)
  BOTTOM w0.147: U80.43 38.74,62.26 37.97,61.49 37.97,59.7 v1(38.35,59.32) ; R367.1 v1(28.3,61.85)
PRG1_RGMII2_RX_CTL: length 63.3
  TOP w0.147: R135.1 v1(43.05,61.61) ; U23.W12 v1(84.26,75.9)
  L08_SIG2 w0.091: v1(43.05,61.61) 43.69,61.61 44.69,62.61 44.69,64.71 45.69,65.72 45.91,65.72 46,65.81 46,66.59 46.1,66.68 46.26,66.68 46.35,66.59 46.35,65.81 46.44,65.72 46.6,65.72 46.7,65.81 46.7,66.59 46.79,66.68 46.95,66.68 47.04,66.59 47.04,65.81 47.13,65.72 48.01,65.72 48.11,65.81 48.11,66.58 48.2,66.67 48.36,66.67 48.45,66.58 48.45,65.81 48.54,65.72 48.99,65.72 49.19,65.92 49.19,66.05 48.89,66.35 48.89,66.48 49,66.6 49.13,66.6 49.43,66.29 49.56,66.29 49.68,66.41 49.68,66.54 49.38,66.84 49.38,66.97 49.49,67.08 49.62,67.08 49.92,66.78 50.05,66.78 50.17,66.9 50.17,67.03 49.86,67.33 49.86,67.64 50.04,67.82 50.93,67.82 61.21,78.11 75.38,78.11 76.98,76.51 80.79,76.51 81.3,77.02 82.7,77.02 83.27,76.45 83.31,76.45 83.46,76.3 83.86,76.3 v1(84.26,75.9)
  BOTTOM w0.147: U80.38 41.24,62.28 41.66,61.86 42.34,61.86 42.6,61.61 v1(43.05,61.61) R135.1
PRG1_RGMII2_RXC: length 61.5
  TOP w0.147: U23.U11 v1(85.86,77.5)
  L08_SIG2 w0.091: v1(43.31,65.49) 44.07,66.25 44.07,67.06 42.93,68.2 42.93,69.23 43.26,69.57 43.48,69.57 44.49,70.57 46.42,70.57 46.52,70.48 46.52,69.81 46.61,69.72 46.79,69.72 46.88,69.81 46.88,70.48 46.97,70.57 47.16,70.57 47.25,70.48 47.25,69.81 47.34,69.72 47.52,69.72 47.61,69.81 47.61,70.48 47.7,70.57 47.89,70.57 47.98,70.48 47.98,69.81 48.07,69.72 48.25,69.72 48.34,69.81 48.34,70.48 48.44,70.57 48.62,70.57 48.71,70.48 48.71,69.81 48.8,69.72 48.98,69.72 49.08,69.81 49.08,70.48 49.17,70.57 49.35,70.57 49.44,70.48 49.44,69.81 49.53,69.72 49.72,69.72 49.81,69.81 49.81,70.48 49.9,70.57 52.54,70.57 60.77,78.8 75.18,78.8 75.25,78.87 78.46,78.87 79.62,77.71 82.68,77.71 83.65,76.74 85.17,76.74 85.86,77.43 v1(85.86,77.5)
  BOTTOM w0.147: v1(43.31,65.49) 43.3,65.5 U80.32
PRG1_RGMII2_TD0: length 59.4
  TOP w0.147: U23.AA10 82.58,77.9 82.4,77.72 79.62,77.72 77.47,79.88 73.03,79.88 72.64,80.27 69.86,80.27 68.22,81.91 67.53,81.91 66.89,82.55 57.4,82.55 55.34,80.49 55.34,79.67 55.23,79.55 54.76,79.55 54.64,79.43 54.64,79.26 54.76,79.15 55.23,79.15 55.34,79.03 55.34,78.86 55.23,78.74 54.76,78.74 54.64,78.63 54.64,78.46 54.76,78.34 55.23,78.34 55.34,78.23 55.34,78.06 55.23,77.94 54.76,77.94 54.64,77.82 54.64,77.66 54.76,77.54 55.23,77.54 55.34,77.42 55.34,77.26 55.23,77.14 54.76,77.14 54.64,77.02 54.64,76.86 54.76,76.74 55.23,76.74 55.34,76.62 55.34,76.45 55.23,76.34 55.02,76.34 54.9,76.22 54.9,76.05 55.02,75.94 55.23,75.94 55.34,75.82 55.34,72.36 53.32,70.34 46.05,70.34 45.83,70.12 v1(44.83,70.12)
  BOTTOM w0.147: U80.28 43.35,67.5 44.2,68.34 44.2,69.48 v1(44.83,70.12)
PRG1_RGMII2_TD1: length 59.9
  TOP w0.147: U23.V10 v1(85.06,78.3)
  L08_SIG2 w0.091: v1(43.31,69.99) 44.32,71.01 45.07,71.01 45.16,71.1 45.16,71.41 45.25,71.5 45.43,71.5 45.53,71.41 45.53,71.1 45.62,71.01 45.8,71.01 45.89,71.1 45.89,71.41 45.98,71.5 46.17,71.5 46.26,71.41 46.26,71.1 46.35,71.01 46.53,71.01 46.62,71.1 46.62,71.41 46.71,71.5 46.9,71.5 46.99,71.41 46.99,71.1 47.08,71.01 47.26,71.01 47.36,71.1 47.36,71.36 47.45,71.45 47.63,71.45 47.72,71.36 47.72,71.1 47.81,71.01 49.84,71.01 49.93,71.1 49.93,71.75 50.02,71.84 50.19,71.84 50.28,71.75 50.28,71.1 50.37,71.01 50.53,71.01 50.62,71.1 50.62,71.75 50.71,71.84 50.88,71.84 50.97,71.75 50.97,71.1 51.06,71.01 51.22,71.01 51.31,71.1 51.31,71.75 51.4,71.84 51.57,71.84 51.66,71.75 51.66,71.1 51.75,71.01 52.45,71.01 60.61,79.17 75.03,79.17 75.69,79.83 78.02,79.83 79.77,78.07 82.63,78.07 83.74,76.96 85.08,76.96 85.46,77.34 85.46,77.91 v1(85.06,78.3)
  BOTTOM w0.147: v1(43.31,69.99) 43.81,69.48 43.81,69.17 43.82,69.16 43.82,68.79 43.81,68.78 43.81,68.38 43.43,68 U80.27
PRG1_RGMII2_TD2: length 59.5
  TOP w0.147: U23.U10 v1(85.86,78.3)
  L08_SIG2 w0.091: v1(43.36,68.98) 44.24,68.1 44.46,68.1 44.55,68.19 44.55,68.37 44.64,68.46 44.81,68.46 44.9,68.37 44.9,68.19 44.99,68.1 45.15,68.1 45.38,68.33 45.58,68.33 45.81,68.1 46.16,68.1 46.25,68.01 46.25,66.95 46.35,66.86 46.51,66.86 46.6,66.95 46.6,68.01 46.69,68.1 46.85,68.1 46.94,68.01 46.94,66.95 47.04,66.86 47.2,66.86 47.29,66.95 47.29,68.01 47.38,68.1 47.78,68.1 47.87,68.01 47.87,67.65 47.97,67.56 48.13,67.56 48.22,67.65 48.22,68.01 48.31,68.1 48.47,68.1 48.57,68.01 48.57,67.65 48.66,67.56 48.82,67.56 48.91,67.65 48.91,68.01 49,68.1 49.17,68.1 49.26,68.01 49.26,67.65 49.35,67.56 49.51,67.56 49.6,67.65 49.6,68.01 49.69,68.1 50.82,68.1 61.16,78.43 75.62,78.43 76.45,77.6 78.99,77.6 79.25,77.34 82.73,77.34 83.55,76.52 85.52,76.52 86.26,77.25 86.26,77.91 v1(85.86,78.3)
  BOTTOM w0.147: v1(43.36,68.98) 43.36,68.64 43.22,68.5 U80.26
PRG1_RGMII2_TD3: length 59.5
  TOP w0.147: U23.AA11 81.15,77.1 80.48,76.43 80.48,75.21 79.75,74.48 75.69,74.48 75.43,74.73 73.47,74.73 72.5,75.7 72.5,77.21 68.1,81.62 67.41,81.62 66.77,82.25 57.56,82.25 55.67,80.37 55.67,79.91 55.79,79.8 56.14,79.8 56.26,79.68 56.26,79.51 56.14,79.4 55.79,79.4 55.67,79.28 55.67,72.18 53.53,70.04 46.18,70.04 45.67,69.54 42.37,69.54 v1(41.65,68.82)
  BOTTOM w0.147: v1(41.65,68.82) 41.65,68.83 41.81,69 U80.25
PRG1_RGMII2_TX_CTL: length 59.7
  TOP w0.147: v1(41.53,63.64) 42.81,62.36 44.82,62.36 45.14,62.68 45.55,62.68 46.13,63.26 47.46,63.26 56,71.8 56,75.35 62.6,81.96 66.65,81.96 67.29,81.32 67.98,81.32 72.21,77.09 72.21,75.58 73.35,74.44 75.31,74.44 75.56,74.18 79.97,74.18 80.77,74.98 80.77,75.61 81.87,76.7 83.46,76.7 U23.Y11
  BOTTOM w0.147: v1(41.53,63.64) 41.74,63.43 U80.37
PRG1_RGMII2_TXC: length 60
  TOP w0.147: v1(75.82,80.39) 77.55,80.39 79.64,78.3 83.46,78.3 U23.Y10
  L08_SIG2 w0.091: v1(43.31,67) 42.55,67.77 42.55,70.36 44.07,71.88 46.1,71.88 46.48,72.26 53.09,72.26 60.36,79.53 60.6,79.53 60.69,79.62 60.69,80.68 60.78,80.77 60.96,80.77 61.05,80.68 61.05,79.62 61.15,79.53 61.33,79.53 61.42,79.62 61.42,80.68 61.51,80.77 61.69,80.77 61.79,80.68 61.79,79.62 61.88,79.53 62.06,79.53 62.15,79.62 62.15,80.68 62.24,80.77 62.43,80.77 62.52,80.68 62.52,79.62 62.61,79.53 62.89,79.53 62.98,79.62 62.98,80.66 63.07,80.75 63.25,80.75 63.34,80.66 63.34,79.62 63.44,79.53 68.99,79.53 69.85,80.39 v1(75.82,80.39)
  BOTTOM w0.147: U80.29 43.3,67 v1(43.31,67)
PRG1_RGMII_INTN: length 151
  TOP w0.147: U20.44 38.37,85.85 37.72,86.5 37.72,86.85 37.48,87.1 R105.1 37.13,87.1 36.8,87.43 v1(36.79,87.43)
  L03_SIG1 w0.091: v1(36.79,87.43) 36.79,85.4 36.8,85.39 36.8,76.97 36.68,76.85 36.68,70.78 36.66,70.77 v1(36.66,60.69)
  L08_SIG2 w0.091: v1(101.37,62.24) 101.37,64.5 101.7,64.83 101.7,67.31 98.3,70.71 98.3,72.07 98.09,72.28 96.14,72.28 95.89,72.53 95.88,72.53 95.88,74.52 95.7,74.7 95.23,74.7 95.08,74.86 95.08,77.66 94.81,77.92 94.39,77.92 94.25,77.79 94.25,77.26 94.12,77.13 92.1,77.13 91.85,77.38 91.85,79.36 91.72,79.49 88.09,79.49 87.87,79.27 87.87,77.38 87.07,76.59 87.07,74.87 86.91,74.71 81.63,74.71 80.59,75.75 80.32,75.75 76.67,75.75 75.07,77.34 61.86,77.34 47.17,62.65 47.17,62.46 46.78,62.08 46.78,60.42 45.31,58.94 39.37,58.94 37.62,60.69 v1(36.66,60.69)
  BOTTOM w0.147: v1(36.66,60.69) 36.67,60.69 37,61.02 R368.1 37.59,61.28 37.59,61.62 38.24,62.26 U80.44 ; R250.1 37.59,105.68 36.7,104.79 36.7,97.04 35.94,96.28 35.94,90.95 36.96,89.93 36.96,87.6 v1(36.79,87.43) ; v1(101.37,62.24) 100.86,62.24 99.46,63.64 R597.1
PRG1_RGMII_INTN_RC: length 9.8
  TOP w0.147: v1(101.27,65.7) 100.82,65.7 99.06,67.46 99.06,68.47 98.66,68.87 98.66,70.07 98.42,70.3 97.86,70.3 U23.C19
  BOTTOM w0.147: v1(101.27,65.7) 100.73,65.15 C491.1 R597.2
PRG_EARTH: length 3.3
  BOTTOM w0.254: v1(4.06,85.1) 2.85,85.1 C295.1 2.85,84.14 v1(2.79,84.09)
  BOTTOM w0.381: R304.1 5.78,85.99 v1(6.11,86.31)
PRI_INN: length 7.2
  TOP w0.147: v1(63.11,105.56) 62.66,105.12 62.66,103.72 v1(63.5,102.88) R55.1
  BOTTOM w0.147: C252.2 R55.1 v1(63.5,102.88) ; U70.14 v1(63.11,105.56)
RESETSTATZ: length 215.3
  TOP w0.147: v1(59.95,33.7) 55.86,37.78 40.19,37.78 38.23,39.75 v1(38.23,43.83) ; TP68.1 106.96,41.7 v1(108.08,42.81) ; U23.F16 v1(95.46,72.7) ; U54.2 v1(116.46,25.03)
  L03_SIG1 w0.091: 116.46,26.43 v1(116.46,25.03) ; 116.46,26.43 113.41,29.48 113.41,37.04 113.06,37.39 113.06,38.97 109.22,42.81 v1(108.08,42.81) ; 116.46,26.43 122.81,32.78 122.81,51.53 123.22,51.93 123.22,52.82 122.84,53.2 109.25,53.2 106.68,55.77 106.68,63.64 103.98,66.33 103.98,70.3 103.62,70.66 103.01,70.66 v1(102.74,70.4)
  L08_SIG2 w0.091: v1(59.95,33.7) 60.22,33.43 60.3,33.43 60.96,32.77 60.96,26.94 64.39,23.51 77.34,23.51 82.01,18.84 91.03,18.84 93.51,21.32 99.46,21.32 102.28,18.5 110.94,18.5 116.46,24.02 v1(116.46,25.03)
  BOTTOM w0.114: 98.39,73.1 97.31,73.1 95.86,73.1 v1(95.46,72.7)
  BOTTOM w0.147: U86.3 32.27,44.2 32.77,43.7 33.66,43.7 34.29,44.34 37.72,44.34 v1(38.23,43.83) U88.2 ; 98.39,73.1 99.17,73.1 101.31,70.97 102.17,70.97 v1(102.74,70.4) 103.07,70.73 104.06,70.73 R344.2 ; U85.2 v1(108.08,42.81) 106.95,41.69 R435.2 ; v1(59.95,33.7) 59.5,33.7 59.21,33.41 U91.28
SEL_XDS: length 68.4
  TOP w0.147: v1(104.52,34.3) 104.52,33.67 104.76,33.43 U47.4 ; U56.4 v1(136.06,23.47) ; v1(94.61,35.57) 94.75,35.57 94.88,35.44 U45.6
  L08_SIG2 w0.091: v1(94.61,35.57) 95,35.19 103.63,35.19 v1(104.52,34.3) 105.06,33.76 105.07,33.76 106.6,32.24 111.36,32.24 119.58,24.02 119.63,24.02 119.73,23.92 135.61,23.92 v1(136.06,23.47) 136.54,23.95 137.53,23.95 141.53,19.94 147.94,19.94 v1(149.79,18.1)
  BOTTOM w0.147: v1(149.79,18.1) U98.15 150.39,17.55 150.53,17.41 150.75,17.41 150.89,17.55 U98.14
SEL_XDS110_INV: length 155.2
  TOP w0.147: U60.15 109.02,13.43 109.52,13.93 109.52,16.56 110.59,17.63 111.44,17.63 113.16,19.34 113.16,31.59 v1(112.24,32.5) 112.2,32.54 R184.1 R183.1 109.2,32.54 108.97,32.78 U47.2 ; v1(91.69,33.03) 91.69,33.31 91.28,33.73 U46.4 ; v1(71.72,26.42) 73.44,26.42 73.62,26.6 U52.1 74.32,27.55 75.45,26.42 v1(77.31,26.42) 79,26.42 79.21,26.63 U53.1 ; v1(138.59,27.69) 138.57,27.69 138.56,27.7 138.55,27.7 U55.6 ; v1(73.27,37.58) 73.27,38.09 72.48,38.88 72.01,38.88 71.63,39.26 71.63,39.64 71.88,39.89 J25.8 ; U37.14 87.69,46.5 87.88,46.3 v1(87.88,46.28) 88.19,46.58 U37.15
  L03_SIG1 w0.091: v1(87.88,46.28) 89.79,44.38 89.79,40.53 91.69,38.62 v1(91.69,33.03)
  L08_SIG2 w0.091: v1(77.31,26.42) 73.28,30.45 73.28,37.2 73.27,37.21 v1(73.27,37.58) ; v1(138.59,27.69) 138.14,27.25 132.01,27.25 129.29,24.53 119.7,24.53 112.24,31.98 v1(112.24,32.5)
  BOTTOM w0.147: U94.1 v1(71.72,26.42) ; U93.1 77.27,27.52 77.27,26.45 v1(77.31,26.42) ; J33.58 76.72,39.63 75.86,38.77 75.86,38.52 ; 75.86,38.52 75.71,38.37 74.05,38.37 v1(73.27,37.58) ; 75.86,38.52 75.86,38.38 76.27,37.97 81.77,37.97 87.88,44.08 v1(87.88,46.28) ; v1(112.24,32.5) 104.95,32.5 103.1,30.65 94.72,30.65 92.33,33.03 v1(91.69,33.03)
SERDES0_ATB_0: length 3.2
  TOP w0.147: U23.W15 v1(84.26,73.5)
  BOTTOM w0.114: TP66.1 82.3,73.8 82.4,73.9 83.86,73.9 v1(84.26,73.5)
SERDES0_ATB_1: length 13.8
  TOP w0.147: U23.V16 v1(85.06,72.7)
  L08_SIG2 w0.091: v1(79.38,68.85) 81.04,68.85 81.33,69.14 81.33,69.87 82.04,70.58 82.04,71.39 82.8,72.15 83.51,72.15 83.86,72.5 83.86,72.79 83.87,72.81 83.87,72.88 84.09,73.1 84.66,73.1 v1(85.06,72.7)
  BOTTOM w0.147: TP73.1 75.69,68.24 76.3,68.85 v1(79.38,68.85)
SERDES0_REXT: length 20
  TOP w0.147: U23.T13 v1(86.66,75.1)
  L03_SIG1 w0.091: v1(86.66,75.1) 86.27,74.72 86.27,73.18 86.18,73.09 85.64,73.09 85.44,72.89 85.44,72.42 85.32,72.3 84.9,72.3 84.64,72.04 84.64,71.75 84.42,71.52 82.05,71.52 81.71,71.18 79.31,71.18 78.49,72.01 78.49,72.24 78.23,72.49 78,72.49 76.64,73.85 75.86,73.85 74.42,75.28 v1(74.42,75.69)
  BOTTOM w0.147: R338.1 74.18,75 74.42,75.24 v1(74.42,75.69)
SERDES_REFCLK0_N: length 85.6
  L08_SIG2 w0.081: v1(79.55,72.47) 79.79,72.22 arc(79.82,72.21) 79.85,72.2 80.31,72.2 arc(80.55,72.3) 80.64,72.53 arc(80.31,73.35) 79.5,73.68 75.28,73.68 arc(74.58,73.82) 73.99,74.22 73.78,74.43 arc(73.15,74.85) 72.41,74.99 65.04,74.99 arc(62.97,74.58) 61.22,73.41 52.92,65.11 arc(52.15,63.96) 51.88,62.6 51.88,58.93 arc(51.41,56.58) 50.08,54.58 45.01,49.51 arc(42.78,48.02) 40.14,47.5 35.28,47.5 arc(33.49,47.14) 31.97,46.13 arc(31.2,44.97) 30.92,43.6 30.92,40.6 arc(30.43,39.4) 29.23,38.91 25.28,38.91 arc(24.46,38.57) 24.12,37.74 24.12,36.08 arc(24.16,35.98) 24.26,35.94 24.77,35.94 J27.A14
  BOTTOM w0.108: R333.1 R339.1 80.16,72.33 arc(80.11,72.23) 80.01,72.19 79.65,72.19 arc(79.58,72.22) 79.55,72.29 v1(79.55,72.47)
SERDES_REFCLK0_N_R: length 4.4
  TOP w0.14: U23.W16 v1(84.26,72.7)
  BOTTOM w0.108: R339.2 81.13,72.37 arc(81.19,72.24) 81.32,72.19 83.47,72.19 arc(83.59,72.21) 83.69,72.28 83.7,72.29 arc(83.87,72.4) 84.07,72.44 84.16,72.44 arc(84.23,72.47) 84.26,72.54 v1(84.26,72.7)
SERDES_REFCLK0_P: length 88.4
  L08_SIG2 w0.081: v1(79.55,71.62) 79.79,71.86 arc(79.82,71.88) 79.85,71.88 80.31,71.88 arc(80.77,72.07) 80.96,72.53 arc(80.53,73.57) 79.5,74 75.28,74 arc(74.7,74.12) 74.22,74.44 74.01,74.65 arc(73.28,75.14) 72.41,75.31 65.04,75.31 arc(62.85,74.87) 60.99,73.63 52.7,65.34 arc(51.86,64.08) 51.56,62.6 51.56,58.93 arc(51.12,56.7) 49.86,54.81 44.79,49.74 arc(42.66,48.32) 40.14,47.82 35.28,47.82 arc(33.37,47.44) 31.75,46.35 arc(30.9,45.09) 30.61,43.6 30.61,40.6 arc(30.2,39.63) 29.23,39.22 25.28,39.22 arc(24.23,38.79) 23.8,37.74 23.8,36.08 23.78,36.06 J27.A13
  BOTTOM w0.108: v1(79.55,71.62) 79.73,71.8 arc(79.78,71.83) 79.83,71.86 arc(79.9,71.89) 79.98,71.9 80.01,71.9 arc(80.11,71.85) 80.16,71.75 R342.1 R346.1
SERDES_REFCLK0_P_R: length 4.4
  TOP w0.14: U23.W17 v1(84.26,71.9)
  BOTTOM w0.108: v1(84.26,71.9) 84.26,72.05 arc(84.23,72.12) 84.16,72.15 84.07,72.15 arc(83.98,72.13) 83.91,72.08 83.9,72.07 arc(83.7,71.94) 83.47,71.9 81.26,71.9 arc(81.17,71.86) 81.13,71.77 R342.2
SERDES_RXN0: length 87.3
  TOP w0.14: U23.Y15 v1(83.46,73.5)
  L08_SIG2 w0.081: v1(83.46,73.5) 83.22,73.26 arc(83.19,73.24) 83.15,73.22 83.14,73.21 83.1,73.21 arc(82.85,73.16) 82.64,73.02 81.33,71.71 arc(80.52,71.17) 79.57,70.98 77.6,70.98 arc(75.61,71.38) 73.93,72.5 73.66,72.77 arc(73.32,73.07) 72.94,73.31 72.61,73.48 arc(72.39,73.56) 72.15,73.59 arc(71.83,73.64) 71.51,73.66 65.24,73.66 arc(63.88,73.39) 62.73,72.62 56.65,66.54 arc(56.65,66.54) 56.65,66.54 56.58,66.49 55.51,65.42 arc(54.05,63.22) 53.53,60.64 53.53,50.29 arc(53.16,48.42) 52.1,46.83 51.13,45.86 arc(49.99,45.1) 48.64,44.83 45.21,44.83 arc(43.34,44.46) 41.76,43.4 36.6,38.24 arc(35.57,37.55) 34.36,37.31 30.05,37.31 arc(29.84,37.35) 29.67,37.47 29.61,37.53 arc(29.42,37.66) 29.19,37.7 26.28,37.7 arc(25.97,37.57) 25.84,37.27 25.84,36.45 25.77,35.86 arc(25.83,35.59) 25.98,35.36 27.18,34.16 arc(27.41,34) 27.68,33.95 J27.A17
SERDES_RXP0: length 87.4
  TOP w0.14: U23.Y16 v1(83.46,72.7)
  L08_SIG2 w0.081: v1(83.46,72.7) 83.39,72.78 arc(83.26,72.86) 83.1,72.89 arc(82.97,72.87) 82.86,72.79 81.55,71.48 arc(80.64,70.88) 79.57,70.66 77.6,70.66 arc(75.49,71.08) 73.7,72.28 73.44,72.55 arc(73.13,72.81) 72.79,73.02 arc(72.44,73.18) 72.08,73.28 arc(71.8,73.33) 71.51,73.34 65.24,73.34 arc(64,73.1) 62.95,72.39 56.88,66.32 arc(56.86,66.3) 56.84,66.28 56.79,66.25 55.74,65.19 arc(54.34,63.1) 53.85,60.64 53.85,50.29 arc(53.45,48.3) 52.32,46.61 51.36,45.64 arc(50.11,44.81) 48.64,44.51 45.21,44.51 arc(43.46,44.17) 41.98,43.18 36.82,38.01 arc(35.69,37.26) 34.36,36.99 30.05,36.99 arc(29.72,37.06) 29.45,37.24 29.39,37.3 arc(29.3,37.36) 29.19,37.38 28.96,37.38 arc(28.84,37.33) 28.79,37.21 28.79,37.06 arc(28.62,36.9) 28.46,37.06 28.46,37.21 arc(28.29,37.38) 28.12,37.21 28.12,36.96 arc(27.95,36.79) 27.79,36.96 27.79,37.21 arc(27.62,37.38) 27.45,37.21 27.45,36.99 arc(27.28,36.82) 27.12,36.99 27.12,37.21 arc(26.95,37.38) 26.78,37.21 26.78,36.99 arc(26.61,36.82) 26.45,36.99 26.45,37.21 arc(26.4,37.33) 26.28,37.38 arc(26.2,37.35) 26.16,37.27 26.16,36.45 arc(26.18,36.35) 26.24,36.27 26.4,36.11 arc(26.57,35.99) J27.A16
SERDES_TXN0: length 90.4
  TOP w0.108: C100.1 74.3,71.09 arc(74.26,71.07) 74.22,71.06 73.81,71.06 arc(73.77,71.07) 73.75,71.09 v1(73.47,71.37)
  L08_SIG2 w0.081: v1(73.47,71.37) 73.2,71.1 arc(73.18,71.08) 73.14,71.07 72.95,71.07 arc(72.77,71.04) 72.62,70.94 72.47,70.78 arc(72.3,70.67) 72.1,70.63 71.24,70.63 arc(70.76,70.72) 70.36,70.99 70.36,70.99 arc(69.72,71.42) 68.98,71.56 64.98,71.56 arc(64.49,71.47) 64.08,71.19 62,69.11 arc(61.54,68.42) 61.38,67.62 61.38,62.01 arc(61.38,62) 61.38,61.99 arc(61.29,61.78) 61.15,61.6 56.45,56.89 arc(55.96,56.17) 55.8,55.32 55.8,45.91 arc(55.35,43.66) 54.08,41.76 50.31,37.99 arc(49.92,37.4) 49.78,36.71 49.78,26.62 arc(49.65,25.96) 49.28,25.4 arc(48.43,24.84) 47.44,24.64 32.93,24.64 arc(32.14,24.8) 31.47,25.24 30.45,26.26 arc(29.59,26.83) 28.57,27.03 27.97,27.03 arc(27.66,27.1) 27.4,27.27 25.9,28.77 arc(25.88,28.79) 25.87,28.81 arc(25.8,28.93) 25.78,29.06 J27.B15
SERDES_TXN0_C: length 8.9
  TOP w0.108: U23.AA16 82.71,73.1 arc(82.63,73.07) 82.6,73 82.6,72.96 arc(82.57,72.88) 82.49,72.85 81.92,72.85 arc(81.58,72.78) 81.29,72.59 79.86,71.16 arc(79.78,71.1) 79.69,71.06 75.72,71.06 arc(75.45,71.11) 75.22,71.27 75.13,71.36
SERDES_TXP0: length 90.4
  TOP w0.108: v1(73.47,70.46) 73.75,70.74 arc(73.76,70.75) 73.78,70.76 73.83,70.77 74.22,70.77 arc(74.26,70.76) 74.3,70.74 C102.1
  L08_SIG2 w0.081: J27.B14 25.62,28.61 arc(25.64,28.58) 25.67,28.55 25.84,28.38 arc(25.89,28.26) 25.84,28.14 25.75,28.05 arc(25.75,27.81) 25.99,27.81 26.08,27.9 arc(26.32,27.9) 26.32,27.67 26.26,27.61 arc(26.26,27.37) 26.5,27.37 26.55,27.43 arc(26.67,27.48) 26.79,27.43 27.17,27.05 arc(27.54,26.8) 27.97,26.72 28.57,26.72 arc(29.47,26.54) 30.23,26.03 31.24,25.02 arc(32.02,24.5) 32.93,24.32 47.44,24.32 arc(48.55,24.54) 49.5,25.18 arc(49.94,25.84) 50.1,26.62 50.1,36.71 arc(50.21,37.28) 50.54,37.77 54.3,41.53 arc(55.64,43.54) 56.11,45.91 56.11,55.32 arc(56.26,56.05) 56.67,56.67 61.38,61.37 arc(61.57,61.62) 61.68,61.91 arc(61.69,61.96) 61.7,62.01 61.7,67.62 arc(61.83,68.3) 62.22,68.88 64.3,70.97 arc(64.61,71.17) 64.98,71.25 68.98,71.25 arc(69.6,71.12) 70.13,70.77 arc(70.64,70.43) 71.24,70.31 72.1,70.31 arc(72.42,70.37) 72.69,70.55 72.85,70.71 arc(72.89,70.74) 72.95,70.75 73.14,70.75 arc(73.18,70.75) 73.2,70.73 v1(73.47,70.46)
SERDES_TXP0_C: length 8.9
  TOP w0.108: U23.AA17 82.71,72.3 arc(82.63,72.34) 82.6,72.41 82.6,72.45 arc(82.57,72.53) 82.49,72.56 81.92,72.56 arc(81.69,72.51) 81.5,72.39 80.07,70.95 arc(79.91,70.84) 79.73,70.77 75.53,70.77 arc(75.43,70.75) 75.35,70.69 75.13,70.47
SOC_CLKIN: length 101.9
  TOP w0.147: R137.1 v1(98.21,61.95)
  L03_SIG1 w0.091: v1(78.74,65.17) 77.71,65.17 75.05,67.83 73.17,67.83 72.44,68.55 72.44,72.29 70.67,74.06 62.48,74.06 60.33,76.21 60.33,85.61 v1(62.61,87.9)
  L08_SIG2 w0.091: v1(98.21,61.95) 98.21,57.71 92.46,51.96 83.69,51.96 79.25,56.4 79.25,64.66 v1(78.74,65.17)
  BOTTOM w0.147: U73.4 70.89,101.07 71.17,101.35 72.16,101.35 73.79,99.72 73.79,89.55 72.14,87.9 v1(62.61,87.9)
SOC_CLKIN_3V3: length 2.4
  BOTTOM w0.147: U73.2 66.8,100.42 66.72,100.34 R272.2
SOC_DVDD1V8: length 4.3
  TOP w0.254: U23.M15 v1(89.86,73.5) ; U23.E12 v1(96.26,75.9) ; U23.K14 v1(92.26,74.3) ; U23.J15 v1(93.06,73.5) ; U23.M14 v1(89.86,74.3) ; U23.K16 v1(92.26,72.7)
  BOTTOM w0.254: v1(96.26,75.9) 96.41,75.9 C359.1 ; C379.1 89.74,73.62 v1(89.86,73.5) ; v1(92.26,72.7) 92.27,72.71 C383.1
  vias: v1(106.83,73.5) v1(108.23,73.47) v1(108.96,73.5) v1(126.62,111.01) v1(126.62,110) v1(126.62,108.98) v1(126.62,107.96) v1(127.64,111.01) v1(127.64,110) v1(127.64,108.98) v1(127.64,107.96) v1(128.65,111.01) v1(128.65,110) v1(128.65,108.98) v1(128.65,107.96)
SOC_DVDD3V3: length 15.7
  TOP w0.254: U23.G14 v1(94.66,74.3) ; U23.F13 v1(95.46,75.1) ; U23.G8 v1(94.66,79.9) ; U23.R13 v1(87.46,75.1) ; U23.F9 v1(95.46,79.1) ; U23.R10 v1(87.46,78.3) ; U23.F11 v1(95.46,77.5) ; U23.G12 v1(94.66,75.9) ; U23.F14 v1(95.46,74.3) ; U23.P7 v1(88.26,80.7) ; U23.T9 v1(86.66,79.1) ; U23.P15 v1(88.26,73.5) ; U23.P14 v1(88.26,74.3) ; U23.R8 v1(87.46,79.9) ; U23.M7 v1(89.86,80.7) ; U23.G10 v1(94.66,78.3) ; U23.N6 v1(89.06,81.5)
  L06_PWR2 w0.381: v1(88.26,73.5) v1(88.26,74.3)
  BOTTOM w0.254: C361.1 95.45,75.11 v1(95.46,75.1) ; C326.1 86.78,79.22 v1(86.66,79.1) ; C331.1 94.65,78.31 v1(94.66,78.3) ; v1(94.66,79.9) 94.78,79.78 C321.1 ; C351.1 v1(94.66,75.9) ; C333.1 87.58,78.42 v1(87.46,78.3) ; C378.1 v1(88.26,73.5) ; C319.1 87.34,80.02 v1(87.46,79.9) ; v1(87.46,75.1) 87.34,75.22 C360.1 ; v1(89.06,81.5) 88.94,81.62 C304.1 ; v1(89.86,80.7) 89.98,80.82 C309.1 ; C312.1 88.38,80.82 v1(88.26,80.7) ; v1(95.46,79.1) 95.61,79.1 C328.1 ; C337.1 95.58,77.62 v1(95.46,77.5) 95.58,77.38 C343.1 ; C376.1 94.85,74.11 v1(94.66,74.3) ; C374.1 95.58,74.18 v1(95.46,74.3)
  vias: v1(103.35,73.5) v1(104.41,73.5) v1(133.35,92.6) v1(133.35,91.58) v1(133.35,90.57) v1(133.35,89.55) v1(134.37,92.6) v1(134.37,91.58) v1(134.37,90.57) v1(134.37,89.55) v1(135.38,92.6) v1(135.38,91.58) v1(135.38,90.57) v1(135.38,89.55)
SOC_EMU0: length 131.2
  TOP w0.147: U55.5 139.05,27.48 v1(139.57,28) ; U45.5 96.89,35.94 97.32,36.37 102.4,36.37 106.17,40.15 106.17,46.09 113.33,53.25 122.5,53.25 126.28,57.03 126.28,60.72 125.41,61.6 124.49,61.6 124.35,61.45 124.35,61.11 v1(124.08,60.85) ; U23.D10 v1(97.06,78.3)
  L03_SIG1 w0.091: v1(97.06,78.3) 97.46,78.71 101.5,78.71 101.78,78.43 102.92,78.43 103.59,77.77 111.4,77.77 116.1,73.07 116.1,67.29 116.74,66.65 120.02,66.65 124.43,62.24 124.43,61.2 v1(124.08,60.85)
  L08_SIG2 w0.091: v1(124.08,60.85) 123.7,60.47 123.7,59.07 124.56,58.21 125.49,58.21 127.58,56.12 127.58,39.62 138.9,28.31 139.26,28.31 v1(139.57,28)
SOC_EMU1: length 141.9
  TOP w0.147: U55.4 v1(139.57,23.51) ; v1(98.04,35.83) 98.08,35.83 98.2,35.94 U45.4 ; U23.E10 v1(96.26,78.3)
  L03_SIG1 w0.091: v1(107.61,59.35) 107.61,58.73 107.44,58.56 107.44,57.42 107.85,57.02 107.85,56 110.21,53.64 123.32,53.64 125.6,51.36 125.6,27.07 128.71,23.95 139.13,23.95 v1(139.57,23.51)
  L08_SIG2 w0.091: v1(107.61,59.35) 107.88,59.09 109.8,59.09 110.29,59.58 110.29,63.26 108.2,65.35 108.2,68.57 108.16,68.61 108.16,68.68 103.86,72.98 103.86,73.78 103.33,74.31 100.33,74.31 98.04,76.6 97.16,76.6 96.66,77.09 96.66,77.73 96.26,78.13 v1(96.26,78.3) ; v1(139.57,23.51) 138.81,24.27 136.14,24.27 135.98,24.1 119.81,24.1 111.49,32.43 107.16,32.43 103.35,36.24 98.45,36.24 v1(98.04,35.83)
SOC_I2C0_SCL: length 135.2
  TOP w0.147: J2.E1 v1(74.55,132.35) ; v1(105.99,119.44) 105.9,119.53 U7.6 103.64,119.53 103.38,119.79 103.38,122.93 J5.3 106.02,125.57 107.87,125.57 108.58,124.86 108.58,123.54 109.29,122.83 113.41,122.83 115.88,120.36 115.88,116.14 112.18,112.44 112.18,90.05 113.37,88.86 113.37,83.02 116.28,80.11 116.28,69.64 112.69,66.05 109.27,66.05 109.17,66.16 v1(108.71,66.16)
  L03_SIG1 w0.091: J5.3 104.85,122.12 101.94,119.21 94.16,119.21 88.77,124.6 85.85,124.6 83.41,127.05 79.92,127.05 77.5,129.46 77.5,130.61 75.76,132.35 v1(74.55,132.35)
  BOTTOM w0.147: U7.6 105.9,119.53 v1(105.99,119.44) ; R598.1 103.9,66.17 104.34,65.73 108.28,65.73 v1(108.71,66.16) 109.45,65.42 R358.2
