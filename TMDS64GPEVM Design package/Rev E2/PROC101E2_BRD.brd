# Allegro board PROC101E2_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MCU_RESETSTATZ: length 212.1
  TOP w0.147: v1(102.49,75.07) 101.66,75.9 98.66,75.9 U23.B13 ; J2.E3 v1(72.01,132.35) ; TP1.1 164.59,127.54 J1.19
  L03_SIG1 w0.091: J1.19 163.32,129.94 137.79,129.94 134.88,127.02 99.15,127.02 93.32,132.86 86.11,132.86 85.22,131.97 85.22,130.19 82.3,127.27 80.01,127.27 77.72,129.55 77.72,130.7 75.64,132.79 72.45,132.79 v1(72.01,132.35)
  L08_SIG2 w0.091: J1.19 153.25,117.32 124.24,117.32 120.74,113.82 120.74,112.32 119.86,111.43 119.86,88.44 114.7,83.28 114.7,82.31 113.28,80.89 113.28,77.64 110.72,75.07 v1(102.49,75.07)
MCU_RESETZ: length 175
  TOP w0.147: TP46.1 123.72,26.08 123.93,26.28 123.93,26.89 123.24,27.57 122.43,27.57 U50.7 121.55,27.58 121.41,27.72 v1(121.41,27.83) ; U23.B12 98.66,76.7 99.22,76.7 99.34,76.82 100.87,76.82 v1(101.35,76.34) 101.67,76.66 102.06,76.66 103.31,77.92 103.31,79.35 104.39,80.43 104.39,81.48 104.83,81.91 v1(105.28,81.91) ; J2.D3 v1(72.01,131.08)
  L03_SIG1 w0.091: v1(105.28,81.91) 105.94,82.57 105.94,83.48 106.93,84.47 106.93,102.83 97.47,112.29 78.11,112.29 75.2,115.2 73.49,115.2 70.67,118.03 70.67,126.31 72.62,128.26 72.62,130.47 72.01,131.08 v1(72.01,131.08) ; v1(125.22,57.55) 124.09,58.69 118.39,58.69 116.5,60.58 116.5,65.49 115,66.99 115,72.59 112.06,75.52 103.31,75.52 102.49,76.34 v1(101.35,76.34)
  L08_SIG2 w0.091: v1(125.22,57.55) 127.18,55.59 127.18,38.95 127.89,38.24 127.89,30.08 127.71,29.9 127.71,29.53 127.89,29.35 127.89,28.56 127.88,28.55 127.88,28.2 127.89,28.2 127.89,27.97 124.7,24.78 122.17,24.78 121.41,25.54 v1(121.41,27.83)
  BOTTOM w0.147: R477.2 121.79,27.45 v1(121.41,27.83)
MCU_SAFETY_ERRORZ_1V8: length 75.7
  TOP w0.147: v1(114.68,66.18) 113.61,65.11 103.05,65.11 99.95,68.21 99.95,69.01 U23.A20 ; U10.4 v1(126.73,115.06)
  L08_SIG2 w0.091: v1(114.68,66.18) 116.57,68.07 117.87,68.07 120.96,71.17 120.96,106.04 124.16,109.24 124.16,112.5 v1(126.73,115.06)
  BOTTOM w0.147: TP72.1 v1(114.68,66.18)
MCU_SAFETY_ERRORZ_3V3: length 51.1
  TOP w0.147: U10.1 v1(125.23,115.06)
  L08_SIG2 w0.091: v1(125.23,115.06) 125.23,115.73 126.6,117.1 155.17,117.1 165.74,127.66 165.74,129.81 J1.22
MCU_SPI0_CLK: length 78.7
  L08_SIG2 w0.091: v1(114.05,88.15) 118.34,92.45 118.34,113.67 123.1,118.42 143.07,118.42 147.42,122.77 154.76,122.77 158.24,126.25 158.24,130.19 159.26,131.21 J1.16
  BOTTOM w0.147: R302.1 v1(114.05,88.15)
MCU_SPI0_CLK_R: length 21
  TOP w0.147: U23.E6 v1(96.26,81.5)
  BOTTOM w0.114: 99.69,81.9 96.66,81.9 v1(96.26,81.5)
  BOTTOM w0.147: R302.2 111.45,88.15 110.01,86.72 101.94,86.72 99.95,84.72 99.95,82.16 99.69,81.9
MCU_SPI0_CS0: length 85.8
  TOP w0.147: U23.D6 v1(97.06,81.5)
  L08_SIG2 w0.091: J1.6 145.48,129.88 145.48,128.2 144.3,127.02 143.9,127.02 143.38,126.5 143.38,126.1 140.05,122.78 122.24,122.78 116.13,116.67 116.13,97.64 111.81,93.32 110.67,93.32 107.56,90.22 107.56,87.06 102,81.49 101.19,81.49 100.36,80.66 99.31,80.66 98.87,81.1 97.46,81.1 v1(97.06,81.5)
MCU_SPI0_CS1: length 80.3
  TOP w0.147: U23.C6 v1(97.86,81.5)
  L08_SIG2 w0.091: J1.3 143.13,127.52 143.13,126.16 139.96,123 122.15,123 115.91,116.76 115.91,97.73 111.72,93.54 110.58,93.54 107.34,90.31 107.34,87.1 102.68,82.44 101.14,82.44 100.21,81.5 v1(97.86,81.5)
MCU_SPI0_D0: length 85
  TOP w0.147: U23.E7 v1(96.26,80.7)
  L08_SIG2 w0.091: J1.4 142.88,129.81 142.88,126.22 139.87,123.22 122.06,123.22 115.69,116.85 115.69,97.83 111.63,93.76 110.48,93.76 107.12,90.4 107.12,87.13 102.66,82.67 101.09,82.67 100.34,81.92 96.91,81.92 96.66,81.67 96.66,81.11 v1(96.26,80.7)
MCU_SPI0_D1: length 81.2
  TOP w0.147: v1(103.72,88.24) 102.97,87.48 102.11,87.48 100.84,86.2 100.84,82.95 99.4,81.5 98.66,81.5 U23.B6
  L08_SIG2 w0.091: J1.2 140.43,129.9 140.43,124.26 139.6,123.44 121.96,123.44 115.47,116.94 115.47,97.92 111.54,93.98 110.39,93.98 106.91,90.5 106.91,89.38 105.76,88.24 v1(103.72,88.24)
MCU_UART0_CTS_3V3: length 65.4
  TOP w0.147: U23.D8 v1(97.06,79.9)
  L03_SIG1 w0.091: v1(116.78,68.7) 116.52,68.44 116.52,67.39 116.89,67.02 120.26,67.02 125.77,61.52 131.23,61.52 133.64,59.1 135.31,59.1 140.17,54.24 v1(144.02,54.24)
  BOTTOM w0.114: v1(97.06,79.9) 97.46,79.5 98.3,79.5
  BOTTOM w0.147: v1(116.78,68.7) 113.51,68.7 112.77,67.96 108.52,67.96 107.89,68.59 107.89,70.65 107.14,71.4 102.61,71.4 102.34,71.67 102.34,72.56 101.49,73.4 100.63,73.4 99.72,74.31 99.72,78.95 99.22,79.45 98.36,79.45 98.3,79.5 ; v1(144.02,54.24) 143.6,53.83 U82.9
MCU_UART0_RTS_3V3: length 66.4
  TOP w0.147: U23.E8 v1(96.26,79.9)
  L03_SIG1 w0.091: v1(142.05,56.09) 142.51,55.63 142.51,54.89 142.11,54.5 140.22,54.5 135.4,59.32 133.73,59.32 131.32,61.74 125.86,61.74 120.1,67.5 v1(117.08,67.5)
  BOTTOM w0.114: 98.51,79.02 98.19,78.7 96.89,78.7 96.66,78.94 96.66,79.5 v1(96.26,79.9)
  BOTTOM w0.147: v1(142.05,56.09) 142.57,55.57 142.57,54.43 ; 98.51,79.02 99.24,79.02 99.41,78.85 99.41,73.27 101.39,71.3 102.29,71.3 102.48,71.1 107.02,71.1 107.59,70.53 107.59,68.46 108.4,67.66 112.89,67.66 113.63,68.4 116.18,68.4 v1(117.08,67.5)
MCU_UART0_RX_3V3: length 63
  TOP w0.147: v1(101.73,79.14) 101.31,78.71 101.04,78.71 101.01,78.69 99.56,78.69 99.54,78.7 U23.A9
  L03_SIG1 w0.091: v1(145.03,54.24) 144.45,53.66 142.13,53.66 141.77,54.02 140.07,54.02 135.21,58.88 133.55,58.88 131.13,61.3 125.64,61.3 120.1,66.84 116.81,66.84 116.32,67.33 116.32,73.16 111.49,77.99 103.68,77.99 103.02,78.65 102.21,78.65 v1(101.73,79.14)
  BOTTOM w0.147: U82.8 142.97,54.63 143.26,54.93 144.35,54.93 v1(145.03,54.24)
MCU_UART0_TX_3V3: length 58.2
  TOP w0.147: v1(103.6,80.66) 102.56,79.62 100.76,79.62 100.65,79.5 U23.A8
  L03_SIG1 w0.091: v1(103.6,80.66) 104.16,80.66 106.17,78.65 113.34,78.65 115.37,76.62 115.37,74.64 116.59,73.42 116.59,69.69 118.26,68.01 119.96,68.01 125.98,61.99 133.22,61.99 138.43,56.78 140.42,56.78 v1(142.07,55.13)
  BOTTOM w0.147: v1(142.07,55.13) 142.17,55.04 U82.6
MCU_UART1_CTS_3V3: length 89.5
  TOP w0.147: v1(102.74,80.66) 101.99,79.91 101.35,79.91 101.34,79.9 98.66,79.9 U23.B8
  L08_SIG2 w0.091: v1(102.74,80.66) 104.42,82.34 105.64,82.34 106.08,82.78 106.08,84.54 108.41,86.87 108.41,89.87 110.94,92.4 112.14,92.4 117.02,97.28 117.02,115.46 122.62,121.06 139.59,121.06 142.24,123.71 146.05,123.71 150.46,128.12 150.46,129.78 J1.10
MCU_UART1_RTS_3V3: length 96.9
  TOP w0.147: v1(100.84,79.1) 98.66,79.1 U23.B9
  L08_SIG2 w0.091: J1.13 155.83,127.52 155.83,124.6 154.25,123.03 147.41,123.03 143.03,118.65 123.01,118.65 118.12,113.76 118.12,96.82 113.59,92.29 113.59,88.09 111.94,86.45 110.43,86.45 108.24,84.26 108.24,80.1 106.06,77.92 103.71,77.92 102.93,78.7 101.24,78.7 v1(100.84,79.1)
MCU_UART1_RX_3V3: length 91.8
  TOP w0.147: U23.C9 v1(97.86,79.1)
  L08_SIG2 w0.091: v1(97.86,79.1) 100.3,79.1 100.76,79.56 106.14,79.56 107.56,80.98 107.56,85.24 108.96,86.64 108.96,88.36 117.64,97.04 117.64,97.19 117.68,97.23 117.68,115.21 122.98,120.51 144.38,120.51 150.98,127.11 152.87,127.11 J1.11
MCU_UART1_TX_3V3: length 100.8
  TOP w0.147: U23.D9 v1(97.06,79.1)
  L08_SIG2 w0.091: v1(97.06,79.1) 97.31,79.1 97.73,78.69 98.67,78.69 98.88,78.48 102.86,78.48 103.72,77.62 106.28,77.62 108.58,79.91 108.58,83.9 110.8,86.12 112.78,86.12 118.56,91.91 118.56,113.58 123.19,118.2 143.11,118.2 147.42,122.52 155.02,122.52 159.51,127.01 J1.15
MIPI_TCK: length 31.2
  TOP w0.147: R194.1 v1(72.52,21.74) ; v1(97.18,14.08) 97.83,13.43 U60.2
  L03_SIG1 w0.091: v1(97.18,14.08) 95.86,14.08 91.73,18.21 76.55,18.21 73.01,21.74 v1(72.52,21.74)
MIPI_TDI_R: length 3.4
  BOTTOM w0.147: J33.5 63.72,48.56 63.63,48.65 63.63,49.39 63.37,49.64 R410.1
MIPI_TDO_R: length 4.4
  BOTTOM w0.147: J33.4 63.22,39.15 64.26,38.11 R450.2
MIPI_TMS_R: length 4.3
  BOTTOM w0.147: R451.2 62.95,37.21 62.48,37.68 62.48,38.82 62.72,39.06 J33.2
MIPI_TRC_CLK: length 39.5
  TOP w0.147: v1(57.12,59.78) 59.28,59.78 62.68,63.18 62.68,65.24 65.36,67.93 65.36,68.15 66.05,68.85 66.56,68.85 68.02,70.31 68.02,71.06 67.79,71.29 RA2.16
  BOTTOM w0.147: v1(57.12,59.78) 61.42,55.48 61.42,55.27 61.23,55.08 61.23,54.91 61.35,54.79 61.52,54.79 61.73,55.01 62.07,55.01 62.19,54.89 62.19,54.72 61.99,54.52 61.99,54.36 62.11,54.24 62.27,54.24 62.47,54.44 62.64,54.44 62.75,54.32 62.75,54.16 62.56,53.96 62.56,53.79 62.67,53.67 62.84,53.67 63.04,53.87 63.2,53.87 63.32,53.75 63.32,53.59 63.12,53.39 63.12,53.22 63.24,53.11 63.41,53.11 63.61,53.3 63.77,53.3 63.89,53.19 63.89,53.02 63.69,52.82 63.69,52.66 64.01,52.34 64.01,49.67 64.97,48.71 65.38,48.71 65.72,48.37 J33.13
MIPI_TRC_CTL: length 36.7
  TOP w0.147: v1(56.78,61.06) 59.79,61.06 62.38,63.65 62.38,65.37 63.75,66.74 63.75,67.31 65.74,69.3 65.99,69.3 67.06,70.36 67.06,70.63 67.16,70.74 67.16,73.12 RA2.15
  BOTTOM w0.147: J33.17 66.72,51.37 57.35,60.74 57.11,60.74 v1(56.78,61.06)
MIPI_TRC_DAT00: length 37
  TOP w0.147: v1(57.03,62.73) 60.32,62.73 62.09,64.5 62.09,65.49 63.12,66.52 63.12,68.07 65.09,70.05 65.72,70.05 66.04,70.36 66.04,71.13 66.7,71.79 RA2.14
  BOTTOM w0.147: J33.19 67.22,51.28 56.71,61.8 56.71,62.41 v1(57.03,62.73)
MIPI_TRC_DAT01: length 36.9
  TOP w0.147: RA2.13 66.2,72.04 64.39,70.23 63.37,70.23 62.99,69.85 62.99,68.79 62.37,68.16 62.22,68.16 62.1,68.04 62.1,67.88 62.22,67.76 62.37,67.76 62.48,67.64 62.48,67.48 62.37,67.36 62.22,67.36 62.1,67.24 62.1,67.07 62.22,66.96 62.37,66.96 62.48,66.84 62.48,66.3 61.79,65.61 61.79,64.84 60.14,63.19 58.37,63.19 v1(58.04,63.51)
  BOTTOM w0.147: J33.21 67.72,51.42 58.04,61.1 v1(58.04,63.51)
MIPI_TRC_DAT02: length 36.6
  TOP w0.147: v1(59.18,63.64) 60.18,63.64 61.5,64.96 61.5,65.73 61.81,66.04 61.81,67.41 61.69,67.53 61.23,67.53 61.11,67.65 61.11,67.81 61.23,67.93 61.69,67.93 61.81,68.05 61.81,68.21 61.69,68.33 61.23,68.33 61.11,68.45 61.11,68.62 61.23,68.73 62.34,68.73 62.48,68.88 62.48,70.46 62.63,70.61 64.03,70.61 65.7,72.29 RA2.12
  BOTTOM w0.147: v1(59.18,63.64) 59.18,60.38 68.02,51.54 68.02,48.35 68.22,48.15 J33.23
MIPI_TRC_DAT03: length 36.8
  TOP w0.147: v1(59.18,65.04) 60.33,65.04 60.82,65.52 60.82,65.95 60.82,65.95 60.82,70.82 61.12,71.12 62.01,71.12 62.14,71.25 62.14,71.5 62.27,71.63 62.45,71.63 62.58,71.5 62.58,71.25 62.71,71.12 62.89,71.12 63.02,71.25 63.02,71.5 63.15,71.63 63.33,71.63 63.46,71.5 63.46,71.25 63.59,71.12 64.01,71.12 64.64,71.75 64.64,72.32 65.2,72.88 RA2.11
  BOTTOM w0.147: J33.25 68.72,48.15 68.31,48.56 68.31,51.66 60.18,59.8 60.18,64.67 59.8,65.04 v1(59.18,65.04)
MIPI_TRC_DAT04: length 36.7
  TOP w0.147: RA2.10 64.7,72.88 64.23,72.4 61.99,72.4 60.53,70.94 60.53,70.62 60.41,70.51 59.91,70.51 59.79,70.39 59.79,70.22 59.91,70.1 60.41,70.1 60.53,69.99 60.53,69.82 60.41,69.7 59.91,69.7 59.79,69.59 59.79,69.42 59.91,69.3 60.41,69.3 60.53,69.18 60.53,66.08 60.38,65.93 v1(59.69,65.93)
  BOTTOM w0.147: J33.27 69.22,48.12 68.61,48.73 68.61,51.79 60.74,59.66 60.74,65.52 60.33,65.93 v1(59.69,65.93)
MIPI_TRC_DAT05: length 36.8
  TOP w0.147: v1(59.82,67.07) 59.5,67.39 59.5,71.56 61.34,73.41 63.37,73.41 63.62,73.15 RA2.9
  BOTTOM w0.147: J33.29 69.72,48.36 69.54,48.54 69.54,49.34 68.9,49.99 68.9,51.91 61.48,59.33 61.48,62.68 61.59,62.8 61.94,62.8 62.06,62.92 62.06,63.09 61.94,63.2 61.59,63.2 61.48,63.32 61.48,63.49 61.59,63.6 61.94,63.6 62.06,63.72 62.06,63.89 61.94,64.01 61.59,64.01 61.48,64.12 61.48,64.29 61.59,64.41 61.94,64.41 62.06,64.52 62.06,64.83 v1(59.82,67.07)
MIPI_TRC_DAT06: length 36.9
  TOP w0.147: RA4.16 75.15,57 75.44,56.72 75.44,55.26 74.8,54.62 74.04,54.62 72.28,52.87 63.59,52.87 62.48,53.98 62.48,58.05 v1(63.12,58.69)
  BOTTOM w0.147: J33.31 70.22,48.36 70.48,48.62 70.48,49.53 70.29,49.73 69.92,49.73 69.65,49.99 69.65,51.58 63.12,58.11 v1(63.12,58.69)
MIPI_TRC_DAT07: length 36.7
  TOP w0.147: v1(64.14,57.92) 63.67,57.92 63.43,57.68 63.43,57.41 63.55,57.29 64.01,57.29 64.13,57.17 64.13,57.01 64.01,56.89 63.55,56.89 63.43,56.77 63.43,56.61 63.55,56.49 64.01,56.49 64.13,56.37 64.13,56.2 64.01,56.09 63.55,56.09 63.43,55.97 63.43,55.8 63.55,55.69 64.01,55.69 64.13,55.57 64.13,55.4 64.01,55.28 63.55,55.28 63.43,55.17 63.43,54.09 64.36,53.16 72.16,53.16 73.07,54.07 73.07,54.24 72.89,54.41 72.89,54.58 73.01,54.7 73.18,54.7 73.35,54.52 73.52,54.52 74.48,55.48 74.48,55.83 74.57,55.92 RA4.15
  BOTTOM w0.147: J33.33 70.72,48.36 70.83,48.46 70.83,50.82 64.46,57.18 64.46,57.6 v1(64.14,57.92)
MIPI_TRC_DAT08: length 36.9
  TOP w0.147: v1(65.28,57.67) 65.32,57.72 65.32,58.25 65.09,58.48 64.86,58.48 64.59,58.21 64.59,57.73 64.44,57.58 64.44,57.08 64.55,56.97 65.67,56.97 65.79,56.85 65.79,56.68 65.67,56.57 64.55,56.57 64.44,56.45 64.44,56.28 64.55,56.16 65.67,56.16 65.79,56.05 65.79,55.88 65.67,55.76 64.55,55.76 64.44,55.65 64.44,55.27 64.16,54.99 64.02,54.99 63.85,54.82 63.85,54.09 64.35,53.59 70.98,53.59 72.57,55.19 73.09,55.19 73.35,55.45 73.35,55.97 74.07,56.68 RA4.14
  BOTTOM w0.147: v1(65.28,57.67) 65.28,56.78 71.12,50.94 71.12,48.53 71.22,48.43 J33.35
MIPI_TRC_DAT09: length 36.8
  TOP w0.147: v1(66.13,57.27) 66.13,56.82 66.29,56.66 66.29,55.8 65.96,55.47 64.93,55.47 64.73,55.27 64.73,55.14 64.2,54.61 64.2,54.26 64.35,54.11 65.13,54.11 65.25,54.23 65.25,54.94 65.37,55.05 65.53,55.05 65.67,54.92 65.67,54.23 65.79,54.11 65.95,54.11 66.07,54.23 66.07,55.02 66.19,55.13 66.36,55.13 66.47,55.02 66.47,54.23 66.59,54.11 66.76,54.11 66.88,54.23 66.88,54.76 66.99,54.88 67.16,54.88 67.28,54.76 67.28,54.23 67.39,54.11 67.56,54.11 67.68,54.23 67.68,54.76 67.8,54.88 67.96,54.88 68.08,54.76 68.08,54.23 68.2,54.11 68.36,54.11 68.48,54.23 68.48,54.76 68.6,54.88 68.76,54.88 68.88,54.76 68.88,54.23 69,54.11 69.36,54.11 69.48,54.23 69.48,54.49 69.6,54.6 69.76,54.6 69.88,54.49 69.88,54.23 70,54.11 70.78,54.11 70.93,54.26 70.93,55.08 71.2,55.35 71.83,55.35 72.58,56.1 72.84,56.1 73.57,56.82 RA4.13
  BOTTOM w0.147: v1(66.13,57.27) 66.13,56.34 71.43,51.05 71.43,48.86 71.72,48.56 J33.37
MIPI_TRC_DAT10: length 37
  TOP w0.147: RA4.12 73.07,57 71.7,55.64 71.08,55.64 70.61,55.17 67.32,55.17 67.17,55.32 67.17,55.54 67.04,55.67 66.8,55.67 66.67,55.8 66.67,55.98 66.8,56.11 67.04,56.11 67.17,56.24 67.17,56.42 67.04,56.55 66.8,56.55 66.67,56.68 66.67,56.87 66.8,57 67.04,57 67.17,57.13 67.17,57.27 66.94,57.51 66.58,57.51 v1(66.17,57.92)
  BOTTOM w0.147: v1(66.17,57.92) 65.65,58.44 65.65,59.57 65.85,59.77 67.55,59.77 67.69,59.63 67.69,59.29 67.58,59.18 66.87,59.18 66.75,59.06 66.75,58.89 66.87,58.77 67.58,58.77 67.69,58.66 67.69,58.49 67.58,58.37 66.87,58.37 66.75,58.25 66.75,58.09 66.87,57.97 67.58,57.97 67.69,57.85 67.69,57.69 67.58,57.57 66.87,57.57 66.75,57.45 66.75,57.29 66.87,57.17 67.58,57.17 67.69,57.05 67.69,56.88 67.58,56.77 66.87,56.77 66.75,56.65 66.75,56.48 66.87,56.37 67.58,56.37 67.69,56.25 67.69,55.2 72.34,50.55 72.34,48.6 72.22,48.49 J33.39
MIPI_TRC_DAT11: length 36.6
  TOP w0.147: v1(68.56,56.66) 68.63,56.59 69.02,56.59 69.13,56.7 69.13,57.4 69.03,57.51 67.67,57.51 67.51,57.35 67.51,55.65 67.7,55.47 68.29,55.47 68.41,55.59 68.41,56.08 68.53,56.2 68.69,56.2 68.81,56.08 68.81,55.59 68.93,55.47 69.09,55.47 69.21,55.59 69.21,56.08 69.33,56.2 69.5,56.2 69.61,56.08 69.61,55.59 69.73,55.47 70.24,55.47 70.49,55.72 70.74,55.72 70.95,55.93 71.57,55.93 72.57,56.93 RA4.11
  BOTTOM w0.147: J33.41 72.72,50.59 72.04,51.26 72.04,51.43 72.32,51.7 72.32,51.87 72.2,51.99 72.03,51.99 71.76,51.71 71.59,51.71 71.48,51.83 71.48,52 71.75,52.27 71.75,52.44 71.63,52.55 71.46,52.55 71.19,52.28 71.03,52.28 70.91,52.4 70.91,52.57 71.18,52.84 71.18,53 71.06,53.12 70.9,53.12 70.62,52.85 70.46,52.85 70.34,52.97 70.34,53.13 70.61,53.41 70.61,53.57 70.5,53.69 70.33,53.69 70.06,53.42 69.89,53.42 69.77,53.53 69.77,53.7 70.05,53.97 70.05,54.14 69.93,54.26 69.76,54.26 69.49,53.98 69.32,53.98 69.21,54.1 69.21,54.27 69.48,54.54 69.48,54.71 69.36,54.82 69.19,54.82 68.92,54.55 68.76,54.55 67.99,55.32 67.99,58.05 68.27,58.33 68.85,58.33 69.12,58.06 69.12,57.78 69.01,57.67 68.59,57.67 68.48,57.55 68.48,57.38 68.59,57.27 69.01,57.27 69.12,57.15 69.12,56.87 69.01,56.76 68.66,56.76 v1(68.56,56.66)
MIPI_TRC_DAT12: length 36.9
  TOP w0.147: v1(69.6,56.66) 70.12,56.13 70.45,56.13 70.73,56.41 70.73,56.83 70.3,57.25 70.3,57.99 70.04,58.25 69.04,58.25 68.92,58.37 68.92,58.6 68.81,58.71 68.64,58.71 68.52,58.6 68.52,58.37 68.41,58.25 68.24,58.25 68.12,58.37 68.12,58.6 68,58.71 67.84,58.71 67.72,58.6 67.72,58.37 67.6,58.25 66.92,58.25 66.29,58.88 66.29,59.8 66.41,59.92 66.86,59.92 66.98,59.8 66.98,58.88 67.1,58.76 67.26,58.76 67.38,58.88 67.38,59.8 67.5,59.92 68.04,59.92 68.16,60.04 68.16,60.21 68.04,60.32 66.41,60.32 66.29,60.44 66.29,60.71 66.42,60.84 68.39,60.84 68.52,60.71 68.52,59.33 68.84,59.01 69.98,59.01 70.7,58.28 70.7,57.29 71.15,56.85 71.91,56.85 72.07,57 RA4.10
  BOTTOM w0.147: v1(69.6,56.66) 69.6,55.01 73.22,51.38 J33.43
MIPI_TRC_DAT13: length 36.7
  TOP w0.147: RA4.9 71.48,57.57 71,58.05 71,58.8 70.49,59.3 68.96,59.3 68.81,59.45 68.81,60.86 68.51,61.16 66.32,61.16 65.99,60.83 65.99,60.2 65.88,60.08 64.8,60.08 64.69,59.96 64.69,59.8 64.8,59.68 65.88,59.68 65.99,59.56 65.99,59.39 65.88,59.28 64.8,59.28 64.69,59.16 64.69,58.99 64.8,58.88 65.88,58.88 66.95,57.8 v1(69.85,57.8)
  BOTTOM w0.147: v1(69.85,57.8) 70.17,57.48 70.17,57.17 70.29,57.05 70.81,57.05 70.93,56.93 70.93,56.76 70.81,56.65 70.29,56.65 70.17,56.53 70.17,56.36 70.29,56.25 70.81,56.25 70.93,56.13 70.93,55.96 70.81,55.84 70.29,55.84 70.17,55.73 70.17,54.85 70.41,54.61 70.57,54.61 70.71,54.75 70.88,54.75 71,54.64 71,54.47 70.86,54.33 70.86,54.16 70.97,54.05 71.14,54.05 71.28,54.19 71.45,54.19 71.56,54.07 71.56,53.9 71.42,53.76 71.42,53.6 71.54,53.48 71.71,53.48 71.85,53.62 72.01,53.62 72.13,53.5 72.13,53.34 71.99,53.19 71.99,53.03 74.35,50.67 74.35,49.12 73.72,48.49 J33.45
MIPI_TRC_DAT14: length 36.8
  BOTTOM w0.147: RA6.16 82.75,57.25 82.63,57.14 82.35,57.14 82.24,57.02 82.24,54.06 82.12,53.94 81.95,53.94 81.83,54.06 81.83,57.02 81.72,57.14 81.55,57.14 81.43,57.02 81.43,56.73 81.32,56.61 80.75,56.61 80.63,56.49 80.63,53.9 80.75,53.79 80.91,53.79 81.03,53.9 81.03,56.09 81.15,56.21 81.32,56.21 81.43,56.09 81.43,53.66 81.55,53.54 81.84,53.54 82.04,53.34 82.04,52.84 81.79,52.59 80.13,52.59 80.02,52.71 80.02,52.87 80.13,52.99 81.19,52.99 81.31,53.11 81.31,53.27 81.19,53.39 79.73,53.39 79.62,53.27 79.62,52.71 79.5,52.59 79.22,52.59 78.93,52.3 78.93,51.22 78.79,51.07 78.39,51.07 78.27,51.19 78.27,51.47 78.51,51.71 78.51,51.88 78.39,52 77.98,52 77.87,51.88 77.87,51.19 77.75,51.07 75.56,51.07 74.65,50.15 74.65,49 74.22,48.58 J33.47
MIPI_TRC_DAT15: length 36.8
  BOTTOM w0.147: RA6.15 83.33,55.91 83.22,55.8 82.65,55.8 82.53,55.68 82.53,52.23 82.65,52.11 82.81,52.11 82.93,52.23 82.93,55.28 83.05,55.4 83.22,55.4 83.33,55.28 83.33,51.97 82.06,50.69 79.75,50.69 79.63,50.81 79.63,50.97 79.75,51.09 81.66,51.09 81.78,51.21 81.78,51.37 81.66,51.49 79.75,51.49 79.63,51.61 79.63,51.77 79.75,51.89 81.66,51.89 81.78,52.01 81.78,52.18 81.66,52.29 79.35,52.29 79.23,52.18 79.23,50.81 79.11,50.69 75.89,50.69 74.94,49.74 74.94,48.88 74.72,48.66 J33.49
MIPI_TRC_DAT16: length 36.9
  BOTTOM w0.147: RA6.14 83.83,48.27 83.72,48.15 83.55,48.15 83.43,48.27 83.43,50.97 83.31,51.09 83.15,51.09 83.03,50.97 83.03,50.7 82.6,50.27 81.75,50.27 81.4,49.91 81.4,49.12 81.51,49.01 81.68,49.01 81.8,49.12 81.8,49.61 81.91,49.73 82.08,49.73 82.2,49.61 82.2,49.12 82.32,49.01 82.48,49.01 82.6,49.12 82.6,49.61 82.72,49.73 82.91,49.73 83.03,49.61 83.03,47.87 83.15,47.75 83.72,47.75 83.83,47.63 83.83,47.19 83.69,47.04 82.44,47.04 82.24,47.24 82.24,48.34 81.94,48.64 79.41,48.64 79.25,48.81 79.25,50.16 79.1,50.31 76.2,50.31 75.31,49.42 75.31,48.83 75.22,48.74 J33.51
MIPI_TRC_DAT17: length 36.9
  BOTTOM w0.147: J33.53 75.72,49.05 76.6,49.93 77.84,49.93 78.5,49.26 78.5,46.64 78.77,46.37 78.98,46.37 79.22,46.61 79.22,48.23 79.34,48.35 81.82,48.35 81.93,48.23 81.93,48.06 81.82,47.95 79.74,47.95 79.62,47.83 79.62,47.66 79.74,47.54 81.82,47.54 81.93,47.43 81.93,47.26 81.82,47.14 79.74,47.14 79.62,47.03 79.62,46.86 79.74,46.74 84.04,46.74 84.33,47.03 RA6.13
MIPI_TRC_DAT18: length 36.9
  BOTTOM w0.147: RA6.12 84.83,55.37 85.25,54.96 86.46,54.96 86.58,54.84 86.58,54.68 86.46,54.56 84.95,54.56 84.83,54.44 84.83,54.28 84.95,54.16 86.46,54.16 86.58,54.04 86.58,53.88 86.46,53.76 84.95,53.76 84.83,53.64 84.83,47.11 83.25,45.53 80.32,45.53 80.2,45.65 80.2,45.81 80.32,45.94 82.22,45.94 82.34,46.05 82.34,46.22 82.22,46.34 79.92,46.34 79.8,46.22 79.8,45.65 79.68,45.53 78.72,45.53 78.04,46.21 78.04,48.95 77.58,49.42 76.73,49.42 76.22,48.91 J33.55
MIPI_TRC_DAT19: length 36.8
  L03_SIG1 w0.091: v1(85.33,56.42) 85.33,55.61 83.13,53.41 71.43,53.41 66.67,48.66 66.67,39.01 v1(66.21,38.54)
  BOTTOM w0.147: v1(66.21,38.54) 66.72,39.06 J33.18 ; RA6.11 85.33,56.87 85.33,56.87 v1(85.33,56.42)
MIPI_TRC_DAT20: length 36.9
  L03_SIG1 w0.091: v1(67.39,38.6) 66.87,39.12 66.87,48.51 70.7,52.34 82.64,52.34 v1(85.83,55.53)
  BOTTOM w0.147: v1(85.83,55.53) 85.83,55.99 85.83,55.99 RA6.10 ; J33.20 67.22,39.26 67.07,39.11 67.07,38.92 v1(67.39,38.6)
MIPI_TRC_DAT21: length 36.8
  L03_SIG1 w0.091: v1(86.38,56.42) 87.12,55.68 87.12,55.21 83.3,51.39 70,51.39 67.09,48.47 67.09,40.02 v1(67.72,39.38)
  BOTTOM w0.147: RA6.9 86.42,56.91 86.38,56.87 v1(86.38,56.42) ; J33.22 v1(67.72,39.38)
MIPI_TRC_DAT22: length 37
  L08_SIG2 w0.091: v1(77.21,38.73) 76.65,38.17 76,38.17 73.91,40.26 70.57,40.26 69.22,38.9 v1(68.84,38.9)
  BOTTOM w0.147: v1(68.84,38.9) 68.22,39.52 J33.24 ; v1(77.21,38.73) 77.86,39.38 77.86,41.45 81.64,45.24 83.55,45.24 85.13,46.81 85.13,49.82 89.21,53.9 89.21,55.07 89.4,55.26 R392.2
MIPI_TRC_DAT23: length 37
  L08_SIG2 w0.091: v1(76.37,38.64) 74.5,40.51 69.93,40.51 v1(68.95,39.53)
  BOTTOM w0.147: R391.2 90.15,56.45 90.15,53.2 86.17,49.22 86.14,49.22 85.42,48.5 85.42,46.69 83.68,44.94 81.76,44.94 78.15,41.33 78.15,38.91 77.5,38.26 76.75,38.26 v1(76.37,38.64) ; v1(68.95,39.53) 68.72,39.76 J33.26
MIPI_TRST#_R: length 5.3
  BOTTOM w0.147: R448.2 66.76,37.21 66.21,37.76 65.88,37.76 64.22,39.42 J33.8
MMC0_CALPAD: length 22.4
  TOP w0.147: U23.F18 v1(95.46,71.1)
  L03_SIG1 w0.091: v1(95.46,71.1) 95.86,71.5 96.42,71.5 96.66,71.26 96.66,70.94 96.9,70.7 97.22,70.7 97.46,70.47 97.46,70.14 97.28,69.96 97.28,66.77 100.2,63.85 100.2,62.49 105.54,57.16 v1(105.54,55.77)
  BOTTOM w0.147: R405.1 v1(105.54,55.77)
MMC0_CLK: length 37.7
  TOP w0.147: v1(118.37,35.35) 118.12,35.1 U44.M6
  L03_SIG1 w0.091: v1(118.37,35.35) 118.82,34.9 120.1,34.9 121.17,35.96 121.17,45.5 117.35,49.31 117.35,49.43 117.48,49.56 117.48,49.67 117.4,49.75 117.29,49.75 117.16,49.62 117.04,49.62 116.96,49.7 116.96,49.81 117.1,49.95 117.1,50.06 117.02,50.14 116.9,50.14 116.77,50.01 116.66,50.01 116.58,50.09 116.58,50.2 116.71,50.33 116.71,50.45 116.63,50.53 116.51,50.53 116.38,50.4 116.27,50.4 116.19,50.48 116.19,50.59 116.32,50.72 116.32,50.84 116.24,50.92 116.13,50.92 115.99,50.78 115.88,50.78 115.8,50.86 115.8,50.98 115.93,51.11 115.93,51.22 115.85,51.3 115.74,51.3 115.61,51.17 115.49,51.17 115.28,51.38 106.24,51.38 v1(104.27,53.35)
  BOTTOM w0.147: R456.2 118.3,35.28 v1(118.37,35.35) ; R404.1 v1(104.27,53.35)
MMC0_DS: length 3
  TOP w0.147: v1(117.12,37.1) 117.37,36.85 U44.H5
  BOTTOM w0.147: R446.2 R444.2 v1(117.12,37.1)
MMC0_VCTRL_TP: length 5.5
  TOP w0.147: U23.F17 v1(95.46,71.9)
  BOTTOM w0.114: TP74.1 95.83,67.98 95.83,69.29 95.06,70.06 95.06,71.5 v1(95.46,71.9)
MMC1_CLK: length 98.5
  TOP w0.147: v1(40.1,25.38) 40.1,27.15 40.65,27.7 41.78,27.7 42.29,27.19 46.57,27.19 47.38,28 v1(47.38,29.22) U49.1
  BOTTOM w0.147: R389.1 93.21,56.41 93.19,56.4 93.19,54.18 88.66,49.65 88.66,41.31 82.55,35.2 78.81,35.2 78.69,35.31 78.69,35.59 78.57,35.7 78.41,35.7 78.29,35.59 78.29,35.31 78.17,35.2 78,35.2 77.89,35.31 77.89,35.59 77.77,35.7 77.6,35.7 77.49,35.59 77.49,35.31 77.37,35.2 77.2,35.2 77.08,35.31 77.08,35.59 76.97,35.7 76.8,35.7 76.68,35.59 76.68,35.31 76.57,35.2 76.4,35.2 76.28,35.31 76.28,35.59 76.16,35.7 76,35.7 75.88,35.59 75.88,35.31 75.76,35.2 75.17,35.2 75.05,35.08 75.05,34.5 74.94,34.39 74.77,34.39 74.65,34.5 74.65,35.08 74.53,35.2 74.37,35.2 74.25,35.08 74.25,34.5 74.13,34.39 73.97,34.39 73.85,34.5 73.85,35.08 73.73,35.2 73.57,35.2 73.45,35.08 73.45,34.5 73.33,34.39 73.16,34.39 73.05,34.5 73.05,35.08 72.93,35.2 72.76,35.2 72.65,35.08 72.65,34.5 72.53,34.39 72.36,34.39 72.24,34.5 72.24,35.08 72.13,35.2 71.96,35.2 71.84,35.08 71.84,34.5 71.73,34.39 71.56,34.39 71.44,34.5 71.44,35.08 71.32,35.2 70.97,35.2 70.16,34.39 69.99,34.39 69.99,34.39 62.68,34.39 61.93,35.15 61.93,37.21 57.74,41.4 50.9,41.4 47.37,37.87 47.37,30.87 47.38,30.85 v1(47.38,29.22) ; J37.5 v1(40.1,25.38)
MMC1_CLK_R: length 12.8
  TOP w0.147: v1(93.21,57.95) 93.21,63.64 92.72,64.12 92.72,65.32 91.67,66.37 91.67,68.26 91.46,68.47 91.46,69.5 U23.L20
MMC1_CMD: length 114.6
  TOP w0.147: U49.2 47.88,29.18 47.88,29.17 v1(47.88,28.72) 47.88,28.08 46.65,26.85 43.85,26.85 v1(43.18,26.18) ; U23.J19 v1(93.06,70.3)
  BOTTOM w0.147: v1(43.18,26.18) 43.07,26.07 R485.2 42.55,25.67 42.3,25.42 J37.3 ; v1(47.88,28.72) 49.49,28.72 49.91,29.13 49.91,36.88 52.96,39.93 57.27,39.93 60.75,36.46 60.75,34.38 63.21,31.92 67.05,31.92 67.17,31.8 67.17,31.42 67.28,31.3 67.45,31.3 67.57,31.42 67.57,31.8 67.68,31.92 67.85,31.92 67.97,31.8 67.97,31.42 68.09,31.3 68.25,31.3 68.37,31.42 68.37,31.8 68.49,31.92 68.65,31.92 68.77,31.8 68.77,31.42 68.89,31.3 69.05,31.3 69.17,31.42 69.17,31.8 69.29,31.92 69.46,31.92 69.57,31.8 69.57,31.42 69.69,31.3 69.86,31.3 69.97,31.42 69.97,31.8 70.09,31.92 70.26,31.92 70.38,31.8 70.38,31.42 70.49,31.3 70.66,31.3 70.78,31.42 70.78,31.8 70.89,31.92 71.06,31.92 71.18,31.8 71.18,31.42 71.3,31.3 71.46,31.3 71.58,31.42 71.58,31.8 71.7,31.92 71.86,31.92 71.98,31.8 71.98,31.42 72.1,31.3 72.27,31.3 72.38,31.42 72.38,31.8 72.5,31.92 72.67,31.92 72.78,31.8 72.78,31.42 72.9,31.3 73.07,31.3 73.19,31.42 73.19,31.8 73.3,31.92 73.47,31.92 73.59,31.8 73.59,31.42 73.7,31.3 73.87,31.3 73.99,31.42 73.99,31.8 74.11,31.92 74.27,31.92 74.39,31.8 74.39,31.42 74.51,31.3 74.67,31.3 74.79,31.42 74.79,31.8 74.91,31.92 80.94,31.92 89.83,40.82 89.83,41.31 89.83,47.56 91.06,48.78 92.07,48.78 92.32,48.78 97.15,53.62 97.15,62.92 96.31,63.76 96.31,66.46 94.58,68.18 94.58,68.99 93.59,69.98 93.41,69.98 93.39,70 93.39,70 93.21,70.17 93.19,70.17 v1(93.06,70.3)
MMC1_D0: length 114.9
  TOP w0.147: U23.K21 91.86,68.61 92.17,68.3 92.17,67.2 92.67,66.7 92.67,66.05 93.02,65.7 93.02,64.48 v1(93.34,64.15) ; v1(38.86,26.21) 38.86,26.94 40.08,28.15 42.35,28.15 42.36,28.16 44.13,28.16 44.13,28.15 45.07,28.15 45.11,28.19 45.32,28.19 46.1,28.97 46.1,31 47.12,32.02 47.69,32.02 v1(47.88,31.83) U49.8
  BOTTOM w0.147: v1(47.88,31.83) 47.88,32.52 47.88,32.53 47.88,37.96 50.94,41.02 57.7,41.02 61.21,37.51 61.21,37.24 61.63,36.83 61.63,34.97 62.51,34.09 75.38,34.09 75.5,34.21 75.5,34.79 75.62,34.9 75.79,34.9 75.9,34.79 75.9,34.21 76.02,34.09 76.19,34.09 76.3,34.21 76.3,34.79 76.42,34.9 76.59,34.9 76.71,34.79 76.71,34.21 76.82,34.09 76.99,34.09 77.11,34.21 77.11,34.79 77.22,34.9 77.39,34.9 77.51,34.79 77.51,34.21 77.63,34.09 77.79,34.09 77.91,34.21 77.91,34.79 78.03,34.9 78.19,34.9 78.31,34.79 78.31,34.21 78.43,34.09 78.59,34.09 78.71,34.21 78.71,34.79 78.83,34.9 79,34.9 79.11,34.79 79.11,34.21 79.23,34.09 79.4,34.09 79.51,34.21 79.51,34.79 79.63,34.9 79.8,34.9 79.92,34.79 79.92,34.21 80.03,34.09 80.2,34.09 80.32,34.21 80.32,34.79 80.43,34.9 80.6,34.9 80.72,34.79 80.72,34.21 80.84,34.09 81.86,34.09 88.95,41.19 88.95,48.02 90.77,49.84 90.77,50.66 96.27,56.16 96.27,62.55 94.67,64.15 v1(93.34,64.15) ; J37.7 37.9,25.31 38.1,25.51 R479.2 38.84,26.19 v1(38.86,26.21)
MMC1_D1: length 114.1
  TOP w0.147: U49.7 48.38,32.15 48.13,32.4 v1(46.86,32.4) 45.72,31.26 45.72,29.22 44.94,28.45 44.25,28.45 44.25,28.45 42.23,28.45 42.23,28.45 39.86,28.45 38.73,27.32 37.21,27.32 v1(36.07,26.18) ; U23.L21 91.06,68.47 91.35,68.18 91.35,66.27 92.43,65.2 92.43,64 92.71,63.72 92.71,56.15 v1(91.82,55.26)
  BOTTOM w0.147: J37.8 36.8,25.31 36.83,25.34 R480.2 36.09,26.19 v1(36.07,26.18) ; v1(46.86,32.4) 46.86,37.78 51.93,42.84 51.93,43.57 52.05,43.69 52.21,43.69 52.33,43.57 52.33,42.84 52.45,42.73 52.61,42.73 52.73,42.84 52.73,43.57 52.85,43.69 53.01,43.69 53.13,43.57 53.13,42.84 53.25,42.73 53.42,42.73 53.53,42.84 53.53,43.57 53.65,43.69 53.82,43.69 53.93,43.57 53.93,42.84 54.05,42.73 54.22,42.73 54.34,42.84 54.34,43.57 54.45,43.69 54.62,43.69 54.74,43.57 54.74,42.84 54.85,42.73 55.02,42.73 55.14,42.84 55.14,43.57 55.26,43.69 55.42,43.69 55.54,43.57 55.54,42.84 55.66,42.73 56.83,42.73 62.22,37.33 62.22,35.59 63.12,34.69 70.04,34.69 71.35,36 82.85,36 88.36,41.51 88.36,49.77 91.82,53.23 v1(91.82,55.26)
MMC1_D2: length 114.1
  TOP w0.147: v1(45.96,26.07) 46.41,26.07 46.56,26.22 47.41,26.22 50.04,28.84 50.04,31.46 49.48,32.02 v1(48.9,32.02) 48.88,32.01 U49.6 ; U23.K19 v1(92.26,70.3)
  BOTTOM w0.147: v1(48.9,32.02) 48.9,36.7 52.72,40.52 57.52,40.52 61.34,36.7 61.34,34.85 62.39,33.8 73.2,33.8 73.32,33.68 73.32,32.8 73.43,32.68 73.6,32.68 73.72,32.8 73.72,33.68 73.84,33.8 74,33.8 74.12,33.68 74.12,32.8 74.24,32.68 74.4,32.68 74.52,32.8 74.52,33.68 74.64,33.8 74.8,33.8 74.92,33.68 74.92,32.8 75.04,32.68 75.21,32.68 75.32,32.8 75.32,33.68 75.44,33.8 75.61,33.8 75.72,33.68 75.72,32.8 75.84,32.68 76.01,32.68 76.13,32.8 76.13,33.68 76.24,33.8 76.41,33.8 76.53,33.68 76.53,32.8 76.64,32.68 76.81,32.68 76.93,32.8 76.93,33.68 77.05,33.8 77.21,33.8 77.33,33.68 77.33,32.8 77.45,32.68 77.61,32.68 77.73,32.8 77.73,33.68 77.85,33.8 81.98,33.8 89.25,41.06 89.25,47.89 90.72,49.37 92.07,49.37 96.56,53.86 96.56,62.67 95.72,63.51 95.72,65.97 94.99,66.7 94.99,66.71 94.01,67.69 94.01,68.49 93.55,68.94 92.94,68.94 92.26,69.62 v1(92.26,70.3) ; v1(45.96,26.07) R483.2 45.29,25.59 45.11,25.41 44.6,25.41 44.5,25.31 J37.1
MMC1_D3: length 114.1
  TOP w0.147: U49.3 v1(48.38,29.22) 48.38,27.82 47.11,26.56 45.05,26.56 v1(44.56,26.07) ; U23.K18 v1(92.26,71.1)
  BOTTOM w0.114: v1(92.26,71.1) 92.66,70.7 92.66,70.12
  BOTTOM w0.147: v1(48.38,29.22) 48.38,30.04 49.53,31.19 49.53,36.92 52.84,40.23 57.39,40.23 61.04,36.58 61.04,34.56 62.82,32.78 65.1,32.78 65.36,33.03 67.44,33.03 68.23,32.24 68.81,32.24 68.92,32.36 68.92,33.29 69.04,33.4 69.21,33.4 69.32,33.29 69.32,32.36 69.44,32.24 69.61,32.24 69.73,32.36 69.73,33.29 69.84,33.4 70.01,33.4 70.13,33.29 70.13,32.36 70.24,32.24 70.41,32.24 70.53,32.36 70.53,33.29 70.65,33.4 70.81,33.4 70.93,33.29 70.93,32.36 71.05,32.24 71.21,32.24 71.33,32.36 71.33,33.29 71.45,33.4 71.61,33.4 71.73,33.29 71.73,32.36 71.85,32.24 72.02,32.24 72.13,32.36 72.13,33.29 72.25,33.4 72.42,33.4 72.53,33.29 72.53,32.36 72.65,32.24 80.84,32.24 89.54,40.94 89.54,47.77 90.85,49.08 92.19,49.08 96.86,53.74 96.86,62.79 96.01,63.64 96.01,66.09 94.29,67.81 94.29,68.86 93.46,69.7 93.03,69.7 92.66,70.07 92.66,70.12 ; J37.2 43.4,25 43.94,25.54 R484.2 v1(44.56,26.07)
MMC1_SD_EN: length 33.4
  L03_SIG1 w0.091: v1(53.99,28.86) 52.43,28.86 49.94,31.36 49.94,32.3 43.89,38.34 41.68,38.34 36.95,43.08 36.95,44.73 v1(36.2,45.48)
  BOTTOM w0.147: U91.7 v1(53.99,28.86) ; U86.1 32.47,45.5 32.49,45.48 R416.1 33.04,45.52 33.62,46.1 35.57,46.1 v1(36.2,45.48)
MMC1_SD_LS_EN: length 165.2
  TOP w0.254: v1(115.24,65.21) 115.24,64.41 115.42,64.23 U39.4
  L03_SIG1 w0.091: v1(28.96,42.56) 30,42.56 35.64,36.92 43.54,36.92 46.58,33.87 46.58,32.72 46.44,32.58 46.44,32.12 47.52,31.03 48.35,31.03 52.25,27.14 55.42,27.14 64.23,18.33 64.23,16.46 65.08,15.61 78.38,15.61 79.25,14.74 90.38,14.74 94.72,10.4 97.91,10.4 98.55,11.05 103.11,11.05 108.28,16.22 112.98,16.22 118.55,21.78 118.55,27.95 123.95,33.35 123.95,50.54 v1(123.44,51.04)
  L08_SIG2 w0.091: v1(123.44,51.04) 121.56,51.04 115.24,57.37 v1(115.24,65.21)
  BOTTOM w0.147: U86.4 28.9,43.36 29.66,42.6 R426.2 v1(28.96,42.56)
MMC1_SDCD: length 112.4
  TOP w0.147: U23.D19 v1(97.06,70.3)
  BOTTOM w0.147: v1(97.06,70.3) 97.06,68.39 97.39,68.06 97.39,66.79 96.9,66.3 96.9,64 97.74,63.16 97.74,53.1 94.6,49.97 94.6,49.79 91.11,46.29 91.11,41.68 80.44,31 63.71,31 60.45,34.26 60.45,36.34 57.15,39.64 53.1,39.64 50.29,36.83 50.29,29.1 49.28,28.08 46.23,28.08 45.97,28.34 35.05,28.34 34.42,27.7 34.42,26.47 34.69,26.19 R481.2 35.31,25.92 35.85,25.38 J37.9
OSC0: length 7.7
  TOP w0.147: U59.88 163.12,24.73 163.55,25.16 C177.2 163.78,25.17 164.14,25.54 166.91,25.54 167.02,25.43 Y2.1
OSC1: length 5.4
  TOP w0.147: U59.89 163.05,25.13 163.78,25.86 C172.2 164.65,25.87 Y2.3
OSPI0_CSN0: length 45.5
  TOP w0.147: U23.L19 v1(91.46,70.3)
  L03_SIG1 w0.091: v1(91.46,70.3) 91.46,66.87 91.78,66.55 91.78,65.54 91.98,65.35 92.1,65.35 92.58,64.86 92.58,63.01 93.11,62.48 95.25,62.48 95.74,62 95.74,61.98 101.77,55.95 101.77,50.64 106.1,46.31 106.1,42.89 105.84,42.63 103.43,42.63 v1(101.47,44.59)
  BOTTOM w0.147: v1(101.47,44.59) R422.2
OSPI0_LBCLK: length 23
  TOP w0.147: v1(94.11,52.32) 94.87,51.56 96.77,51.56 97.63,50.7 R600.2
  L03_SIG1 w0.091: v1(87.63,64.22) 88.01,63.84 88.01,62.61 88.65,61.98 88.65,60.07 89.66,59.05 92.2,59.05 92.71,58.55 92.71,57.66 94.11,56.26 v1(94.11,52.32)
  BOTTOM w0.147: v1(87.63,64.22) 87.52,64.33 R591.1
OSPI_CLK: length 45.1
  TOP w0.147: v1(89.84,65.8) 90.19,66.15 90.19,68.12 89.86,68.45 89.86,69.5 U23.N20 ; R167.1 R157.1 93.36,46.46 93.54,46.63 v1(95.11,46.63)
  L03_SIG1 w0.091: v1(89.84,65.8) 89.84,65.43 89.66,65.25 89.66,63.06 91.63,61.09 93.65,61.09 96.05,58.69 96.05,58.67 96.09,58.63 96.09,56.57 96.17,56.49 96.65,56.49 96.73,56.41 96.73,56.3 96.65,56.22 96.17,56.22 96.09,56.14 96.09,56.02 96.17,55.94 96.65,55.94 96.73,55.86 96.73,55.75 96.65,55.67 96.17,55.67 96.09,55.59 96.09,55.48 96.17,55.4 96.65,55.4 96.73,55.32 96.73,55.2 96.65,55.12 96.17,55.12 96.09,55.04 96.09,54.93 96.17,54.85 96.65,54.85 96.73,54.77 96.73,54.65 96.65,54.57 96.17,54.57 96.09,54.49 96.09,54.38 96.17,54.3 96.65,54.3 96.73,54.22 96.73,54.1 96.65,54.02 96.17,54.02 96.09,53.94 96.09,53.83 96.17,53.75 96.65,53.75 96.73,53.67 96.73,53.56 96.65,53.48 96.17,53.48 96.09,53.4 96.09,53.28 96.17,53.2 96.65,53.2 96.73,53.12 96.73,53.01 96.65,52.93 96.17,52.93 96.09,52.85 96.09,52.73 96.17,52.65 96.65,52.65 96.73,52.57 96.73,52.46 96.65,52.38 96.17,52.38 96.09,52.3 96.09,52.18 96.17,52.1 96.65,52.1 96.73,52.02 96.73,51.91 96.65,51.83 96.17,51.83 96.09,51.75 96.09,51.64 96.17,51.56 96.65,51.56 96.73,51.47 96.73,51.36 96.65,51.28 96.17,51.28 96.09,51.2 96.09,51.09 96.17,51.01 96.65,51.01 96.73,50.93 96.73,50.81 96.65,50.73 96.17,50.73 96.09,50.65 96.09,50.54 96.17,50.46 96.65,50.46 96.73,50.38 96.73,50.26 96.65,50.18 96.17,50.18 96.09,50.1 96.09,47.6 v1(95.11,46.63)
OSPI_CS: length 4.7
  TOP w0.147: R168.1 v1(95.05,44.59) 95.57,44.08 97.31,44.08 U40.C2
  BOTTOM w0.147: R422.1 v1(95.05,44.59)
OSPI_DQ0: length 5.4
  TOP w0.147: U40.D3 99.31,42.08 99.31,40.87 100.35,39.83 v1(100.35,39.38) R181.2
  BOTTOM w0.147: R181.2 v1(100.35,39.38)
OSPI_DQ1: length 4.9
  TOP w0.147: R176.2 v1(95.05,40.78) 96.35,42.08 97.31,42.08 U40.D2
  BOTTOM w0.147: R176.2 v1(95.05,40.78)
OSPI_DQ2: length 4.3
  TOP w0.147: R169.2 v1(102.3,44.46) 101.91,44.08 100.31,44.08 U40.C4
  BOTTOM w0.147: R169.2 v1(102.3,44.46)
OSPI_DQ3: length 4.1
  TOP w0.147: U40.D4 100.31,43.08 102.3,43.08 v1(102.3,43.07) R172.2
  BOTTOM w0.147: R172.2 v1(102.3,43.07)
OSPI_DQ4: length 3.3
  TOP w0.147: R173.2 v1(102.3,41.67) 101.71,41.67 U40.D5
  BOTTOM w0.147: R173.2 v1(102.3,41.67)
OSPI_DQ5: length 3.8
  TOP w0.147: R180.2 v1(99.08,39.32) 98.81,39.59 U40.E3
  BOTTOM w0.147: R180.2 v1(99.08,39.32)
OSPI_DQ6: length 3.7
  TOP w0.147: R179.2 v1(97.81,39.32) U40.E2
  BOTTOM w0.147: R179.2 v1(97.81,39.32)
OSPI_DQ7: length 3.8
  TOP w0.147: U40.E1 96.54,41.31 v1(96.54,39.32) R178.2
  BOTTOM w0.147: R178.2 v1(96.54,39.32)
OSPI_DQS: length 7.8
  TOP w0.147: U40.C3 98.31,44.08 98.31,47.14 98.48,47.31 R152.1 97.94,48.74 97.79,48.9 97.79,49.28 97.41,49.65 R154.1
OSPI_DQS_SOC: length 27.3
  TOP w0.147: v1(99.44,50.62) 99.44,49.91 99.25,49.72 R152.2 ; U23.N19 v1(89.06,70.3)
  L03_SIG1 w0.091: v1(99.44,50.62) 97.43,52.63 97.43,56.28 96.64,57.06 96.64,58.91 v1(95.4,60.15)
  BOTTOM w0.147: v1(89.06,70.3) 89.06,67.79 90.6,66.25 91.62,66.25 92.71,65.16 92.71,63.76 93.26,63.2 93.95,63.2 95.4,61.75 v1(95.4,60.15)
OSPI_INTN: length 36.6
  TOP w0.147: v1(100.33,48.36) 103.49,48.36 103.99,47.85 R156.1 R158.2 ; U23.L17 v1(91.46,71.9)
  L03_SIG1 w0.091: v1(91.46,71.9) 90.56,71 90.56,66.42 90.68,66.3 90.68,65.68 91.27,65.08 91.27,62.92 91.69,62.51 92.06,62.51 92.71,61.86 95.09,61.86 101.04,55.91 101.04,49.07 v1(100.33,48.36)
OSPI_RSTN: length 14.2
  TOP w0.147: U40.A4 99.81,48.77 100.2,49.16 107.31,49.16 v1(107.82,48.66)
  BOTTOM w0.147: U85.4 R414.1 v1(107.82,48.66)
PCIE_CLKREQN: length 3
  BOTTOM w0.147: J27.B12 22.78,28.47 23.39,27.86 R482.1
PCIE_MCU_PORZ: length 112.1
  TOP w0.147: U35.6 127.4,47.35 126.91,46.87 123.51,46.87 122.05,48.33 112.98,48.33 108.87,44.22 108.87,39.52 102.31,32.96 93.17,32.96 91.21,31 86.57,31 85.29,32.27 71.51,32.27 68.09,28.85 59.53,28.85 58.96,29.42 58.96,30.01 59.48,30.52 60.65,30.52 61.35,31.23 61.35,34.44 56.48,39.31 48.33,39.31 J34.3
  BOTTOM w0.147: R576.2 47.88,42.55 47.5,42.16 J34.3
PCIE_PRSNT1#: length 28.6
  TOP w0.147: J35.3 25.79,42.67 20.45,42.67 19.02,41.25 13.12,41.25 8.87,37 8.87,34.86 J27.A1
  BOTTOM w0.147: J35.3 29.35,39.11 R437.2
PCIE_PRSNT2#_1: length 10.9
  TOP w0.147: J35.2 24.84,39.91 25.77,38.98 25.77,35.36 26.79,34.34 26.79,32.44 J27.B17
PCIE_PRSNT2N: length 3.1
  BOTTOM w0.147: J35.1 21.12,41.09 20.9,41.31 R431.2
PCIE_RESET_OUTN: length 3.3
  BOTTOM w0.147: U88.4 41.11,40.02 41.24,40.15 J34.1
PCIE_RESETN: length 28.8
  BOTTOM w0.147: J34.2 41.91,37.1 21.21,37.1 19.78,35.67 J27.A11
PCIE_TCK: length 5.5
  BOTTOM w0.147: TP85.1 14.02,38.58 14.02,37.53 13.78,37.29 J27.A5
PCIE_TDI: length 5.9
  BOTTOM w0.147: J27.A6 14.78,39.85 TP83.1
PCIE_TDO: length 10.4
  BOTTOM w0.147: J27.A7 15.78,32.96 15.47,32.65 15.11,32.65 14.77,32.31 14.77,31.04 13.79,30.06 13.79,29.04 14.1,28.73 14.1,27.07 TP95.1
PCIE_TMS: length 3.7
  BOTTOM w0.147: J27.A8 16.78,38.23 TP84.1
PCIE_TRSTN: length 7.3
  BOTTOM w0.147: J27.B9 17.78,29.87 17.77,29.86 17.77,28.45 TP94.1
PCIE_WAKEN: length 5.1
  BOTTOM w0.147: J27.B11 19.78,30.47 20.21,30.03 R486.1
PORZ: length 28.2
  TOP w0.147: v1(128.65,53.12) 128.65,54.12 R574.2 127.81,54.24 127.4,53.82 U35.1 ; v1(143.76,41.67) 143.71,41.62 TP32.1 142.49,42 R171.2
  L03_SIG1 w0.091: v1(128.65,53.12) 129.41,52.36 129.41,49.16 130.68,47.89 138.37,47.89 142.88,43.39 142.88,42.56 v1(143.76,41.67)
PORZ_OUT: length 257.7
  TOP w0.147: TP82.1 109.96,40.55 v1(109.96,39.78) ; U31.2 29.69,59.96 29.08,59.36 v1(29.08,58.18) ; U19.2 v1(25.4,89.11) ; U23.E17 v1(96.26,71.9)
  L03_SIG1 w0.091: v1(109.96,39.78) 112.98,36.77 112.98,29.2 114.15,28.03 114.15,20.82 110.49,17.16 108.52,17.16 102.96,11.61 94.14,11.61 90.61,15.14 79.6,15.14 78.6,16.14 66.99,16.14 58.93,24.2 58.93,26.56 57.5,27.99 55.83,27.99 55.67,27.83 52.35,27.83 48.46,31.71 48.46,32.83 43.69,37.61 39.47,37.61 37.25,39.83 35.02,39.83 34.26,40.59 34.26,41.02 30.94,44.34 29.2,44.34 v1(27.94,45.61) 27.94,57.04 v1(29.08,58.18) 28.77,58.49 28.77,60.03 28.77,60.39 28.93,60.55 28.93,63.21 29.32,63.6 29.32,85.2 v1(25.4,89.11) ; v1(96.26,71.9) 96.44,71.72 96.68,71.72 96.89,71.51 101.27,71.51 102.01,70.77 v1(102.01,70.4) 102.62,71.01 103.81,71.01 104.29,70.53 104.29,66.33 106.9,63.72 106.9,57.15 107.19,56.86 v1(107.19,56.43)
  L08_SIG2 w0.091: v1(25.4,89.11) 26.23,89.11 35.81,98.69 35.81,103.01 38.1,105.3 44.58,105.3 45.85,106.57 v1(45.85,107.2) ; v1(107.19,56.43) 109.96,53.65 v1(109.96,39.78)
  BOTTOM w0.147: v1(102.01,70.4) 103.17,69.23 R348.2 ; R434.2 v1(109.96,39.78) ; U69.2 v1(45.85,107.2) ; v1(27.94,45.61) 28.05,45.5 U86.6
PRG0_HSE_ETH1_CLK: length 21.1
  TOP w0.147: J2.A17 v1(54.23,127.27)
  L08_SIG2 w0.091: v1(54.23,127.27) 54.23,124.33 56.24,122.33 58.65,122.33 62.08,118.9 62.08,113.65 v1(61.21,112.79)
  BOTTOM w0.147: R236.2 v1(61.21,112.79)
PRG0_HSE_ETH2_CLK: length 22.9
  TOP w0.147: J2.B17 v1(54.23,128.54)
  L08_SIG2 w0.091: v1(54.23,128.54) 54.84,127.93 54.84,124.82 56.79,122.86 60.48,122.86 62.48,120.85 v1(62.48,112.79)
  BOTTOM w0.147: R235.2 v1(62.48,112.79)
PRG0_MDIO0_MDC: length 51.7
  TOP w0.147: U23.P3 v1(88.26,83.9) ; v1(69.47,125.24) 68.83,125.87 J2.A5
  L03_SIG1 w0.091: v1(69.47,125.24) 69.03,124.8 69.03,116.13 83.05,102.1 83.05,93.47 84.23,92.29 84.23,89.14 88.26,85.11 v1(88.26,83.9)
PRG0_MDIO0_MDIO: length 52.6
  TOP w0.147: J2.A4 70.1,125.66 70.28,125.48 70.28,121.25 71.37,120.16 R19.1 72.73,120.12 70.52,117.91 70.52,115.34 77.86,108 77.86,106.06 80.76,103.17 80.76,95.39 84.2,91.94 84.2,91.07 88.17,87.1 88.17,85.36 88.26,85.27 88.26,84.7 U23.P2
PRG0_PRU0_GPO9/CPSW_RGMII1_RX_C: length 41
  TOP w0.147: U23.W6 v1(84.26,81.5)
  L08_SIG2 w0.091: v1(56.16,97.03) 56.43,97.29 69.82,97.29 71.04,96.07 71.04,90.52 71.04,90.22 74.84,86.42 75.16,86.1 77.12,86.1 78.15,85.07 78.19,85.07 81.76,81.5 v1(84.26,81.5)
  BOTTOM w0.147: v1(56.16,97.03) 55.66,97.53 U75.6
PRG0_PRU0_GPO10/CPSW_RGMII1_RXC: length 39
  TOP w0.147: v1(76.71,85.6) 77.97,85.6 81.02,82.55 81.03,82.55 81.11,82.47 81.29,82.47 81.85,81.9 U23.AA5
  L08_SIG2 w0.091: v1(54.97,97.03) 55.61,96.39 56.77,96.39 57.24,96.87 69.4,96.87 69.7,96.87 70.6,95.97 70.6,90.19 70.68,90.12 70.68,90.07 74.47,86.27 75.15,85.6 v1(76.71,85.6)
  BOTTOM w0.147: U75.7 v1(54.97,97.03)
PRG0_PRU0GPO0: length 53.1
  TOP w0.147: J2.B12 60.58,127.27 60.58,126.02 60.91,125.69 61.34,125.69 65.42,121.62 65.42,116.28 72.11,109.59 72.11,107.65 77,102.75 77,94.75 79.29,92.47 79.29,89.93 83.35,85.87 83.58,85.87 83.86,85.58 U23.Y1
PRG0_PRU0GPO1: length 59.7
  TOP w0.147: U23.R4 v1(87.46,83.1) ; J2.E8 v1(65.66,132.35)
  L03_SIG1 w0.091: v1(65.66,132.35) 66.27,131.74 66.27,122.3 68.4,120.18 68.4,115.98 81.41,102.97 81.5,102.88 81.5,94.08 83.57,92.02 83.57,88.6 86.74,85.43 86.74,84.47 87.06,84.15 87.06,83.51 v1(87.46,83.1)
PRG0_PRU0GPO2: length 51.6
  TOP w0.147: J2.A8 65.02,124.1 66.89,122.23 66.89,116.89 76.39,107.39 76.39,105.45 79.28,102.56 79.28,94.55 80.76,93.08 80.76,90.54 83.31,87.99 83.56,87.99 84.21,87.99 85.86,86.33 85.86,84.7 U23.U2
PRG0_PRU0GPO3: length 51.8
  TOP w0.147: J2.A9 63.75,124.53 66.3,121.99 66.3,116.65 75.8,107.15 75.8,105.21 78.69,102.31 78.69,94.31 80.17,92.83 80.17,90.29 83.11,87.35 83.95,87.35 85.06,86.24 85.06,84.7 U23.V2
PRG0_PRU0GPO4: length 57.1
  TOP w0.147: U23.AA2 82.74,84.3 79.11,87.93 73.33,87.93 70.51,90.76 70.51,96.48 70.19,96.8 70.19,107.88 68.03,110.04 68.03,112.13 64.53,115.62 64.53,121.26 60.98,124.81 59.15,124.81 58.67,125.29 J2.A13
PRG0_PRU0GPO5: length 55.7
  TOP w0.147: J2.C6 v1(68.2,129.81) ; U23.R3 v1(87.46,83.9)
  L03_SIG1 w0.091: v1(87.46,83.9) 87.46,84.14 87,84.61 87,85.49 83.79,88.69 83.79,92.11 82.61,93.29 82.61,102.03 68.63,116.01 68.63,120.26 67.77,121.12 67.77,129.38 v1(68.2,129.81)
PRG0_PRU0GPO6: length 62.9
  TOP w0.147: U23.T3 v1(86.66,83.9) ; J2.D8 v1(65.66,131.08)
  L08_SIG2 w0.091: v1(86.66,83.9) 86.66,84.57 85.02,86.21 81.85,86.21 79,89.05 75.67,89.05 74.68,90.04 74.68,90.86 75.36,91.54 75.36,92.46 74.68,93.14 74.68,96.98 70.23,101.42 70.23,104.6 64.67,110.16 64.67,127.89 64.67,127.89 64.67,128.14 66.09,129.56 66.09,130.65 v1(65.66,131.08)
PRG0_PRU0GPO7: length 51.4
  TOP w0.147: J2.B7 66.88,127.32 66.88,123.5 67.77,122.6 67.77,117.26 77.27,107.76 77.27,105.82 80.17,102.92 80.17,95.14 83.61,91.7 83.61,90.83 87.06,87.38 U23.T1
PRG0_PRU0GPO8: length 50.9
  TOP w0.147: U23.T2 86.66,84.7 86.66,87.37 83.32,90.71 83.32,91.58 79.87,95.02 79.87,102.8 76.98,105.69 76.98,107.64 67.48,117.14 67.48,122.48 66.29,123.66 J2.A7
PRG0_PRU0GPO11: length 60.6
  TOP w0.147: U23.Y3 83.62,83.5 83.22,83.9 82.74,83.9 81.43,85.22 81.23,85.22 78.81,87.64 73.21,87.64 70.22,90.63 70.22,96.36 70.05,96.52 70.04,96.52 69.9,96.67 69.9,107.7 67.73,109.87 67.73,111.96 64.24,115.46 64.24,121.13 60.85,124.52 58.48,124.52 57.99,125.01 57.99,127.32 J2.B14
PRG0_PRU0GPO12: length 60.4
  TOP w0.147: U23.AA3 82.73,83.5 81.4,84.84 81.14,84.84 78.63,87.35 73,87.35 67.96,92.38 67.96,96.36 69.6,98 69.6,107.58 67.44,109.74 67.44,111.84 63.94,115.34 63.94,121.01 60.73,124.22 58.01,124.22 57.4,124.83 J2.A14
PRG0_PRU0GPO13: length 59.1
  TOP w0.147: U23.R6 v1(87.46,81.5) ; J2.C5 v1(69.47,129.81)
  L03_SIG1 w0.091: v1(69.47,129.81) 69.91,129.37 69.91,124.75 69.22,124.06 69.22,116.2 83.27,102.14 83.27,93.61 84.45,92.43 84.45,89.25 88.66,85.05 88.66,82.14 88.42,81.91 87.86,81.91 v1(87.46,81.5)
PRG0_PRU0GPO14: length 56.7
  TOP w0.147: U23.V4 v1(85.06,83.1) ; J2.C9 v1(64.39,129.81)
  L03_SIG1 w0.091: v1(85.06,83.1) 85.06,83.18 84.66,83.58 84.66,85.21 80.48,89.4 80.48,102.61 66.93,116.16 66.93,120.26 64.39,122.8 v1(64.39,129.81)
PRG0_PRU0GPO15: length 66.2
  TOP w0.147: U23.T5 v1(86.66,82.3) ; J2.D12 v1(60.58,131.08)
  L03_SIG1 w0.091: v1(86.66,82.3) 86.26,81.9 86.26,80.54 86.02,80.31 84.09,80.31 83.86,80.54 83.86,80.87 83.25,81.47 83.25,84.02 79.37,87.9 79.37,102.43 65.81,115.99 65.81,119.98 61.11,124.68 61.11,130.55 v1(60.58,131.08)
PRG0_PRU0GPO16: length 63.6
  TOP w0.147: U23.U4 v1(85.86,83.1) ; J2.E9 v1(64.39,132.35)
  L08_SIG2 w0.091: v1(85.86,83.1) 85.86,83.33 85.47,83.72 85.47,84.15 85.27,84.35 81.92,84.35 78.18,88.09 75.6,88.09 73.94,89.74 73.94,96.67 69.5,101.12 69.5,104.06 63.75,109.8 J2.E9 v1(64.39,132.35)
PRG0_PRU0GPO17: length 52.1
  TOP w0.147: J2.B8 65.61,127.32 65.61,123.93 67.18,122.35 67.18,117.02 76.68,107.52 76.68,105.57 79.58,102.68 79.58,94.68 81.06,93.2 81.06,90.66 83.43,88.28 84.33,88.28 86.26,86.35 U23.U1
PRG0_PRU0GPO18: length 52.3
  TOP w0.147: J2.B9 64.34,127.32 64.34,124.37 66.59,122.11 66.59,116.77 76.09,107.27 76.09,105.33 78.99,102.43 78.99,94.43 80.47,92.95 80.47,90.41 83.24,87.64 84.07,87.64 85.46,86.26 U23.V1
PRG0_PRU0GPO19: length 53
  TOP w0.147: J2.B11 61.85,127.27 61.85,126.45 61.93,126.37 61.93,125.94 66,121.87 66,116.53 75.5,107.03 75.5,105.08 78.4,102.19 78.4,94.19 79.88,92.71 79.88,90.17 83.04,87.01 83.82,87.01 84.66,86.17 U23.W1
PRG0_PRU1_GPO7/CPSW_RGMII1_RD0: length 42.1
  TOP w0.147: U23.W5 v1(84.26,82.3)
  L08_SIG2 w0.091: v1(84.26,82.3) 81.54,82.3 77.38,86.47 75.31,86.47 75.2,86.58 71.41,90.37 71.41,96.22 69.79,97.84 57.78,97.84 57.66,97.96 57.66,98.11 57.55,98.22 57.42,98.22 57.25,98.04 57.12,98.04 57,98.16 57,98.29 57.18,98.46 57.18,98.59 57.06,98.71 56.93,98.71 56.76,98.53 56.63,98.53 56.47,98.69 56.47,98.72 v1(56.16,99.03)
  BOTTOM w0.147: v1(56.16,99.03) 55.84,99.35 55.35,99.35 55.17,99.53 U75.2
PRG0_PRU1_GPO9/CPSW_RGMII1_RD1: length 42.6
  TOP w0.147: U23.Y5 83.46,82.3 81.87,82.3 81.2,82.97 81.19,82.97 77.7,86.46 72.63,86.46 67.73,91.37 65.39,91.37 65.27,91.25 65.27,91.04 65.16,90.92 64.99,90.92 64.87,91.04 64.87,91.25 64.75,91.37 64.59,91.37 64.47,91.25 64.47,91.04 64.35,90.92 64.19,90.92 64.07,91.04 64.07,91.25 63.95,91.37 63.78,91.37 63.67,91.25 63.67,91.04 63.55,90.92 63.38,90.92 63.27,91.04 63.27,91.25 63.15,91.37 62.98,91.37 62.86,91.25 62.86,91.04 62.75,90.92 62.58,90.92 62.46,91.04 62.46,91.25 62.35,91.37 62.18,91.37 62.06,91.25 62.06,91.04 61.94,90.92 61.78,90.92 61.66,91.04 61.66,91.25 61.54,91.37 61.38,91.37 61.26,91.25 61.26,91.04 61.14,90.92 60.98,90.92 60.86,91.04 60.86,91.25 60.74,91.37 59.18,91.37 55.58,94.97 55.58,98.42 v1(54.97,99.03)
  BOTTOM w0.147: U75.3 v1(54.97,99.03)
PRG0_PRU1_GPO10/CPSW_RGMII1_RD2: length 42.2
  TOP w0.147: U23.V6 v1(85.06,81.5)
  L08_SIG2 w0.091: v1(85.06,81.5) 84.66,81.9 81.65,81.9 77.27,86.29 75.24,86.29 75.02,86.5 71.22,90.3 71.22,90.45 71.22,96.14 69.83,97.54 56.34,97.54 56.16,97.71 v1(56.16,98.08)
  BOTTOM w0.147: U75.4 55.72,98.53 v1(56.16,98.08)
PRG0_PRU1_GPO17/CPSW_RGMII1_RD3: length 42.9
  TOP w0.147: U23.V5 v1(85.06,82.3)
  L08_SIG2 w0.091: v1(85.06,82.3) 84.91,82.45 84.68,82.45 84.43,82.7 81.43,82.7 77.48,86.65 75.39,86.65 71.59,90.45 71.59,96.29 69.86,98.02 58.08,98.02 56.55,99.55 56.03,99.55 55.62,99.14 55.62,98.67 v1(54.97,98.03)
  BOTTOM w0.147: U75.5 v1(54.97,98.03)
PRG0_PRU1_GPO18/CPSW_RGMII1_MDI: length 62.6
  TOP w0.147: U23.P5 v1(88.26,82.3)
  BOTTOM w0.114: v1(88.26,82.3) 88.66,82.7 88.66,84.46 88.14,84.98
  BOTTOM w0.147: U78.4 44.93,74.43 42.29,77.07 42.29,83.96 43.18,84.85 43.81,84.85 44.14,85.18 45.33,85.18 45.87,85.71 v1(70.71,85.71) 71.23,86.23 86.88,86.23 88.14,84.98
PRG0_PRU1_GPO19/CPSW_RGMII1_MDC: length 57.7
  TOP w0.147: U23.R2 v1(87.46,84.7)
  BOTTOM w0.147: U78.6 49.04,74.93 TP64.1 46.35,77.61 45.21,77.61 43.05,79.77 43.05,81.29 44.45,82.69 68.33,82.69 70.97,85.33 73.42,85.33 74.05,84.7 v1(87.46,84.7)
PRG0_PRU1GPO0: length 52.7
  TOP w0.147: J2.A12 59.94,125.82 60.37,125.4 61.22,125.4 65.12,121.5 65.12,116.16 71.82,109.47 71.82,107.52 76.71,102.63 76.71,94.63 78.99,92.34 78.99,89.8 83.46,85.34 83.46,84.88 83.86,84.48 U23.Y2
PRG0_PRU1GPO1: length 52.4
  TOP w0.147: J2.A11 61.63,126.21 61.63,125.82 65.71,121.74 65.71,116.41 72.41,109.71 72.41,107.77 78.11,102.07 78.11,94.07 79.58,92.59 79.58,90.05 82.91,86.72 83.54,86.72 84.26,86.01 84.26,84.7 U23.W2
PRG0_PRU1GPO2: length 57.2
  TOP w0.147: U23.V3 v1(85.06,83.9) ; J2.D9 v1(64.39,131.08)
  L03_SIG1 w0.091: v1(85.06,83.9) 85.06,85.26 80.7,89.63 80.7,102.65 67.51,115.83 67.51,119.93 64.82,122.63 64.82,130.65 v1(64.39,131.08)
PRG0_PRU1GPO3: length 56.9
  TOP w0.147: J2.C8 v1(65.66,129.81) ; U23.T4 v1(86.66,83.1)
  L03_SIG1 w0.091: v1(86.66,83.1) 86.26,83.51 86.26,84.69 81.14,89.81 81.14,102.73 67.96,115.91 67.96,120.1 65.66,122.4 v1(65.66,129.81)
PRG0_PRU1GPO4: length 60
  TOP w0.147: J2.B13 59.26,127.32 59.26,125.47 59.62,125.1 61.1,125.1 64.83,121.38 64.83,115.74 70.48,110.08 70.48,96.92 70.81,96.6 70.81,90.88 73.45,88.23 79.31,88.23 82.83,84.7 83.22,84.7 83.46,84.47 83.46,84.14 83.69,83.9 84.26,83.9 U23.W3
PRG0_PRU1GPO5: length 57.7
  TOP w0.147: U23.P4 v1(88.26,83.1) ; J2.D6 v1(68.2,131.08)
  L03_SIG1 w0.091: v1(88.26,83.1) 87.86,83.5 87.86,85 84.01,88.85 84.01,92.2 82.83,93.38 82.83,102.07 68.81,116.09 68.81,120.33 68.63,120.52 68.63,130.65 v1(68.2,131.08)
PRG0_PRU1GPO6: length 69
  TOP w0.147: U23.R5 v1(87.46,82.3) ; J2.E11 v1(61.85,132.35)
  L08_SIG2 w0.091: v1(87.46,82.3) 87.06,82.7 86.51,82.7 86.26,82.96 86.26,84.3 85.75,84.81 82.27,84.81 78.39,88.69 75.52,88.69 74.31,89.89 74.31,96.83 69.87,101.27 69.87,104.33 64.29,109.91 64.29,128.78 64.87,129.36 64.87,132.54 64.52,132.89 62.39,132.89 v1(61.85,132.35)
PRG0_PRU1GPO8: length 51
  TOP w0.147: J2.B4 69.51,127.31 69.51,125.84 69.92,125.43 69.92,121.27 69.51,120.86 69.51,115.94 77.57,107.88 77.57,105.94 80.46,103.04 80.46,95.27 83.91,91.82 83.91,90.95 87.64,87.22 87.65,87.22 87.86,87.01 U23.R1
