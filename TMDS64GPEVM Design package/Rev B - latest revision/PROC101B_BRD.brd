# Allegro board PROC101B_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HSE_DETECT: length 55.8
  TOP w0.147: J2.E4 v1(70.74,132.35)
  L03_SIG1 w0.091: v1(115.13,118.81) 94,118.81 88.64,124.16 85.67,124.16 83.22,126.61 79.74,126.61 77.06,129.28 77.06,129.94 75.48,131.52 71.57,131.52 v1(70.74,132.35)
  BOTTOM w0.147: U66.4 112.08,118.88 112.26,118.7 R224.1 115.02,118.7 v1(115.13,118.81)
HSE_GPIO0_31: length 93.8
  TOP w0.147: J2.B22 v1(47.88,128.54)
  L03_SIG1 w0.091: v1(47.88,128.54) 47.88,124.87 52.08,120.67 52.08,114.84 54.54,112.38 54.54,76.37 65.07,65.84 65.43,65.84 67.68,63.59 67.68,63.11 69.34,61.45 79.38,61.45 81.15,63.22 82.11,63.22 v1(83.27,64.38)
  BOTTOM w0.147: RA5.9 82.74,63.86 v1(83.27,64.38)
HSE_GPIO0_32: length 94.5
  TOP w0.147: J2.C22 v1(47.88,129.81)
  L03_SIG1 w0.091: v1(47.88,129.81) 47.4,129.33 47.4,125.09 51.87,120.62 51.87,114.74 54.32,112.29 54.32,76.7 54.36,76.66 54.36,76.3 65,65.65 65.36,65.65 67.5,63.51 67.5,62.94 69.21,61.23 79.47,61.23 81.24,63 82.82,63 v1(83.33,63.51)
  BOTTOM w0.147: RA5.10 v1(83.33,63.51)
HSE_GPIO0_33: length 100.4
  TOP w0.147: J2.D22 v1(47.88,131.08)
  L03_SIG1 w0.091: v1(47.88,131.08) 47.22,130.42 47.22,125.02 51.69,120.55 51.69,114.61 54.1,112.2 54.1,76.3 66.6,63.79 66.6,62.19 68.59,60.21 78.76,60.21 81.34,62.78 83.49,62.78 83.9,63.19 83.9,63.92 v1(84.36,64.38)
  BOTTOM w0.147: RA5.11 83.83,63.86 v1(84.36,64.38)
HSE_GPIO0_34: length 98.6
  TOP w0.147: J2.C23 v1(46.61,129.81)
  L03_SIG1 w0.091: v1(46.61,129.81) 47.04,129.38 47.04,124.94 47.13,124.85 51.51,120.47 51.51,114.53 52.83,113.21 52.83,103.52 53.88,102.48 53.88,76.26 65.53,64.6 65.53,61.63 67.17,59.99 78.85,59.99 81.43,62.56 83.81,62.56 84.33,63.08 v1(84.33,63.51)
  BOTTOM w0.147: v1(84.33,63.51) RA5.12
HSE_GPIO0_35: length 102
  TOP w0.147: J2.B24 v1(45.34,128.54)
  L03_SIG1 w0.091: v1(85.36,64.38) 84.9,63.92 84.9,62.45 84.79,62.34 81.52,62.34 78.95,59.77 66.61,59.77 64.39,61.99 64.39,65.49 53.65,76.22 53.65,101.17 52.76,102.06 52.02,102.06 51.76,102.33 51.76,113.11 49.66,115.21 49.66,120.87 45.77,124.75 45.77,128.11 v1(45.34,128.54)
  BOTTOM w0.147: v1(85.36,64.38) 84.83,63.86 RA5.13
HSE_GPIO0_36: length 13.3
  TOP w0.147: U8.19 59.03,121.24 58.12,122.16 52.91,122.16 49.78,125.28 J2.A20
HSE_GPIO0_36/FSI_TX0_CLK: length 91
  TOP w0.147: v1(51.23,112.81) 51.55,112.49 55.45,112.49 57.53,114.57 57.53,114.73 57.55,114.75 57.55,115.2 57.54,115.22 U8.9
  L03_SIG1 w0.091: v1(51.23,112.81) 51.23,102.46 52.26,101.42 52.26,101.17 53.43,100 53.43,76.18 63.04,66.58 63.04,61.42 64.91,59.54 80.83,59.54 83.27,61.99 84.96,61.99 85.33,62.36 v1(85.33,63.51)
  BOTTOM w0.147: RA5.14 v1(85.33,63.51)
HSE_GPIO0_37: length 106.1
  TOP w0.147: J2.C24 v1(45.34,129.81)
  L03_SIG1 w0.091: v1(86.36,64.38) 85.98,64.01 85.98,62.28 85.41,61.7 83.3,61.7 80.92,59.32 64.82,59.32 62.85,61.29 62.85,66.5 53.21,76.15 53.21,99.64 51.01,101.85 51.01,112.18 49.4,113.78 49.4,120.77 44.91,125.26 44.91,129.38 v1(45.34,129.81)
  BOTTOM w0.147: v1(86.36,64.38) 85.83,63.86 RA5.15
HSE_GPIO0_38: length 110.2
  TOP w0.147: J2.E26 v1(42.8,132.35)
  L03_SIG1 w0.091: v1(42.8,132.35) 43.41,131.74 43.41,124.58 47.06,120.93 47.06,116.78 48.51,115.33 48.51,114.36 50.79,112.09 50.79,101.76 50.95,101.59 52.99,99.55 52.99,76.11 62.67,66.43 62.67,61.16 64.76,59.07 86.23,59.07 86.92,59.76 86.92,62 86.42,62.5 v1(86.42,63.51)
  BOTTOM w0.147: RA5.16 v1(86.42,63.51)
HSE_GPIO0_39: length 106.5
  TOP w0.147: J2.C26 v1(42.8,129.81)
  L03_SIG1 w0.091: v1(42.8,129.81) 42.34,129.35 42.34,123.64 42.9,123.08 44.32,123.08 46.61,120.8 46.61,115.58 50.34,111.85 50.34,101.09 51.77,99.67 51.77,87.91 52.48,87.19 52.48,76.01 62.23,66.27 62.23,60.98 64.58,58.63 86.45,58.63 v1(88.11,56.97)
HSE_GPIO0_41: length 110.2
  TOP w0.147: J2.D26 v1(42.8,131.08)
  L03_SIG1 w0.091: v1(42.8,131.08) 43.23,130.65 43.23,124.51 46.84,120.89 46.84,115.66 50.56,111.94 50.56,101.18 51.99,99.76 51.99,88.15 52.67,87.46 52.67,76.14 62.45,66.35 62.45,61.07 64.67,58.85 86.54,58.85 87.84,57.55 91.35,57.55 v1(91.94,56.97)
HSE_MCAN0_RX/UART4_TXD: length 17.3
  TOP w0.147: J2.E24 v1(45.34,132.35)
  L03_SIG1 w0.091: v1(45.34,132.35) 44.5,131.51 44.5,123.85 47.74,120.6 v1(47.74,118.91)
  BOTTOM w0.147: v1(47.74,118.91) 47.83,119 U67.3
HSE_MCAN0_TX/UART4_RXD: length 18.1
  TOP w0.147: J2.D24 v1(45.34,131.08)
  L03_SIG1 w0.091: v1(47.74,117.01) 48.17,117.44 48.17,120.55 44.68,124.04 44.68,130.42 v1(45.34,131.08)
  BOTTOM w0.147: U67.6 47.78,117.05 v1(47.74,117.01)
HSE_MCAN1_RX/I2C3_SDA: length 17
  TOP w0.147: J2.C29 v1(38.99,129.81)
  L03_SIG1 w0.091: v1(38.99,129.81) 38.53,129.35 38.53,121.33 41.66,118.2 v1(41.66,116.6)
  BOTTOM w0.147: v1(41.66,116.6) 41.86,116.4 U67.10
HSE_MCAN1_TX/I2C3_SCL: length 18.3
  TOP w0.147: J2.D29 v1(38.99,131.08)
  L03_SIG1 w0.091: v1(38.99,131.08) 38.18,130.27 38.18,121.1 40.5,118.77 v1(40.5,117.7)
  BOTTOM w0.147: v1(40.5,117.7) 41.15,118.35 U67.13
HSE_PRG0_PRU0_GPO9: length 42.3
  TOP w0.147: J2.D28 v1(40.26,131.08)
  L03_SIG1 w0.091: v1(49.02,98.06) 48.95,97.99 47.28,97.99 46.74,98.53 46.74,113.9 45.34,115.29 45.34,120.33 44.49,121.18 44.48,121.17 42.17,121.17 41.13,122.21 41.13,124.69 39.83,125.98 39.83,130.65 v1(40.26,131.08)
  BOTTOM w0.147: U75.33 49.92,97.53 49.39,98.06 v1(49.02,98.06)
HSE_PRG0_PRU0_GPO10: length 40.8
  TOP w0.147: J2.B29 v1(38.99,128.54)
  L03_SIG1 w0.091: v1(38.99,128.54) 38.99,126.15 40.03,125.11 40.03,122.54 41.61,120.97 44.44,120.97 45.12,120.29 45.12,115.2 46.55,113.77 46.55,98.46 47.97,97.04 v1(49.02,97.04)
  BOTTOM w0.147: U75.31 49.54,96.53 v1(49.02,97.04)
HSE_PRG0_PRU1_GPO7: length 34.6
  TOP w0.147: J2.D23 v1(46.61,131.08)
  L03_SIG1 w0.091: v1(46.61,131.08) 46.14,130.61 46.14,125.58 51.32,120.4 51.32,114.46 52.42,113.36 52.42,103.28 v1(53.2,102.5)
  BOTTOM w0.147: U75.42 v1(53.2,102.5)
HSE_PRG0_PRU1_GPO9: length 35.6
  TOP w0.147: J2.E23 v1(46.61,132.35)
  L03_SIG1 w0.091: v1(52.2,102.5) 52.2,112.97 49.91,115.26 49.91,121.02 45.95,124.98 45.95,131.69 v1(46.61,132.35)
  BOTTOM w0.147: 52.2,100.48 v1(52.2,102.5)
HSE_PRG0_PRU1_GPO10: length 40.1
  TOP w0.147: J2.E27 v1(41.53,132.35)
  L03_SIG1 w0.091: v1(49.04,100.09) 49.04,101.85 47.16,103.73 47.16,114.1 45.79,115.46 45.79,120.44 44.53,121.71 42.16,121.71 41.5,122.37 41.5,124.83 40.87,125.46 40.87,131.69 v1(41.53,132.35)
  BOTTOM w0.147: v1(49.04,100.09) 49.58,99.55 50.04,99.55 50.06,99.53 U75.37
HSE_PRG0_PRU1_GPO17: length 39.1
  TOP w0.147: J2.C28 v1(40.26,129.81)
  L03_SIG1 w0.091: v1(40.26,129.81) 40.69,129.38 40.69,125.39 41.31,124.76 41.31,122.29 42.17,121.43 44.5,121.43 45.57,120.36 45.57,115.37 46.98,113.97 46.98,103.28 47.9,102.36 47.9,99.37 48.19,99.07 v1(49.02,99.07)
  BOTTOM w0.147: v1(49.02,99.07) 49.26,99.07 49.81,98.53 U75.35
IFORCE: length 5.3
  TOP w0.147: U23.H16 v1(93.86,72.7)
  BOTTOM w0.114: TP71.1 95.26,69.14 94.26,70.14 94.26,72.3 v1(93.86,72.7)
IN_SEL0: length 2.6
  TOP w0.147: R40.2 v1(55.88,106.95)
  BOTTOM w0.147: U70.30 56.45,107.06 56.33,106.95 v1(55.88,106.95) R40.2
IN_SEL1: length 3.2
  TOP w0.147: R45.1 v1(55.88,105.68)
  BOTTOM w0.147: U70.29 56.31,106.56 55.88,106.13 v1(55.88,105.68) R45.1
INA_ALERT: length 142.2
  TOP w0.147: J4.4 136.78,121.81 142.95,115.64 ; R43.2 125.62,106.93 125.73,107.04 132.63,107.04 134.51,105.15 R47.1 R48.2 137.41,105.63 137.72,105.93 142.37,105.93 142.95,106.51 142.95,107.1 v1(143.79,107.94) 143,108.73 142.95,108.73 142.95,115.64 ; 142.95,115.64 143.89,116.58 149.5,116.58 149.97,116.11 R28.2 ; R1.2 v1(86.36,132.22) ; R122.2 v1(137.56,74.55)
  L03_SIG1 w0.091: J4.4 134.67,126.84 96.24,126.84 91.36,131.71 90.17,131.71 89.61,132.28 86.85,132.28 86.79,132.22 v1(86.36,132.22) ; v1(137.56,74.55) 138.3,75.29 138.3,90.68 144.12,96.5 144.12,107.15 143.79,107.48 v1(143.79,107.94)
  BOTTOM w0.147: v1(143.79,107.94) 144.24,107.94 144.4,108.09 R244.2
IO_EXP_INTN_SDIO: length 72.2
  TOP w0.147: v1(98.3,63.26) 98.3,64.18 97.06,65.41 97.06,69.5 U23.C20 ; v1(59.45,29.75) 59.98,29.22 60.83,29.22 62.36,30.75 62.36,32.91 63.25,33.8 78.11,33.8 91.44,47.13 92.46,47.13 93.8,48.47 93.8,49.36 93.47,49.68 93.47,51.12 93.6,51.25 v1(93.6,51.7)
  L08_SIG2 w0.091: v1(98.3,63.26) 99.06,62.5 99.06,56.39 94.38,51.7 v1(93.6,51.7)
  BOTTOM w0.147: v1(59.45,29.75) R465.1 58.9,30.37 58.74,30.53 58.74,31.21 58.54,31.41 U91.32
JTAG_CTI_RTCK: length 33.8
  TOP w0.147: v1(70.1,50.18) 70.61,49.67 J25.9
  L08_SIG2 w0.091: v1(81.05,27.83) 81.05,31.41 77.64,34.82 77.64,39.02 70.48,46.17 70.48,49.8 v1(70.1,50.18)
  BOTTOM w0.147: R636.1 R637.1 R491.1 v1(81.05,27.83)
JTAG_CTI_TCK: length 34.6
  TOP w0.147: J25.11 69.34,48.5 69.56,48.72 69.68,48.72 v1(70,49.04) ; U53.2 R190.1 R188.1 v1(76.16,29.48)
  L03_SIG1 w0.091: v1(70,49.04) 70,48.6 69.98,48.58 69.98,46.62 70.48,46.12 70.48,31.64 72.64,29.48 v1(76.16,29.48)
  BOTTOM w0.147: v1(76.16,29.48) 77.59,29.48 78.26,28.82 U53.2
JTAG_DIR: length 3.2
  TOP w0.147: U37.3 87.69,51.62 R148.2 88.16,51.49 88.19,51.46 U37.2
JTAG_EMU0: length 53.6
  TOP w0.147: v1(96.63,34.7) 96.37,34.44 U45.8 ; v1(96.63,31.15) 96.37,30.89 U48.8 ; v1(69.09,49.04) 68.58,49.04 68.07,48.53 J25.13
  L03_SIG1 w0.091: v1(96.63,34.7) 95.78,34.7 93.47,32.4 92.66,32.4 91.13,30.88 80.75,30.88 77.7,33.92 75.75,33.92 72.7,36.98 72.7,47.08 70.29,49.48 69.53,49.48 v1(69.09,49.04)
  BOTTOM w0.147: v1(96.63,31.15) 95.41,32.36 R455.2 96.11,34.76 96.17,34.7 v1(96.63,34.7)
JTAG_EMU1: length 45.1
  TOP w0.147: U45.1 98.31,34.44 98.2,34.56 v1(97.79,34.56) ; v1(72.26,37.1) 69.33,37.1 68.18,38.26 68.18,39.57 68.07,39.68 J25.14 ; v1(97.94,31.15) 98.2,30.89 U48.1
  L03_SIG1 w0.091: v1(72.26,37.1) 75.89,33.48 77.84,33.48 80.79,30.52 93.75,30.52 v1(97.79,34.56)
  BOTTOM w0.147: v1(97.94,31.15) 99.06,32.27 99.06,34.32 R458.2 98.32,34.48 98.24,34.56 v1(97.79,34.56)
JTAG_EMU_RSTN: length 141
  TOP w0.147: v1(65.53,35.64) 62.68,38.5 62.68,48.97 63.89,50.18 66.06,50.18 66.66,49.58 R150.2 66.66,48.95 66.8,48.81 J25.15 ; U41.6 139.56,45.03 137.97,46.62 134.75,46.62 134.11,47.26 130.68,47.26 125.6,42.18 125.6,33.3 123.7,31.39 116.6,31.39 113.64,28.44 v1(113.64,27.6)
  L03_SIG1 w0.091: v1(65.53,35.64) 67.61,33.57 67.61,17.9 69.11,16.4 79.36,16.4 79.61,16.14 89.92,16.14 94.23,11.83 102.87,11.83 108.76,17.72 108.76,22.72 v1(113.64,27.6)
  BOTTOM w0.147: R449.1 v1(65.53,35.64)
JTAG_MIPI_EMU0: length 35
  TOP w0.147: v1(96.63,32.13) 96.37,32.39 U48.5
  L03_SIG1 w0.091: v1(72.14,38.24) 71.83,37.93 71.83,36.27 74.84,33.26 77.75,33.26 80.7,30.3 94.8,30.3 v1(96.63,32.13)
  BOTTOM w0.147: J33.38 71.72,39.58 71.71,39.57 71.71,39.2 71.72,39.19 71.72,38.66 v1(72.14,38.24) ; R461.2 v1(96.63,32.13)
JTAG_MIPI_EMU1: length 37.1
  TOP w0.147: v1(97.94,32.13) 98.2,32.39 U48.4
  L03_SIG1 w0.091: v1(97.94,32.13) 97.5,31.69 97.5,31.1 96.49,30.08 80.61,30.08 77.66,33.03 74.74,33.03 71.61,36.17 71.61,38.82 v1(72.17,39.38)
  BOTTOM w0.147: R460.2 v1(97.94,32.13) ; J33.40 72.26,41.17 72.26,39.48 v1(72.17,39.38)
JTAG_MIPI_RTCK: length 40.9
  L08_SIG2 w0.091: v1(64.14,48.78) 64.14,36.72 63.63,36.21 63.63,34.3 63.25,33.92 63.25,31.54 64.8,29.99 71.25,29.99 75.46,25.77 v1(75.46,23.98)
  BOTTOM w0.147: v1(64.14,48.78) 64.22,48.7 J33.7 ; R638.1 R639.1 v1(75.46,23.98) R492.1
JTAG_MIPI_TCK: length 35.8
  TOP w0.147: v1(70.58,29.48) R187.1 R189.1 U52.2
  L08_SIG2 w0.091: v1(63.14,48.78) 63.14,37.37 62.48,36.72 62.48,31.64 64.64,29.48 v1(70.58,29.48)
  BOTTOM w0.147: v1(70.58,29.48) 71.8,29.48 72.67,28.62 U52.2 ; J33.3 63.22,48.7 v1(63.14,48.78)
JTAG_MUX_SEL: length 15.4
  TOP w0.147: U60.1 v1(98.2,14.08)
  BOTTOM w0.147: v1(98.2,14.08) 100.06,12.21 J29.2
JTAG_TCK: length 54.3
  TOP w0.147: v1(97.18,12.78) 97.83,12.13 U60.4 ; U37.12 v1(86.69,46.28)
  L03_SIG1 w0.091: v1(97.18,12.78) 97.62,12.34 98.81,12.34 101.78,15.31 101.78,23.87 103.38,25.47 103.38,31.51 103.2,31.69 102.68,31.69 102.42,31.95 102.42,32.98 100.04,35.36 97.88,35.36 97.44,35.8 95.36,35.8 90.08,41.08 90.08,44.81 88.14,46.75 87.16,46.75 v1(86.69,46.28)
  BOTTOM w0.147: v1(86.69,46.28) 86.69,45.83 86.75,45.76 R640.2
JTAG_TDI: length 30
  TOP w0.147: 75.06,49.16 74.42,48.53 J25.3 ; 75.06,49.16 75.06,50.05 74.17,50.94 64.26,50.94 v1(63.37,51.83) 62.82,51.28 R642.2 ; 75.06,49.16 81.66,49.16 84.33,46.5 85.34,46.5 85.69,46.84 U37.10
  BOTTOM w0.147: R410.2 v1(63.37,51.83)
JTAG_TDIS: length 2.9
  TOP w0.147: J25.4 R177.2
JTAG_TDO: length 58.5
  TOP w0.147: J25.7 v1(71.88,49.29) ; U46.7 90.48,36.39 90.72,36.63 91.36,36.63 91.82,37.09 91.82,38.11 91.44,38.5 v1(83.82,38.5)
  L03_SIG1 w0.091: v1(71.88,49.29) 71.43,49.74 69.19,49.74 68.55,49.1 68.55,40.94 69.6,39.89 69.6,37.2 68.6,36.21 64.83,36.21 v1(64.26,35.64)
  BOTTOM w0.147: R450.1 v1(64.26,35.64) 64.93,34.98 69.88,34.98 71.2,36.29 81.62,36.29 v1(83.82,38.5)
JTAG_TMS: length 53.3
  TOP w0.147: R641.2 v1(62.99,35.64) ; J25.1 83.15,46.66 84.54,45.26 v1(85.69,45.26) 85.69,45.32 86.19,45.82 U37.11
  L03_SIG1 w0.091: v1(85.69,45.26) 80.23,50.73 69.87,50.73 68.33,49.18 68.33,40.91 68.36,40.87 68.36,40.87 69.38,39.85 69.38,37.64 68.2,36.46 63.81,36.46 v1(62.99,35.64)
  BOTTOM w0.147: R641.2 v1(62.99,35.64)
JTAG_TRST#: length 30.4
  TOP w0.147: U37.13 87.19,45.33 86.75,44.89 R643.2 86.75,43.7 85.65,42.6 78.54,42.6 78.16,42.22 R685.2 C529.2 78.16,37.84 75.51,35.19 67.26,35.19 v1(66.8,35.64)
  BOTTOM w0.147: R448.1 v1(66.8,35.64)
LED1: length 34.1
  TOP w0.147: U34.3 41.78,49.23 41.68,49.33 41.68,51.79 34.37,59.11 34.37,60.08 29.84,64.6 29.84,68.36 31.54,70.05 34.26,70.05 36.35,72.14 LD16.1
LED2: length 32.5
  TOP w0.147: LD17.1 34.32,72.15 32.55,70.38 30.79,70.38 29.55,69.14 29.55,64.48 34.07,59.95 34.07,58.98 40.28,52.77 40.28,49.28 40.51,49.05 U34.4
LED3: length 30.5
  TOP w0.147: LD18.1 32.28,72.13 31.43,71.27 31.09,71.27 29.25,69.43 29.25,64.36 33.78,59.83 33.78,58.86 34.79,57.85 34.79,56.6 39.24,52.15 U34.5
LED4: length 29.1
  TOP w0.147: U34.6 37.97,52.96 34.49,56.44 34.49,57.73 33.48,58.74 33.48,59.71 28.96,64.24 28.96,69.8 30.25,71.09 LD19.1
LED5: length 54.9
  TOP w0.147: v1(60.48,46.51) 60.15,46.84 58.75,46.84 57.33,45.42 56.34,45.42 56.03,45.11 54.01,45.11 53.01,44.11 50.66,44.11 50.11,44.66 46.1,44.66 45.73,45.03 43.26,45.03 42.72,45.57 39.8,45.57 37.97,43.74 U34.11 ; LD14.1 v1(51.15,68.59)
  L03_SIG1 w0.091: v1(51.15,68.59) 53.71,68.59 58.55,63.75 58.55,60.6 60.59,58.57 60.59,52.63 60.48,52.52 v1(60.48,46.51)
LED6: length 52.1
  TOP w0.147: v1(50.55,67.69) 50.52,67.67 50.24,67.67 50.09,67.81 LD13.1 ; v1(59.05,45.97) 58.3,45.97 57.45,45.12 56.46,45.12 56.15,44.82 54.13,44.82 53.13,43.82 50.54,43.82 49.99,44.36 45.98,44.36 45.61,44.73 42.55,44.73 42.33,44.96 40.21,44.96 39.88,44.63 39.88,43.65 39.24,43.02 U34.12
  L03_SIG1 w0.091: v1(59.05,45.97) 59.73,46.65 59.73,58.53 57.63,60.63 57.63,63.32 57.61,63.34 57.61,63.69 57.63,63.71 57.63,63.8 53.75,67.69 v1(50.55,67.69)
LED7: length 89.8
  TOP w0.147: LD12.1 23.53,87.23 v1(23.77,87.48) ; U34.13 40.51,43.02 41.41,43.92 42.59,43.92 43.11,44.44 45.49,44.44 45.86,44.07 49.87,44.07 50.41,43.53 57.47,43.53 v1(58.72,44.78)
  L03_SIG1 w0.091: v1(58.72,44.78) 58.17,45.33 58.17,48.3 57.71,48.77 57.71,53.04 56.62,54.13 56.62,56.79 55.85,57.56 55.85,59.77 55.95,59.87 55.95,60.22 55.7,60.47 55.68,60.47 v1(55.37,60.78)
  BOTTOM w0.147: v1(55.37,60.78) 53.72,60.78 51.92,62.59 51.92,63.3 50.32,64.9 48.26,64.9 47.12,66.04 47.12,67.71 46.66,68.17 46.66,72.82 42.07,77.41 42.07,84.33 41.28,85.12 36.62,85.12 35.25,86.49 26.51,86.49 25.53,87.48 v1(23.77,87.48)
LED8: length 94.6
  TOP w0.147: v1(59.21,44.12) 58.12,43.03 46.48,43.03 45.36,44.15 43.23,44.15 42.71,43.62 42.39,43.62 41.78,43.02 U34.14 ; LD11.1 v1(19.42,87.23)
  L03_SIG1 w0.091: v1(55.52,60.05) 55.52,57.6 56.32,56.8 56.32,54.07 57.35,53.04 57.35,48.86 57.99,48.23 57.99,44.63 58.47,44.15 58.81,44.15 58.84,44.12 v1(59.21,44.12)
  BOTTOM w0.147: v1(19.42,87.23) 19.88,87.23 20.14,86.97 25.32,86.97 26.1,86.2 35.12,86.2 36.49,84.83 41.16,84.83 41.77,84.21 41.77,77.28 46.37,72.68 46.37,68.05 46.54,67.88 46.83,67.59 46.83,65.91 48.14,64.6 49.45,64.6 50.24,63.81 50.24,62.05 52.25,60.05 v1(55.52,60.05)
LM5140_COMP1: length 6.2
  TOP w0.147: U30.29 158.26,59.48 157.71,58.93 156.44,58.93 155.37,57.86 155.37,57.37 R142.1 155.17,57.01 C135.2
LM5140_COMP2: length 4
  TOP w0.147: C130.1 168.2,59.14 168.18,59.16 R141.2 166.94,59.16 166.63,59.48 U30.2
MCAN0_H: length 7.8
  TOP w0.104: U4.7 21.97,126.78 22.07,126.88 22.37,126.88 22.48,126.99 22.48,127.4 R4.1 22.48,128.16 22.48,129.43 J31.1
MCAN0_L: length 7.8
  TOP w0.104: U4.6 23.24,126.78 23.13,126.88 22.83,126.88 22.73,126.99 22.73,127.4 R5.2 22.73,128.16 22.73,129.42 J31.3
MCAN0_RX: length 41.8
  L08_SIG2 w0.091: v1(50.66,119.17) 51.31,118.52 51.31,116.35 50.05,115.09 45.13,115.09 41.82,118.4 41.09,118.4 40.29,119.19 28.31,119.19 27.1,117.98 27.1,117.16 J9.1
  BOTTOM w0.147: v1(50.66,119.17) 50.18,119.65 U67.2 ; J9.1 24.51,115.7 24.13,116.08 24.13,118.12 24.51,118.5 R220.1
MCAN0_RX/HSE: length 123.1
  TOP w0.147: v1(72.9,115.2) 78.36,115.2 79.37,114.18 97.49,114.18 107.49,104.18 107.49,92.29 112.49,87.3 112.49,82.65 115.39,79.74 115.39,70.01 113.13,67.75 111.6,67.75 111.3,67.44 105.28,67.44 103.83,68.88 103.83,69.16 103.38,69.61 101.99,69.61 101.25,70.35 101.25,71.31 99.86,72.7 98.66,72.7 U23.B17
  BOTTOM w0.147: v1(72.9,115.2) 71.87,116.22 60.96,116.22 59.69,117.49 54.22,117.49 53.36,118.35 U67.4
MCAN0_STB_3V3: length 120.6
  TOP w0.381: U4.8 R9.2 19.05,126.5 v1(19.05,126.51)
  L03_SIG1 w0.091: v1(51.07,31.41) 50.7,31.41 50.37,31.75 50.37,32.49 46.34,36.52 46.34,40.63 43.96,43 42.67,43 39.88,45.8 39.88,63.01 39.63,63.26 39.63,69.93 38.73,70.82 38.73,77.92 37.97,78.69 37.97,87.48 37.03,88.43 37.03,91.89 33.78,95.14 33.78,108.8 34.67,109.68 34.67,113.55 35.69,114.57 35.69,119.54 30.88,124.35 21.21,124.35 v1(19.05,126.51)
  BOTTOM w0.147: U91.9 v1(51.07,31.41)
MCAN0_T: length 8
  TOP w0.147: R4.2 C2.1 v1(19.92,128.52) ; R5.1 v1(24.89,127.78)
  BOTTOM w0.147: v1(24.89,127.78) 20.66,127.78 v1(19.92,128.52)
MCAN0_TX: length 41.5
  L08_SIG2 w0.091: v1(50.79,117.14) 50.79,116.21 49.89,115.31 45.23,115.31 41.82,118.73 41.33,118.73 40.62,119.43 27.23,119.43 25.21,117.42 24.82,117.42 J9.2
  BOTTOM w0.147: U67.5 50.23,117.7 v1(50.79,117.14) ; R221.1 20.7,117.74 21.97,116.47 J9.2
MCAN0_TX/HSE: length 122.2
  TOP w0.147: U23.A17 99.85,72.3 100.97,71.19 100.97,70.22 101.91,69.27 102.94,69.27 105.06,67.14 111.42,67.14 111.73,67.45 113.26,67.45 115.69,69.89 115.69,79.87 112.78,82.77 112.78,87.42 108.08,92.12 108.08,104.01 97.61,114.48 79.49,114.48 78.38,115.58 73.41,115.58 73.28,115.71 v1(71.63,115.71)
  BOTTOM w0.147: v1(71.63,115.71) 56.9,115.71 56.01,116.6 54.48,116.6 54.28,116.4 U67.7
MCAN1_H: length 7.8
  TOP w0.104: J32.1 12.57,129.43 12.57,128.15 R2.1 12.57,127.4 12.57,126.99 12.47,126.88 12.17,126.88 12.07,126.78 U3.7
MCAN1_L: length 7.8
  TOP w0.104: J32.3 12.82,129.42 12.82,128.16 R3.2 12.83,127.4 12.83,126.99 12.93,126.88 13.23,126.88 13.34,126.78 13.34,125.78
MCAN1_RX: length 40.7
  L08_SIG2 w0.091: J10.1 19.39,119.73 40.79,119.73 41.41,119.11 42.09,119.11 v1(44.15,117.05)
  BOTTOM w0.147: J10.1 13.84,115.44 14.6,116.2 R222.1 ; U67.11 v1(44.15,117.05)
MCAN1_RX/HSE: length 91
  TOP w0.147: U23.D17 v1(97.06,71.9)
  L03_SIG1 w0.091: v1(97.06,71.9) 96.98,71.9 96.58,72.31 88.93,72.31 88.69,72.55 88.69,75.26 88.95,75.52 89.2,75.52 89.43,75.75 89.43,78.46 89.18,78.71 84.11,78.71 81.66,81.16 81.66,82 78.93,84.73 78.93,94.95 v1(77.53,96.34)
  BOTTOM w0.147: v1(77.53,96.34) 77.09,96.79 77.09,107.71 70.73,114.07 60.55,114.07 59.78,113.3 55.24,113.3 54.23,114.31 46.19,114.31 44.75,115.75 U67.9
MCAN1_STB_3V3: length 131.7
  TOP w0.381: U3.8 R8.2 9.14,126.5 v1(9.15,126.51)
  L03_SIG1 w0.091: v1(51.82,31.94) 51.69,31.81 51.69,31.26 51.31,30.88 50.68,30.88 50.14,31.41 50.14,32.41 43.69,38.86 43.69,41.07 42.34,42.42 41.25,42.42 39.66,44.01 39.66,62.59 38.51,63.74 38.51,77.83 37.75,78.59 37.75,87.23 37.08,87.9 36.56,87.9 36.03,88.43 36.03,92.51 33.56,94.98 33.56,108.89 34.36,109.69 34.36,110.94 33.73,111.58 33.73,113.24 35.45,114.97 35.45,118.38 29.73,124.09 11.56,124.09 v1(9.15,126.51)
  BOTTOM w0.147: v1(51.82,31.94) 51.84,31.91 U91.10
MCAN1_T: length 8
  TOP w0.147: v1(10.01,128.52) C1.1 R2.2 ; R3.1 v1(14.99,127.78)
  BOTTOM w0.147: v1(10.01,128.52) 10.76,127.78 v1(14.99,127.78)
MCAN1_TX: length 43.4
  L08_SIG2 w0.091: v1(44.44,118.79) 43.14,120.09 17.2,120.09 J10.2
  BOTTOM w0.147: v1(44.44,118.79) 44.23,119 U67.14 ; J10.2 11.3,115.44 10.8,115.95 R223.1
MCAN1_TX/HSE: length 93.5
  TOP w0.147: U23.C17 v1(97.86,71.9)
  L03_SIG1 w0.091: v1(77.54,97.42) 79.15,95.82 79.15,84.82 82.04,81.93 82.04,81.58 84.11,79.52 89.99,79.52 90.27,79.23 90.27,75.78 89.98,75.49 89.7,75.49 89.48,75.26 89.48,73.27 89.64,73.11 96.4,73.11 96.66,72.85 96.66,72.57 96.92,72.31 97.46,72.31 v1(97.86,71.9)
  BOTTOM w0.147: v1(77.54,97.42) 77.54,107.89 70.99,114.44 58.17,114.44 57.4,113.68 55.5,113.68 54.36,114.82 46.14,114.82 44.78,116.18 44.78,117.49 44.57,117.7 U67.12
MCU_GPIO0_6: length 161.9
  TOP w0.147: v1(101.22,80.7) 100.76,80.7 100.72,80.66 99.27,80.66 99.22,80.7 98.66,80.7 U23.B7 ; v1(116.87,76.82) 122.06,71.63 123.44,71.63 124.84,70.23 124.84,66.94 125.75,66.03 125.75,63.4 129.95,59.21 129.95,56.44 131.44,54.94 131.44,49.93 123.38,41.86 v1(123.38,31.95)
  L03_SIG1 w0.091: v1(116.87,76.82) 116.87,78.48 116.73,78.61 113.63,78.61 113.41,78.83 106.24,78.83 103.92,81.15 101.67,81.15 v1(101.22,80.7)
  L08_SIG2 w0.091: J1.8 147.96,129.81 147.96,127.9 144.21,124.15 142.06,124.15 140.24,122.33 122.42,122.33 116.57,116.48 116.57,97.46 111.99,92.88 110.85,92.88 108,90.03 108,86.98 102.13,81.11 101.62,81.11 v1(101.22,80.7)
  BOTTOM w0.147: R470.2 v1(123.38,31.95)
MCU_GPIO0_7: length 89.3
  TOP w0.147: U23.D7 v1(97.06,80.7)
  L08_SIG2 w0.091: J1.9 144.96,121.74 141.3,121.74 140.44,120.88 122.78,120.88 117.24,115.33 117.24,97.16 108.59,88.51 108.59,86.79 106.26,84.46 106.26,82.71 106.17,82.62 106.17,80.93 105.45,80.2 98.44,80.2 98.34,80.3 97.46,80.3 v1(97.06,80.7)
MCU_GPIO0_8: length 83.2
  TOP w0.147: U23.C7 v1(97.86,80.7)
  L08_SIG2 w0.091: v1(97.86,80.7) 98.84,80.7 99.14,80.41 100.39,80.41 101.28,81.29 102.05,81.29 107.78,87.02 107.78,90.13 110.76,93.1 111.9,93.1 116.35,97.55 116.35,116.58 122.33,122.55 140.15,122.55 142.95,125.36 143,125.36 144.53,125.36 146.18,127.01 146.18,128.03 J1.5
MCU_GPIO0_9: length 93.3
  TOP w0.147: U23.C8 v1(97.86,79.9)
  L08_SIG2 w0.091: J1.12 153.16,129.94 153.16,128.37 152.35,127.56 151.08,127.56 144.22,120.7 122.88,120.7 117.46,115.28 117.46,97.12 108.77,88.44 108.77,86.72 107.19,85.14 107.19,81.18 105.99,79.98 100.6,79.98 100.53,79.9 v1(97.86,79.9)
MCU_I2C0_SCL: length 91.5
  L08_SIG2 w0.091: J1.20 163.19,129.81 163.19,127.53 153.21,117.54 123.46,117.54 119.19,113.26 119.19,88.35 114.54,83.71 113.74,83.71 113.1,83.07 v1(111.76,83.07)
  BOTTOM w0.147: R593.1 113.39,82.28 113.25,82.42 112.51,82.42 112.41,82.52 R311.2 v1(111.76,83.07)
MCU_I2C0_SCL_RC: length 23.2
  TOP w0.147: U23.E9 v1(96.26,79.1)
  L08_SIG2 w0.091: v1(112.41,79.68) 112.41,77.71 110.47,75.76 100.14,75.76 97.98,77.92 97.7,77.92 97.48,78.15 97.48,78.43 97.2,78.71 96.73,78.71 96.33,79.1 v1(96.26,79.1)
  BOTTOM w0.147: v1(112.41,79.68) C487.1 R593.2
MCU_I2C0_SDA: length 85.7
  L08_SIG2 w0.091: J1.17 162.05,126.64 153.17,117.76 123.37,117.76 119,113.39 119,91.59 v1(111.76,84.34)
  BOTTOM w0.147: R594.1 110.81,85.79 111.76,84.84 v1(111.76,84.34) R309.2
MCU_I2C0_SDA_RC: length 23.9
  TOP w0.147: U23.A10 v1(100.71,77.9)
  L08_SIG2 w0.091: v1(100.71,77.9) 102.67,75.95 110.39,75.95 111.81,77.36 111.81,81.5 111.25,82.06 111.25,84.45 v1(110.89,84.81)
  BOTTOM w0.147: C488.1 R594.2 v1(110.89,84.81)
MCU_I2C1_SCL: length 105.4
  TOP w0.147: v1(102.74,77.99) 101.85,77.1 U23.A11
  L08_SIG2 w0.091: J1.18 160.61,129.77 160.61,126.72 159.89,126 159.89,124.86 153.02,117.98 123.28,117.98 118.78,113.48 118.78,91.67 112.73,85.61 v1(111.76,85.61) 111.07,85.61 109.65,84.19 109.65,78.2 108.76,77.32 103.42,77.32 v1(102.74,77.99)
  BOTTOM w0.147: R306.2 v1(111.76,85.61)
MCU_I2C1_SDA: length 98.6
  TOP w0.147: v1(102.74,79.14) 102.05,78.45 101.41,78.45 101.34,78.37 100.59,78.37 100.52,78.3 98.66,78.3 U23.B10
  L08_SIG2 w0.091: J1.14 156.72,131.21 155.57,130.06 155.57,128.03 154.43,126.89 151.01,126.89 144.46,120.33 124.38,120.33 117.9,113.85 117.9,96.91 113.36,92.37 113.36,88.48 v1(111.76,86.88) 109.72,86.88 107.74,84.91 107.74,79.99 105.85,78.1 104.15,78.1 103.12,79.14 v1(102.74,79.14)
  BOTTOM w0.147: R303.2 v1(111.76,86.88)
MCU_OSC0_XI: length 9
  TOP w0.147: R138.2 99.19,63.99 97.46,65.73 U23.C21
MCU_OSC0_XO: length 11.3
  TOP w0.147: R139.2 101.28,60.77 100.36,61.69 100.36,64.31 98.42,66.25 98.42,68.29 97.86,68.86 97.86,69.5 U23.B20
MCU_PORZ: length 341.1
  TOP w0.147: U23.B21 98.37,68.99 98.37,68.75 98.77,68.35 98.77,66.93 100.88,64.82 113.96,64.82 115.3,66.16 116.66,66.16 R606.1 117.23,65.58 117.23,65.39 120.52,62.09 120.52,61.08 120.85,60.75 123.22,60.75 124.36,61.89 126.85,61.89 128.85,59.88 128.85,55.75 127.46,54.36 126.37,54.36 125.19,53.18 125.19,51.09 124.61,50.51 ; J2.E30 v1(37.72,132.35) ; 124.61,50.51 U35.4 ; 124.61,50.51 R575.2 123.99,50.51 123.78,50.3 v1(123.33,50.3) 123.33,50.97 TP33.1
  L03_SIG1 w0.091: v1(123.33,50.3) 123.33,32.99 118.36,28.02 118.36,21.86 112.9,16.4 108.07,16.4 103.05,11.38 94.05,11.38 90.51,14.92 79.33,14.92 78.36,15.89 66.93,15.89 55.5,27.32 52.32,27.32 48.43,31.22 47.63,31.22 47.27,31.57 47.27,32.08 47.4,32.2 47.4,33.31 43.61,37.1 35.83,37.1 29.92,43.01 28.96,43.01 26.62,45.34 26.62,62.53 28.93,64.83 28.93,84.63 24.71,88.85 24.71,90.05 20.77,93.98 20.77,116.2 23.32,118.75 26.36,118.75 27.64,117.47 28.18,117.47 28.42,117.71 28.42,119.1 23.72,123.81 10.33,123.81 8.5,125.64 8.5,126.74 9.12,127.36 9.8,127.36 11.05,126.11 16.76,126.11 17.96,127.3 22.28,127.3 23.57,126.01 26.55,126.01 27.79,127.25 34.49,127.25 36.52,129.27 36.52,131.14 v1(37.72,132.35)
MCU_RESETSTATZ: length 212.1
  TOP w0.147: U23.B13 98.66,75.9 101.66,75.9 v1(102.49,75.07) ; TP1.1 164.59,127.54 J1.19 ; J2.E3 v1(72.01,132.35)
  L03_SIG1 w0.091: v1(72.01,132.35) 72.45,132.79 75.64,132.79 77.72,130.7 77.72,129.55 80.01,127.27 82.3,127.27 85.22,130.19 85.22,131.97 86.11,132.86 93.32,132.86 99.15,127.02 134.88,127.02 137.79,129.94 163.32,129.94 J1.19
  L08_SIG2 w0.091: J1.19 153.25,117.32 124.24,117.32 120.74,113.82 120.74,112.32 119.86,111.43 119.86,88.44 114.7,83.28 114.7,82.31 113.28,80.89 113.28,77.64 110.72,75.07 v1(102.49,75.07)
MCU_RESETZ: length 173.3
  TOP w0.147: v1(105.28,81.91) 104.83,81.91 104.39,81.48 104.39,80.43 103.31,79.35 103.31,77.92 102.06,76.66 101.67,76.66 v1(101.35,76.34) 100.87,76.82 99.34,76.82 99.22,76.7 98.66,76.7 U23.B12 ; TP46.1 123.72,26.08 123.93,26.28 123.93,26.89 123.24,27.57 122.43,27.57 U50.7 121.55,27.58 121.41,27.72 v1(121.41,27.83) ; J2.D3 v1(72.01,131.08)
  L03_SIG1 w0.091: v1(72.01,131.08) 72.01,131.08 72.62,130.47 72.62,128.26 70.67,126.31 70.67,118.03 73.49,115.2 75.2,115.2 78.11,112.29 97.47,112.29 106.93,102.83 106.93,84.47 105.94,83.48 105.94,82.57 v1(105.28,81.91) ; v1(124.03,58.19) 123.66,58.19 123.58,58.12 118.62,58.12 117.24,59.49 117.24,59.72 116.5,60.46 116.5,65.49 115,66.99 115,72.59 112.06,75.52 103.31,75.52 102.49,76.34 v1(101.35,76.34)
  L08_SIG2 w0.091: v1(121.41,27.83) 121.41,25.54 122.17,24.78 123.15,24.78 125.78,27.41 125.78,46 122.68,49.1 122.68,56.29 124.03,57.63 v1(124.03,58.19)
  BOTTOM w0.147: v1(121.41,27.83) 121.79,27.45 R477.2
MCU_SAFETY_ERRORZ_1V8: length 75.7
  TOP w0.147: U23.A20 99.95,69.01 99.95,68.21 103.05,65.11 113.61,65.11 v1(114.68,66.18) ; U10.4 v1(126.73,115.06)
  L08_SIG2 w0.091: v1(114.68,66.18) 116.57,68.07 117.87,68.07 120.96,71.17 120.96,105.09 124.16,108.29 124.16,112.5 v1(126.73,115.06)
  BOTTOM w0.147: TP72.1 v1(114.68,66.18)
MCU_SAFETY_ERRORZ_3V3: length 51.1
  TOP w0.147: U10.1 v1(125.23,115.06)
  L08_SIG2 w0.091: J1.22 165.74,129.81 165.74,127.66 155.17,117.1 126.6,117.1 125.23,115.73 v1(125.23,115.06)
MCU_SPI0_CLK: length 78.7
  L08_SIG2 w0.091: J1.16 159.26,131.21 158.24,130.19 158.24,126.25 154.76,122.77 147.42,122.77 143.07,118.42 123.1,118.42 118.34,113.67 118.34,92.45 v1(114.05,88.15)
  BOTTOM w0.147: R302.1 v1(114.05,88.15)
MCU_SPI0_CLK_R: length 21
  TOP w0.147: U23.E6 v1(96.26,81.5)
  BOTTOM w0.114: 99.69,81.9 96.66,81.9 v1(96.26,81.5)
  BOTTOM w0.147: R302.2 111.45,88.15 110.01,86.72 101.94,86.72 99.95,84.72 99.95,82.16 99.69,81.9
MCU_SPI0_CS0: length 85.8
  TOP w0.147: U23.D6 v1(97.06,81.5)
  L08_SIG2 w0.091: v1(97.06,81.5) 97.46,81.1 98.87,81.1 99.31,80.66 100.36,80.66 101.19,81.49 102,81.49 107.56,87.06 107.56,90.22 110.67,93.32 111.81,93.32 116.13,97.64 116.13,116.67 122.24,122.78 140.05,122.78 143.38,126.1 143.38,126.5 143.9,127.02 144.3,127.02 145.48,128.2 145.48,129.88 J1.6
MCU_SPI0_CS1: length 80.3
  TOP w0.147: U23.C6 v1(97.86,81.5)
  L08_SIG2 w0.091: v1(97.86,81.5) 100.21,81.5 101.14,82.44 102.68,82.44 107.34,87.1 107.34,90.31 110.58,93.54 111.72,93.54 115.91,97.73 115.91,116.76 122.15,123 139.96,123 143.13,126.16 143.13,127.52 J1.3
MCU_SPI0_D0: length 85
  TOP w0.147: U23.E7 v1(96.26,80.7)
  L08_SIG2 w0.091: J1.4 142.88,129.81 142.88,126.22 139.87,123.22 122.06,123.22 115.69,116.85 115.69,97.83 111.63,93.76 110.48,93.76 107.12,90.4 107.12,87.13 102.66,82.67 101.09,82.67 100.34,81.92 96.91,81.92 96.66,81.67 96.66,81.11 v1(96.26,80.7)
MCU_SPI0_D1: length 81.2
  TOP w0.147: v1(103.72,88.24) 102.97,87.48 102.11,87.48 100.84,86.2 100.84,82.95 99.4,81.5 98.66,81.5 U23.B6
  L08_SIG2 w0.091: J1.2 140.43,129.9 140.43,124.26 139.6,123.44 121.96,123.44 115.47,116.94 115.47,97.92 111.54,93.98 110.39,93.98 106.91,90.5 106.91,89.38 105.76,88.24 v1(103.72,88.24)
MCU_UART0_CTS_3V3: length 65.4
  TOP w0.147: U23.D8 v1(97.06,79.9)
  L03_SIG1 w0.091: v1(144.02,54.24) 140.17,54.24 135.31,59.1 133.64,59.1 130.72,62.02 125.26,62.02 120.26,67.02 116.89,67.02 116.52,67.39 116.52,68.44 v1(116.78,68.7)
  BOTTOM w0.114: v1(97.06,79.9) 97.46,79.5 98.3,79.5
  BOTTOM w0.147: v1(116.78,68.7) 113.51,68.7 112.77,67.96 108.52,67.96 107.89,68.59 107.89,70.65 107.14,71.4 102.61,71.4 102.34,71.67 102.34,72.56 101.49,73.4 100.63,73.4 99.72,74.31 99.72,78.95 99.22,79.45 98.36,79.45 98.3,79.5 ; v1(144.02,54.24) 143.6,53.83 U82.9
MCU_UART0_RTS_3V3: length 65.4
  TOP w0.147: U23.E8 v1(96.26,79.9)
  L03_SIG1 w0.091: v1(142.77,55.68) 142.51,55.41 142.51,54.89 142.11,54.5 140.22,54.5 135.4,59.32 133.73,59.32 130.81,62.24 125.35,62.24 120.1,67.5 v1(117.08,67.5)
  BOTTOM w0.114: 98.51,79.02 98.19,78.7 96.89,78.7 96.66,78.94 96.66,79.5 v1(96.26,79.9)
  BOTTOM w0.147: v1(117.08,67.5) 116.18,68.4 113.63,68.4 112.89,67.66 108.4,67.66 107.59,68.46 107.59,70.53 107.02,71.1 102.48,71.1 102.29,71.3 101.39,71.3 99.41,73.27 99.41,78.85 99.24,79.02 98.51,79.02 ; v1(142.77,55.68) 142.77,55.22 142.57,55.02 142.57,54.43
MCU_UART0_RX_3V3: length 63
  TOP w0.147: v1(101.73,79.14) 101.31,78.71 101.04,78.71 101.01,78.69 99.56,78.69 99.54,78.7 U23.A9
  L03_SIG1 w0.091: v1(145.03,54.24) 144.45,53.66 142.13,53.66 141.77,54.02 140.07,54.02 135.21,58.88 133.55,58.88 130.63,61.8 125.13,61.8 120.1,66.84 116.81,66.84 116.32,67.33 116.32,73.16 111.49,77.99 103.68,77.99 103.02,78.65 102.21,78.65 v1(101.73,79.14)
  BOTTOM w0.147: v1(145.03,54.24) 144.35,54.93 143.26,54.93 142.97,54.63 U82.8
MCU_UART0_TX_3V3: length 61.9
  TOP w0.147: v1(103.6,80.66) 102.56,79.62 100.76,79.62 100.65,79.5 U23.A8
  L03_SIG1 w0.091: v1(142.99,56.6) 140.61,56.6 140.42,56.78 138.43,56.78 132.72,62.5 125.48,62.5 119.96,68.01 118.26,68.01 116.59,69.69 116.59,73.42 115.37,74.64 115.37,76.62 113.34,78.65 106.17,78.65 104.16,80.66 v1(103.6,80.66)
  BOTTOM w0.147: U82.6 142.17,56.59 142.99,57.42 ; 142.99,57.42 v1(142.99,56.6) ; 142.99,57.42 R611.2
MCU_UART1_CTS_3V3: length 89.5
  TOP w0.147: v1(102.74,80.66) 101.99,79.91 101.35,79.91 101.34,79.9 98.66,79.9 U23.B8
  L08_SIG2 w0.091: v1(102.74,80.66) 104.42,82.34 105.64,82.34 106.08,82.78 106.08,84.54 108.41,86.87 108.41,89.87 110.94,92.4 112.14,92.4 117.02,97.28 117.02,115.46 122.62,121.06 139.59,121.06 142.24,123.71 146.05,123.71 150.46,128.12 150.46,129.78 J1.10
MCU_UART1_RTS_3V3: length 96.9
  TOP w0.147: v1(100.84,79.1) 98.66,79.1 U23.B9
  L08_SIG2 w0.091: J1.13 155.83,127.52 155.83,124.6 154.25,123.03 147.41,123.03 143.03,118.65 123.01,118.65 118.12,113.76 118.12,96.82 113.59,92.29 113.59,88.09 111.94,86.45 110.43,86.45 108.24,84.26 108.24,80.1 106.06,77.92 103.71,77.92 102.93,78.7 101.24,78.7 v1(100.84,79.1)
MCU_UART1_RX_3V3: length 91.8
  TOP w0.147: U23.C9 v1(97.86,79.1)
  L08_SIG2 w0.091: v1(97.86,79.1) 100.3,79.1 100.76,79.56 106.14,79.56 107.56,80.98 107.56,85.24 108.96,86.64 108.96,88.36 117.64,97.04 117.64,97.19 117.68,97.23 117.68,115.21 122.98,120.51 144.38,120.51 150.98,127.11 152.87,127.11 J1.11
MCU_UART1_TX_3V3: length 100.8
  TOP w0.147: U23.D9 v1(97.06,79.1)
  L08_SIG2 w0.091: J1.15 159.51,127.01 155.02,122.52 147.42,122.52 143.11,118.2 123.19,118.2 118.56,113.58 118.56,91.91 112.78,86.12 110.8,86.12 108.58,83.9 108.58,79.91 106.28,77.62 103.72,77.62 102.86,78.48 98.88,78.48 98.67,78.69 97.73,78.69 97.31,79.1 v1(97.06,79.1)
MIPI_TCK: length 31.2
  TOP w0.147: R194.1 v1(72.52,21.74) ; U60.2 97.83,13.43 v1(97.18,14.08)
  L03_SIG1 w0.091: v1(97.18,14.08) 95.86,14.08 91.73,18.21 76.55,18.21 73.01,21.74 v1(72.52,21.74)
MIPI_TDI_R: length 3.4
  BOTTOM w0.147: J33.5 63.72,48.56 63.63,48.65 63.63,49.39 63.37,49.64 R410.1
MIPI_TDO_R: length 4.4
  BOTTOM w0.147: R450.2 64.26,38.11 63.22,39.15 J33.4
MIPI_TMS_R: length 4.3
  BOTTOM w0.147: J33.2 62.72,39.06 62.48,38.82 62.48,37.68 62.95,37.21 R451.2
MIPI_TRC_CLK: length 39.5
  TOP w0.147: v1(57.12,59.78) 59.28,59.78 62.68,63.18 62.68,65.24 65.36,67.93 65.36,68.15 66.05,68.85 66.56,68.85 68.02,70.31 68.02,71.06 67.79,71.29 RA2.16
  BOTTOM w0.147: J33.13 65.72,48.37 65.38,48.71 64.97,48.71 64.01,49.67 64.01,52.34 63.69,52.66 63.69,52.82 63.89,53.02 63.89,53.19 63.77,53.3 63.61,53.3 63.41,53.11 63.24,53.11 63.12,53.22 63.12,53.39 63.32,53.59 63.32,53.75 63.2,53.87 63.04,53.87 62.84,53.67 62.67,53.67 62.56,53.79 62.56,53.96 62.75,54.16 62.75,54.32 62.64,54.44 62.47,54.44 62.27,54.24 62.11,54.24 61.99,54.36 61.99,54.52 62.19,54.72 62.19,54.89 62.07,55.01 61.73,55.01 61.52,54.79 61.35,54.79 61.23,54.91 61.23,55.08 61.42,55.27 61.42,55.48 v1(57.12,59.78)
MIPI_TRC_CTL: length 36.7
  TOP w0.147: v1(56.78,61.06) 59.79,61.06 62.38,63.65 62.38,65.37 63.75,66.74 63.75,67.31 65.74,69.3 65.99,69.3 67.06,70.36 67.06,70.63 67.16,70.74 67.16,73.12 RA2.15
  BOTTOM w0.147: v1(56.78,61.06) 57.64,60.2 57.89,60.2 66.72,51.37 J33.17
MIPI_TRC_DAT00: length 37.8
  TOP w0.147: v1(57.03,62.73) 57.8,62.73 57.93,62.6 57.93,62.21 58.06,62.08 58.24,62.08 58.37,62.21 58.37,62.6 58.5,62.73 60.52,62.73 62.09,64.3 62.09,65.49 63.12,66.52 63.12,68.07 65.09,70.05 65.72,70.05 66.04,70.36 66.04,71.13 66.7,71.79 RA2.14
  BOTTOM w0.147: v1(57.03,62.73) 57.03,61.47 67.22,51.28 J33.19
MIPI_TRC_DAT01: length 37.8
  TOP w0.147: RA2.13 66.2,72.04 64.39,70.23 63.37,70.23 62.99,69.85 62.99,68.79 62.81,68.61 62.81,68.41 62.68,68.28 62.31,68.28 62.18,68.16 62.18,67.97 62.31,67.84 62.68,67.84 62.81,67.71 62.81,67.53 62.68,67.4 62.31,67.4 62.18,67.27 62.18,67.09 62.31,66.96 62.68,66.96 62.81,66.83 62.81,66.63 61.79,65.61 61.79,64.84 60.14,63.19 58.37,63.19 v1(58.04,63.51)
  BOTTOM w0.147: v1(58.04,63.51) 58.04,61.1 67.72,51.42 J33.21
MIPI_TRC_DAT02: length 37.9
  TOP w0.147: RA2.12 65.7,72.29 64.03,70.61 62.63,70.61 62.48,70.46 62.48,68.88 62.34,68.73 61.23,68.73 61.11,68.62 61.11,68.45 61.23,68.33 61.69,68.33 61.81,68.21 61.81,68.05 61.69,67.93 61.23,67.93 61.11,67.81 61.11,67.65 61.23,67.53 61.69,67.53 61.81,67.41 61.81,66.04 61.5,65.73 61.5,64.96 60.18,63.64 v1(59.18,63.64)
  BOTTOM w0.147: J33.23 68.22,48.15 68.02,48.35 68.02,51.54 58.9,60.66 58.9,62.28 59.03,62.41 59.43,62.41 59.56,62.54 59.56,62.72 59.43,62.85 59.03,62.85 58.9,62.98 58.9,63.36 v1(59.18,63.64)
MIPI_TRC_DAT03: length 37.8
  TOP w0.147: v1(59.18,65.04) 60.33,65.04 60.82,65.52 60.82,65.95 60.82,65.95 60.82,70.82 61.12,71.12 62.01,71.12 62.14,71.25 62.14,71.7 62.27,71.83 62.45,71.83 62.58,71.7 62.58,71.25 62.71,71.12 62.89,71.12 63.05,71.27 63.05,71.78 63.18,71.91 63.36,71.91 63.49,71.78 63.49,71.25 63.62,71.12 64.08,71.12 64.64,71.68 64.64,72.32 65.2,72.88 RA2.11
  BOTTOM w0.147: v1(59.18,65.04) 59.8,65.04 60.18,64.67 60.18,59.8 68.31,51.66 68.31,48.56 68.72,48.15 J33.25
MIPI_TRC_DAT04: length 37.7
  TOP w0.147: v1(59.69,65.93) 60.38,65.93 60.53,66.08 60.53,68.35 60.4,68.48 59.95,68.48 59.82,68.61 59.82,68.79 59.95,68.92 60.4,68.92 60.53,69.05 60.53,69.23 60.4,69.36 59.95,69.36 59.82,69.49 59.82,69.68 59.95,69.81 60.4,69.81 60.53,69.94 60.53,70.12 60.4,70.25 59.95,70.25 59.82,70.38 59.82,70.56 59.95,70.69 60.4,70.69 60.53,70.82 60.53,71.07 61.77,72.31 64.13,72.31 64.7,72.88 RA2.10
  BOTTOM w0.147: J33.27 69.22,48.12 68.61,48.73 68.61,51.79 61.11,59.28 61.11,65.14 60.33,65.93 v1(59.69,65.93)
MIPI_TRC_DAT05: length 37.9
  TOP w0.147: RA2.9 63.62,73.15 63.09,72.62 60.22,72.62 59.41,71.81 59.41,67.48 v1(59.82,67.07)
  BOTTOM w0.147: v1(59.82,67.07) 62.06,64.83 62.06,64.52 61.94,64.41 61.59,64.41 61.48,64.29 61.48,64.12 61.59,64.01 62.19,64.01 62.31,63.89 62.31,63.72 62.19,63.6 61.59,63.6 61.48,63.49 61.48,63.32 61.59,63.2 62.19,63.2 62.31,63.09 62.31,62.92 62.19,62.8 61.59,62.8 61.48,62.68 61.48,59.33 68.9,51.91 68.9,49.99 69.54,49.34 69.54,48.54 69.72,48.36 J33.29
MIPI_TRC_DAT06: length 37.7
  TOP w0.147: v1(63.12,58.69) 62.68,58.69 62.48,58.5 62.48,53.09 62.7,52.87 72.28,52.87 74.04,54.62 74.8,54.62 75.44,55.26 75.44,56.72 75.15,57 RA4.16
  BOTTOM w0.147: J33.31 70.22,48.36 70.48,48.62 70.48,49.53 70.29,49.73 69.92,49.73 69.65,49.99 69.65,51.58 63.12,58.11 v1(63.12,58.69)
MIPI_TRC_DAT07: length 37.8
  TOP w0.147: RA4.15 74.57,55.92 74.48,55.83 74.48,55.48 73.52,54.52 73.35,54.52 73.18,54.7 73.01,54.7 72.89,54.58 72.89,54.41 73.07,54.24 73.07,54.07 72.16,53.16 63.05,53.16 62.87,53.34 62.87,54.1 62.99,54.23 63.24,54.23 63.37,54.36 63.37,54.54 63.24,54.67 62.99,54.67 62.87,54.8 62.87,54.98 62.99,55.11 63.24,55.11 63.37,55.24 63.37,55.42 63.24,55.55 62.99,55.55 62.87,55.68 62.87,55.86 62.99,55.99 63.24,55.99 63.37,56.12 63.37,56.31 63.24,56.44 62.99,56.44 62.87,56.57 62.87,56.75 62.99,56.88 63.24,56.88 63.37,57.01 63.37,57.19 63.24,57.32 62.99,57.32 62.87,57.45 62.87,57.71 63.08,57.92 v1(64.14,57.92)
  BOTTOM w0.147: v1(64.14,57.92) 64.46,57.6 64.46,57.18 70.83,50.82 70.83,48.46 70.72,48.36 J33.33
MIPI_TRC_DAT08: length 37.8
  TOP w0.147: RA4.14 74.07,56.68 73.35,55.97 73.35,55.45 73.09,55.19 72.57,55.19 70.88,53.49 64.09,53.49 63.7,53.88 63.7,54.38 63.83,54.51 64.64,54.51 64.77,54.64 64.77,54.82 64.64,54.95 63.83,54.95 63.7,55.08 63.7,55.26 63.83,55.39 64.64,55.39 64.77,55.52 64.77,55.7 64.64,55.83 63.83,55.83 63.7,55.96 63.7,56.15 63.83,56.28 64.64,56.28 64.77,56.41 64.77,56.59 64.64,56.72 64.08,56.72 63.93,56.87 63.93,57.08 64.59,57.73 64.59,58.33 64.81,58.55 65.17,58.55 65.32,58.4 65.32,57.72 v1(65.28,57.67)
  BOTTOM w0.147: J33.35 71.22,48.43 71.12,48.53 71.12,50.94 65.28,56.78 v1(65.28,57.67)
MIPI_TRC_DAT09: length 37.7
  TOP w0.147: RA4.13 73.57,56.82 72.84,56.1 72.58,56.1 71.83,55.35 71.2,55.35 70.93,55.08 70.93,53.99 70.87,53.93 70.71,53.93 70.61,54.03 70.61,54.66 70.48,54.79 70.3,54.79 70.17,54.66 70.17,53.93 70.04,53.8 69.86,53.8 69.73,53.93 69.73,54.66 69.6,54.79 69.41,54.79 69.28,54.66 69.28,53.93 69.15,53.8 68.97,53.8 68.84,53.93 68.84,54.66 68.71,54.79 68.53,54.79 68.4,54.66 68.4,53.93 68.27,53.8 68.09,53.8 67.96,53.93 67.96,54.66 67.83,54.79 67.65,54.79 67.52,54.66 67.52,53.93 67.39,53.8 67.2,53.8 67.07,53.93 67.07,54.66 66.94,54.79 66.76,54.79 66.63,54.66 66.63,53.93 66.5,53.8 66.32,53.8 66.19,53.93 66.19,54.66 66.06,54.79 65.88,54.79 65.75,54.66 65.75,53.93 65.62,53.8 65.38,53.8 65.07,54.1 65.07,56.72 65.63,57.27 v1(66.13,57.27)
  BOTTOM w0.147: J33.37 71.72,48.56 71.43,48.86 71.43,51.05 66.13,56.34 v1(66.13,57.27)
MIPI_TRC_DAT10: length 37.6
  TOP w0.147: v1(66.17,57.92) 66.65,57.44 66.65,57.12 66.19,56.67 65.84,56.67 65.38,56.21 65.38,55.42 65.63,55.17 70.61,55.17 71.08,55.64 71.7,55.64 73.07,57 RA4.12
  BOTTOM w0.147: J33.39 72.22,48.49 72.34,48.6 72.34,50.55 67.69,55.2 67.69,56.25 67.58,56.37 66.87,56.37 66.75,56.48 66.75,56.65 66.87,56.77 67.58,56.77 67.69,56.88 67.69,57.05 67.58,57.17 66.87,57.17 66.75,57.29 66.75,57.45 66.87,57.57 67.58,57.57 67.69,57.69 67.69,57.85 67.58,57.97 66.87,57.97 66.75,58.09 66.75,58.25 66.87,58.37 67.58,58.37 67.69,58.49 67.69,58.66 67.58,58.77 66.87,58.77 66.75,58.89 66.75,59.06 66.87,59.18 67.58,59.18 67.69,59.29 67.69,59.63 67.55,59.77 65.85,59.77 65.65,59.57 65.65,58.44 v1(66.17,57.92)
MIPI_TRC_DAT11: length 37.8
  TOP w0.147: RA4.11 72.57,56.93 71.57,55.93 70.95,55.93 70.74,55.72 70.49,55.72 70.24,55.47 69.73,55.47 69.61,55.59 69.61,56.08 69.5,56.2 69.33,56.2 69.21,56.08 69.21,55.59 69.09,55.47 68.93,55.47 68.81,55.59 68.81,56.08 68.69,56.2 68.53,56.2 68.41,56.08 68.41,55.59 68.29,55.47 67.13,55.47 66.98,55.62 66.98,57.25 67.23,57.51 69.03,57.51 69.13,57.4 69.13,56.7 69.02,56.59 68.63,56.59 v1(68.56,56.66)
  BOTTOM w0.147: v1(68.56,56.66) 68.66,56.76 69.01,56.76 69.12,56.87 69.12,57.15 69.01,57.27 68.59,57.27 68.48,57.38 68.48,57.55 68.59,57.67 69.01,57.67 69.12,57.78 69.12,58.06 68.74,58.45 68.22,58.45 67.99,58.21 67.99,55.32 68.76,54.55 68.92,54.55 69.19,54.82 69.36,54.82 69.48,54.71 69.48,54.54 69.21,54.27 69.21,54.1 69.32,53.98 69.49,53.98 69.76,54.26 69.93,54.26 70.05,54.14 70.05,53.97 69.77,53.7 69.77,53.53 69.89,53.42 70.06,53.42 70.33,53.69 70.5,53.69 70.61,53.57 70.61,53.41 70.34,53.13 70.34,52.97 70.46,52.85 70.62,52.85 70.9,53.12 71.06,53.12 71.18,53 71.18,52.84 70.91,52.57 70.91,52.4 71.03,52.28 71.19,52.28 71.46,52.55 71.63,52.55 71.75,52.44 71.75,52.27 71.48,52 71.48,51.83 71.59,51.71 71.76,51.71 72.03,51.99 72.2,51.99 72.32,51.87 72.32,51.7 72.04,51.43 72.04,51.26 72.72,50.59 J33.41
MIPI_TRC_DAT12: length 37.7
  TOP w0.147: RA4.10 72.07,57 71.91,56.85 71.15,56.85 70.7,57.29 70.7,58.61 70.3,59.01 68.84,59.01 68.52,59.33 68.52,60.71 68.39,60.84 66.42,60.84 66.29,60.71 66.29,60.44 66.41,60.32 68.04,60.32 68.16,60.21 68.16,60.04 68.04,59.92 67.5,59.92 67.38,59.8 67.38,58.88 67.26,58.76 67.1,58.76 66.98,58.88 66.98,59.8 66.86,59.92 66.41,59.92 66.29,59.8 66.29,58.88 66.92,58.25 67.6,58.25 67.72,58.37 67.72,58.6 67.84,58.71 68,58.71 68.12,58.6 68.12,58.37 68.24,58.25 68.41,58.25 68.52,58.37 68.52,58.6 68.64,58.71 68.81,58.71 68.92,58.6 68.92,58.37 69.04,58.25 69.27,58.25 69.4,58.38 69.4,58.57 69.53,58.7 69.71,58.7 69.84,58.57 69.84,58.38 69.97,58.25 70.04,58.25 70.3,57.99 70.3,57.25 70.73,56.83 70.73,56.41 70.45,56.13 70.12,56.13 v1(69.6,56.66)
  BOTTOM w0.147: v1(69.6,56.66) 69.6,55.01 73.22,51.38 J33.43
MIPI_TRC_DAT13: length 37.7
  TOP w0.147: RA4.9 71.48,57.57 71,58.05 71,58.8 70.49,59.3 68.96,59.3 68.81,59.45 68.81,60.86 68.51,61.16 66.32,61.16 65.99,60.83 65.99,60.2 65.88,60.08 64.57,60.08 64.46,59.96 64.46,59.8 64.57,59.68 65.88,59.68 65.99,59.56 65.99,59.39 65.88,59.28 64.57,59.28 64.46,59.16 64.46,58.99 64.57,58.88 65.88,58.88 66.95,57.8 v1(69.85,57.8)
  BOTTOM w0.147: J33.45 73.72,48.49 74.35,49.12 74.35,50.67 71.99,53.03 71.99,53.19 72.13,53.34 72.13,53.5 72.01,53.62 71.85,53.62 71.71,53.48 71.54,53.48 71.42,53.6 71.42,53.76 71.56,53.9 71.56,54.07 71.45,54.19 71.28,54.19 71.14,54.05 70.97,54.05 70.86,54.16 70.86,54.33 71,54.47 71,54.64 70.88,54.75 70.71,54.75 70.57,54.61 70.41,54.61 70,55.02 70,55.56 70.29,55.84 70.81,55.84 70.93,55.96 70.93,56.13 70.81,56.25 70.29,56.25 70.17,56.36 70.17,56.53 70.29,56.65 70.81,56.65 70.93,56.76 70.93,56.93 70.81,57.05 70.29,57.05 70.17,57.17 70.17,57.48 v1(69.85,57.8)
MIPI_TRC_DAT14: length 39.2
  BOTTOM w0.147: J33.47 74.22,48.58 74.65,49 74.65,50.9 74.82,51.07 77.92,51.07 78.05,51.2 78.05,53.59 78.18,53.72 78.37,53.72 78.5,53.59 78.5,51.2 78.62,51.07 79.12,51.07 79.26,51.22 79.26,52.66 79.41,52.81 81.71,52.81 82.04,53.14 82.04,53.22 81.91,53.35 80.6,53.35 80.47,53.48 80.47,53.67 80.6,53.8 81.91,53.8 82.04,53.92 82.04,54.11 81.91,54.24 80.6,54.24 80.47,54.37 80.47,54.55 80.6,54.68 81.91,54.68 82.04,54.81 82.04,54.99 81.91,55.12 80.6,55.12 80.47,55.25 80.47,55.43 80.6,55.56 81.91,55.56 82.04,55.69 82.04,55.88 81.91,56.01 80.6,56.01 80.47,56.13 80.47,56.32 80.6,56.45 81.91,56.45 82.04,56.58 82.04,56.76 81.91,56.89 80.6,56.89 80.47,57.02 80.47,57.2 80.6,57.33 81.08,57.33 81.21,57.46 81.21,58.14 81.34,58.27 81.53,58.27 81.65,58.14 81.65,57.46 81.78,57.33 81.91,57.33 82.04,57.46 82.04,57.58 82.12,57.66 RA6.16
MIPI_TRC_DAT15: length 39.4
  BOTTOM w0.147: J33.49 74.72,48.66 74.94,48.88 74.94,50.2 75.43,50.69 79.51,50.69 79.64,50.82 79.64,52.25 79.77,52.37 79.95,52.37 80.08,52.25 80.08,50.82 80.21,50.69 80.39,50.69 80.52,50.82 80.52,52.25 80.65,52.37 80.83,52.37 80.96,52.25 80.96,50.82 81.09,50.69 81.28,50.69 81.41,50.82 81.41,52.25 81.54,52.37 81.72,52.37 81.85,52.25 81.85,50.82 81.98,50.69 83.05,50.69 83.33,50.97 83.33,56.09 83.2,56.22 83.02,56.22 82.89,56.09 82.89,51.29 82.76,51.16 82.58,51.16 82.45,51.29 82.45,56.53 82.58,56.66 83.2,56.66 83.33,56.79 RA6.15
MIPI_TRC_DAT16: length 39.3
  BOTTOM w0.147: J33.51 75.22,48.74 75.31,48.83 75.31,49.94 75.68,50.31 79.1,50.31 79.25,50.16 79.25,48.81 79.41,48.64 81.94,48.64 82.24,48.34 82.24,47.24 82.44,47.04 83.69,47.04 83.83,47.19 83.83,47.63 83.72,47.75 83.15,47.75 83.03,47.87 83.03,48.86 82.88,49.01 82.22,49.01 82.07,49.15 82.07,49.79 81.95,49.91 81.78,49.91 81.67,49.79 81.67,49.12 81.55,49.01 81.38,49.01 81.27,49.12 81.27,49.79 81.15,49.91 80.98,49.91 80.86,49.79 80.86,49.12 80.75,49.01 80.13,49.01 79.98,49.15 79.98,50.12 80.13,50.27 83.16,50.27 83.43,49.99 83.43,48.27 83.55,48.15 83.72,48.15 83.83,48.27 RA6.14
MIPI_TRC_DAT17: length 39.3
  BOTTOM w0.147: RA6.13 84.33,47.03 84.04,46.74 79.74,46.74 79.62,46.86 79.62,47.03 79.74,47.14 81.82,47.14 81.93,47.26 81.93,47.43 81.82,47.54 79.74,47.54 79.62,47.66 79.62,47.83 79.74,47.95 81.82,47.95 81.93,48.06 81.93,48.23 81.82,48.35 79.36,48.35 79.24,48.23 79.24,45.51 79.1,45.36 78.67,45.36 78.52,45.51 78.52,49.59 78.19,49.93 76.57,49.93 75.72,49.08 J33.53
MIPI_TRC_DAT18: length 39.2
  BOTTOM w0.147: J33.55 76.22,48.91 76.73,49.42 77.58,49.42 78.04,48.95 78.04,45.28 78.44,44.88 79.45,44.88 79.8,45.23 79.8,46.22 79.92,46.34 82.22,46.34 82.34,46.22 82.34,46.05 82.22,45.94 80.32,45.94 80.2,45.81 80.2,45.65 80.32,45.53 83.25,45.53 84.83,47.11 84.83,52.86 85.03,53.05 86.67,53.05 86.84,53.23 86.84,53.47 86.67,53.64 84.98,53.64 84.83,53.79 84.83,54.03 85.03,54.23 86.67,54.23 86.84,54.41 86.84,54.65 86.67,54.82 84.98,54.82 84.83,54.97 RA6.12
MIPI_TRC_DAT19: length 36.8
  L03_SIG1 w0.091: v1(66.21,38.54) 66.67,39.01 66.67,48.64 71.44,53.41 82.33,53.41 84.27,55.36 84.27,55.49 84.14,55.62 84.14,55.75 84.27,55.88 84.4,55.88 84.53,55.75 84.66,55.75 v1(85.33,56.42)
  BOTTOM w0.147: v1(85.33,56.42) 85.33,56.87 85.33,56.87 RA6.11 ; J33.18 66.72,39.06 v1(66.21,38.54)
MIPI_TRC_DAT20: length 36.9
  L03_SIG1 w0.091: v1(85.83,55.53) 82.64,52.34 70.7,52.34 66.87,48.51 66.87,39.12 v1(67.39,38.6)
  BOTTOM w0.147: J33.20 67.22,39.26 67.07,39.11 67.07,38.92 v1(67.39,38.6) ; RA6.10 85.83,55.99 85.83,55.99 v1(85.83,55.53)
MIPI_TRC_DAT21: length 36.8
  L03_SIG1 w0.091: v1(67.72,39.38) 67.09,40.02 67.09,48.47 70,51.39 84.36,51.39 86.38,53.41 v1(86.38,56.42)
  BOTTOM w0.147: RA6.9 86.42,56.91 86.38,56.87 v1(86.38,56.42) ; J33.22 v1(67.72,39.38)
MIPI_TRC_DAT22: length 38.8
  L08_SIG2 w0.091: v1(77.21,38.73) 76.65,38.17 76,38.17 73.91,40.26 70.57,40.26 69.22,38.9 v1(68.84,38.9)
  BOTTOM w0.147: R392.2 89.4,54.09 86.94,51.64 86.76,51.64 86.52,51.87 86.34,51.87 86.21,51.74 86.21,51.56 86.45,51.32 86.45,51.14 86.32,51.01 86.13,51.01 85.9,51.25 85.71,51.25 85.58,51.12 85.58,50.93 85.82,50.7 85.82,50.51 85.13,49.82 85.13,46.81 83.55,45.24 81.64,45.24 77.86,41.45 77.86,39.38 v1(77.21,38.73) ; v1(68.84,38.9) 68.22,39.52 J33.24
MIPI_TRC_DAT23: length 38.7
  L08_SIG2 w0.091: v1(68.95,39.53) 69.93,40.51 74.5,40.51 v1(76.37,38.64)
  BOTTOM w0.147: v1(76.37,38.64) 76.75,38.26 77.5,38.26 78.15,38.91 78.15,41.33 81.76,44.94 83.68,44.94 85.42,46.69 85.42,48.5 86.14,49.22 86.17,49.22 88.63,51.68 88.63,51.87 88.4,52.1 88.4,52.28 88.53,52.41 88.71,52.41 88.95,52.18 89.13,52.18 89.26,52.31 89.26,52.49 89.03,52.73 89.03,52.91 89.16,53.04 89.34,53.04 89.57,52.81 89.76,52.81 90.15,53.2 90.15,56.45 R391.2 ; v1(68.95,39.53) 68.72,39.76 J33.26
MIPI_TRST#_R: length 5.3
  BOTTOM w0.147: J33.8 64.22,39.42 65.88,37.76 66.21,37.76 66.76,37.21 R448.2
MMC0_CALPAD: length 22.4
  TOP w0.147: U23.F18 v1(95.46,71.1)
  L03_SIG1 w0.091: v1(95.46,71.1) 95.86,71.5 96.42,71.5 96.66,71.26 96.66,70.94 96.9,70.7 97.22,70.7 97.46,70.47 97.46,70.14 97.28,69.96 97.28,66.77 100.2,63.85 100.2,62.57 105.54,57.23 v1(105.54,55.77)
  BOTTOM w0.147: R405.1 v1(105.54,55.77)
MMC0_CLK: length 38.3
  TOP w0.147: U44.M6 118.12,35.1 v1(118.37,35.35) ; R644.1 v1(104.27,53.35)
  L03_SIG1 w0.091: v1(118.37,35.35) 118.82,34.9 120.1,34.9 121.17,35.96 121.17,45.5 117.35,49.31 117.35,49.43 117.48,49.56 117.48,49.67 117.4,49.75 117.29,49.75 117.16,49.62 117.04,49.62 116.96,49.7 116.96,49.81 117.1,49.95 117.1,50.06 117.02,50.14 116.9,50.14 116.77,50.01 116.66,50.01 116.58,50.09 116.58,50.2 116.71,50.33 116.71,50.45 116.63,50.53 116.51,50.53 116.38,50.4 116.27,50.4 116.19,50.48 116.19,50.59 116.32,50.72 116.32,50.84 116.24,50.92 116.13,50.92 115.99,50.78 115.88,50.78 115.8,50.86 115.8,50.98 115.93,51.11 115.93,51.22 115.85,51.3 115.74,51.3 115.61,51.17 115.49,51.17 115.28,51.38 106.24,51.38 v1(104.27,53.35)
  BOTTOM w0.147: R456.2 118.3,35.28 v1(118.37,35.35) ; R644.1 v1(104.27,53.35)
MMC0_DS: length 3
  TOP w0.147: U44.H5 117.37,36.85 v1(117.12,37.1)
  BOTTOM w0.147: v1(117.12,37.1) R444.2 R446.2
MMC0_VCTRL_TP: length 5.5
  TOP w0.147: U23.F17 v1(95.46,71.9)
  BOTTOM w0.114: TP74.1 95.83,67.98 95.83,69.29 95.06,70.06 95.06,71.5 v1(95.46,71.9)
MMC1_CLK: length 100.6
  TOP w0.147: U49.1 v1(47.38,29.22) 47.38,28 46.57,27.19 42.29,27.19 41.78,27.7 40.65,27.7 40.1,27.15 v1(40.1,25.38)
  BOTTOM w0.147: v1(47.38,29.22) 48.14,29.98 R646.2 48.14,30.24 47.37,31.01 47.37,37.87 50.9,41.4 55.63,41.4 57.02,40.01 57.35,40.01 57.78,39.58 58.63,39.58 61.93,36.29 61.93,35.15 62.68,34.39 69.99,34.39 69.99,34.39 70.16,34.39 70.97,35.2 71.32,35.2 71.44,35.08 71.44,34.5 71.56,34.39 71.73,34.39 71.84,34.5 71.84,35.08 71.96,35.2 72.13,35.2 72.24,35.08 72.24,34.5 72.36,34.39 72.53,34.39 72.65,34.5 72.65,35.08 72.76,35.2 72.93,35.2 73.05,35.08 73.05,34.5 73.16,34.39 73.33,34.39 73.45,34.5 73.45,35.08 73.57,35.2 73.73,35.2 73.85,35.08 73.85,34.5 73.97,34.39 74.13,34.39 74.25,34.5 74.25,35.08 74.37,35.2 74.53,35.2 74.65,35.08 74.65,34.5 74.77,34.39 74.94,34.39 75.05,34.5 75.05,35.08 75.17,35.2 75.76,35.2 75.88,35.31 75.88,35.59 76,35.7 76.16,35.7 76.28,35.59 76.28,35.31 76.4,35.2 76.57,35.2 76.68,35.31 76.68,35.59 76.8,35.7 76.97,35.7 77.08,35.59 77.08,35.31 77.2,35.2 77.37,35.2 77.49,35.31 77.49,35.59 77.6,35.7 77.77,35.7 77.89,35.59 77.89,35.31 78,35.2 78.17,35.2 78.29,35.31 78.29,35.59 78.41,35.7 78.57,35.7 78.69,35.59 78.69,35.31 78.81,35.2 82.55,35.2 88.66,41.31 88.66,48.22 89.84,49.4 89.84,50.83 94.67,55.66 R645.1 R389.1 ; J37.5 v1(40.1,25.38)
