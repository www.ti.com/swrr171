# Allegro board PROC101B_BRD.brd (continued)
## Nets (continued)
DDR_VTT_EN_3V3: R29.1 TP7.1(TP) U10.8(B1) U68.7(S3) U68.9(S5)
DEBOUNCE_GPIO_SOC/MCU: C465.2 D8.2 Q17.2(S) R534.1 SW5.1 SW5.2 U50.3(2A)
DEBOUNCE_MCU_RESETZ: C466.2 D9.2 Q8.2(S) R536.1 SW6.1 SW6.2 U50.1(1A)
DEBOUNCE_WARM_RST: C467.2 D11.2 Q10.2(S) R537.1 SW4.1 SW4.2 U50.6(3A)
DEMB: R693.2 R694.1 U30.33(DEMB)
DIR: R355.1 R356.2 U79.2(DIR) U81.2(DIR)
DISPLAY_VDDB3V3_ON: R538.2 U99.4(ON)
EEPROM_A1: R26.2 R27.2 U7.2(A1)
EEPROM_A2: R17.2 R18.2 U7.3(A2)
EEPROM_WP: R25.2 U7.7(WP)
EMMC_RSTN: R193.2 U44.K5(RST_N) U54.4(Y)
EXP_BRD_DET_INTN: R226.1 U66.13(I\N\T\)
FSI_FET_ENN: R21.1 U8.17(E\N\)
FSI_FET_SEL: R218.1 U8.11(IN2) U8.21(IN1) U91.8(P07)
FSI_RX0_CLK: J7.1 U8.8(NO1)
FSI_RX0_D0: J7.5 U8.10(NO2)
FSI_RX0_D1: J7.7 U8.12(NO3)
FSI_TX0_CLK: J7.2 U8.13(NO6)
FSI_TX0_D0: J7.6 U8.14(NO4)
FSI_TX0_D1: J7.8 U8.15(NO5)
FT4232_DO: R191.1 R192.2 U92.4(DO)
FT4232_EECLK: R186.1 U87.62(EECLK) U92.2(CLK)
FT4232_EECS: R463.1 U87.63(EECS) U92.1(CS)
FT4232_EEDATA: R192.1 U87.61(EEDATA) U92.3(DI)
FT4232_MCU_UART0_CTS_3V3: U82.12(2B2) U87.28(BDBUS2)
FT4232_MCU_UART0_RTS_3V3: U82.14(1B2) U87.29(BDBUS3)
FT4232_MCU_UART0_RX_3V3: U82.13(2B1) U87.26(BDBUS0)
FT4232_MCU_UART0_TX_3V3: U82.15(1B1) U87.27(BDBUS1)
FT4232_REF: R175.2 U87.6(REF)
FT4232_RESET: C416.2 R417.1 U87.14(R\E\S\E\T\)
FT4232_UART0_CTS_3V3: U84.12(2B2) U87.18(ADBUS2)
FT4232_UART0_RTS_3V3: U84.14(1B2) U87.19(ADBUS3)
FT4232_UART0_RX_3V3: U84.13(2B1) U87.16(ADBUS0)
FT4232_UART0_TX_3V3: U84.15(1B1) U87.17(ADBUS1)
FT4232_UART1_RX_3V3: U87.38(CDBUS0) U89.13(2B1)
FT4232_UART1_TX_3V3: U87.39(CDBUS1) U89.15(1B1)
FT4232_UART3_RX_3V3: U87.48(DDBUS0) U89.12(2B2)
FT4232_UART3_TX_3V3: U87.52(DDBUS1) U89.14(1B2)
FT4232_USB_DM: J26.2(D-) U42.5(IO4) U87.7(DM)
FT4232_USB_DP: J26.3(D+) U42.4(IO3) U87.8(DP)
FT4232_USB_VBUS: C152.2 C154.2 D6.2 J26.1(VBUS) U42.6(VCC) U43.4(EN) U43.6(IN)
FT_PWREN#: R464.1 U87.60(P\W\R\E\N\)
GPIO1_43_INTN: R471.2 U23.C13(SPI0_CS1)
GPIO_CPSW1_RST: R241.1 R242.1 U69.1(A) U91.3(P02)
GPIO_EMMC_RSTN: R196.1 U54.1(A) U91.1(P00)
GPIO_OLED_RESETN: J36.6 R531.2 U91.15(P16)
GPIO_OSPI_RSTN: R429.1 U23.K17(OSPI0_CSN2) U85.1(A)
GPIO_PCIE_RST_OUT: R424.2 R430.1 U88.1(A) U91.6(P05)
GPIO_RGMII1_RST: R300.1 R301.1 U19.1(A) U91.4(P03)
GPIO_RGMII2_RST: R371.1 R380.1 U31.1(A) U91.5(P04)
GPIO_SOC/MCU: R470.1 R471.1 U50.5(2Y)
GPMC0_AD0: J2.E14 RA1.9
GPMC0_AD1: J2.D14 RA1.10
GPMC0_AD2: J2.C14 RA1.11
GPMC0_AD3: J2.E15 RA1.12
GPMC0_AD4: J2.D15 RA1.13
GPMC0_AD5: J2.C15 RA1.14
GPMC0_AD6: J2.E17 RA1.15
GPMC0_AD7: J2.D17 RA1.16
GPMC0_AD8: J2.A22 U8.23(NC1)
GPMC0_AD8/FSI_RX0_CLK: RA3.9 U8.1(COM1)
GPMC0_AD9: J2.A21 U8.22(NC2)
GPMC0_AD9/FSI_RX0_D0: RA3.10 U8.3(COM2)
GPMC0_AD10: J2.B21 U8.20(NC3)
GPMC0_AD10/FSI_RX0_D1: RA3.11 U8.4(COM3)
GPMC0_AD11: J2.E21 RA3.12
GPMC0_AD12: J2.C21 RA3.13
GPMC0_AD13: J2.D21 RA3.14
GPMC0_AD14: J2.B20 U8.18(NC4)
GPMC0_AD14/FSI_TX0_D0: RA3.15 U8.6(COM4)
GPMC0_AD15: J2.A19 U8.16(NC5)
GPMC0_AD15/FSI_TX0_D1: RA3.16 U8.7(COM5)
GPMC0_ADVN_ALE: RA5.7 RA6.2 U23.P16(GPMC0_ADVN_ALE)
GPMC0_BE0N_CLE: RA5.4 RA6.5 U23.P17(GPMC0_BE0N_CLE)
GPMC0_BE1N: RA5.3 RA6.6 U23.T19(GPMC0_BE1N)
GPMC0_CLK: RA5.8 RA6.1 U23.R17(GPMC0_CLK)
GPMC0_CSN0: R390.1 R391.1 U23.R19(GPMC0_CSN0)
GPMC0_CSN1: J2.E19 U23.R20(GPMC0_CSN1)
GPMC0_CSN2: J2.D18 U23.P19(GPMC0_CSN2)
GPMC0_CSN3: J2.D19 U23.R21(GPMC0_CSN3)
GPMC0_DIR: J2.E18 U23.N17(GPMC0_DIR)
GPMC0_OEN_REN: RA5.6 RA6.3 U23.R18(GPMC0_OEN_REN)
GPMC0_WAIT0: RA5.2 RA6.7 U23.W19(GPMC0_WAIT0)
GPMC0_WAIT1: RA5.1 RA6.8 U23.Y18(GPMC0_WAIT1)
GPMC0_WEN: RA5.5 RA6.4 U23.T21(GPMC0_WEN)
GPMC0_WPN: R392.1 R393.1 U23.N16(GPMC0_WPN)
HSE_DETECT: J2.E4 R224.1 U66.4(P0)
HSE_GPIO0_31: J2.B22 RA5.9
HSE_GPIO0_32: J2.C22 RA5.10
HSE_GPIO0_33: J2.D22 RA5.11
HSE_GPIO0_34: J2.C23 RA5.12
HSE_GPIO0_35: J2.B24 RA5.13
HSE_GPIO0_36: J2.A20 U8.19(NC6)
HSE_GPIO0_36/FSI_TX0_CLK: RA5.14 U8.9(COM6)
HSE_GPIO0_37: J2.C24 RA5.15
HSE_GPIO0_38: J2.E26 RA5.16
HSE_GPIO0_39: J2.C26 R393.2
HSE_GPIO0_41: J2.D26 R390.2
HSE_MCAN0_RX/UART4_TXD: J2.E24 U67.3(1B2)
HSE_MCAN0_TX/UART4_RXD: J2.D24 U67.6(2B2)
HSE_MCAN1_RX/I2C3_SDA: J2.C29 U67.10(3B2)
HSE_MCAN1_TX/I2C3_SCL: J2.D29 U67.13(4B2)
HSE_PRG0_PRU0_GPO9: J2.D28 U75.33(C4)
HSE_PRG0_PRU0_GPO10: J2.B29 U75.31(C5)
HSE_PRG0_PRU1_GPO7: J2.D23 U75.42(C0)
HSE_PRG0_PRU1_GPO9: J2.E23 U75.40(C1)
HSE_PRG0_PRU1_GPO10: J2.E27 U75.37(C2)
HSE_PRG0_PRU1_GPO17: J2.C28 U75.35(C3)
IFORCE: TP71.1(TP) U23.H16(IFORCE)
IN_SEL0: R40.2 R248.2 U70.30(IN_SEL0)
IN_SEL1: R45.1 R253.1 U70.29(IN_SEL1)
INA_ALERT: J4.4 R1.2 R28.2 R43.2 R47.1 R48.2 R122.2 R244.2
IO_EXP_INTN_SDIO: R465.1 U23.C20(MMC1_SDWP) U91.32(I\N\T\)
JTAG_CTI_RTCK: J25.9 R491.1 R636.1 R637.1
JTAG_CTI_TCK: J25.11 R188.1 R190.1 U53.2(B) U93.2(B)
JTAG_DIR: R148.2 U37.2(1DIR) U37.3(2DIR)
JTAG_EMU0: J25.13 R455.2 U45.8(B1) U48.8(B1)
JTAG_EMU1: J25.14 R458.2 U45.1(B2) U48.1(B2)
JTAG_EMU_RSTN: J25.15 R150.2 R449.1 U41.6(C)
JTAG_MIPI_EMU0: J33.38 R461.2 U48.5(A1)
JTAG_MIPI_EMU1: J33.40 R460.2 U48.4(A2)
JTAG_MIPI_RTCK: J33.7 R492.1 R638.1 R639.1
JTAG_MIPI_TCK: J33.3 R187.1 R189.1 U52.2(B) U94.2(B)
JTAG_MUX_SEL: J29.2 U60.1(S)
JTAG_TCK: R640.2 U37.12(1B2) U60.4(1A)
JTAG_TDI: J25.3 R410.2 R642.2 U37.10(2B2)
JTAG_TDIS: J25.4 R177.2
JTAG_TDO: J25.7 R450.1 U46.7(B1)
JTAG_TMS: J25.1 R451.1 R641.2 U37.11(2B1)
JTAG_TRST#: C529.2 R448.1 R643.2 R685.2 U37.13(1B1)
LED1: LD16.1(CATHODE) U34.3(DRAIN0)
LED2: LD17.1(CATHODE) U34.4(DRAIN1)
LED3: LD18.1(CATHODE) U34.5(DRAIN2)
LED4: LD19.1(CATHODE) U34.6(DRAIN3)
LED5: LD14.1(CATHODE) U34.11(DRAIN4)
LED6: LD13.1(CATHODE) U34.12(DRAIN5)
LED7: LD12.1(CATHODE) U34.13(DRAIN6)
LED8: LD11.1(CATHODE) U34.14(DRAIN7)
LM5140_COMP1: C135.2 R142.1 U30.29(COMP1)
LM5140_COMP2: C130.1 R141.2 U30.2(COMP2)
MAIN: F1.1 J6.1
MCAN0_H: J31.1 R4.1 U4.7(CANH)
MCAN0_L: J31.3 R5.2 U4.6(CANL)
MCAN0_RX: J9.1 R220.1 U67.2(1B1)
MCAN0_RX/HSE: U23.B17(MCAN0_RX) U67.4(1A)
MCAN0_STB_3V3: R9.2 U4.8(STB) U91.9(P10)
MCAN0_T: C2.1 R4.2 R5.1
MCAN0_TX: J9.2 R221.1 U67.5(2B1)
MCAN0_TX/HSE: U23.A17(MCAN0_TX) U67.7(2A)
MCAN1_H: J32.1 R2.1 U3.7(CANH)
MCAN1_L: J32.3 R3.2 U3.6(CANL)
MCAN1_RX: J10.1 R222.1 U67.11(3B1)
MCAN1_RX/HSE: U23.D17(MCAN1_RX) U67.9(3A)
MCAN1_STB_3V3: R8.2 U3.8(STB) U91.10(P11)
MCAN1_T: C1.1 R2.2 R3.1
MCAN1_TX: J10.2 R223.1 U67.14(4B1)
MCAN1_TX/HSE: U23.C17(MCAN1_TX) U67.12(4A)
MCU_GPIO0_6: J1.8 R470.2 U23.B7(MCU_SPI1_CS1)
MCU_GPIO0_7: J1.9 U23.D7(MCU_SPI1_CLK)
MCU_GPIO0_8: J1.5 U23.C7(MCU_SPI1_D0)
MCU_GPIO0_9: J1.12 U23.C8(MCU_SPI1_D1)
MCU_I2C0_SCL: J1.20 R311.2 R593.1
MCU_I2C0_SCL_RC: C487.1 R593.2 U23.E9(MCU_I2C0_SCL)
MCU_I2C0_SDA: J1.17 R309.2 R594.1
MCU_I2C0_SDA_RC: C488.1 R594.2 U23.A10(MCU_I2C0_SDA)
MCU_I2C1_SCL: J1.18 R306.2 U23.A11(MCU_I2C1_SCL)
MCU_I2C1_SDA: J1.14 R303.2 U23.B10(MCU_I2C1_SDA)
MCU_OSC0_XI: R137.2 R138.2 U23.C21(MCU_OSC0_XI)
MCU_OSC0_XO: R139.2 R140.2 U23.B20(MCU_OSC0_XO)
MCU_PORZ: J2.E30 R575.2 R606.1 TP33.1(TP) U23.B21(MCU_PORZ) U35.4(Y)
MCU_RESETSTATZ: J1.19 J2.E3 TP1.1(TP) U23.B13(MCU_RESETSTATZ)
MCU_RESETZ: J2.D3 R477.2 TP46.1(TP) U23.B12(MCU_RESETZ) U50.7(1Y)
MCU_SAFETY_ERRORZ_1V8: TP72.1(TP) U10.4(A2) U23.A20(MCU_SAFETY_ERRORN)
MCU_SAFETY_ERRORZ_3V3: J1.22 U10.1(B2)
MCU_SPI0_CLK: J1.16 R302.1
MCU_SPI0_CLK_R: R302.2 U23.E6(MCU_SPI0_CLK)
MCU_SPI0_CS0: J1.6 U23.D6(MCU_SPI0_CS0)
MCU_SPI0_CS1: J1.3 U23.C6(MCU_SPI0_CS1)
MCU_SPI0_D0: J1.4 U23.E7(MCU_SPI0_D0)
MCU_SPI0_D1: J1.2 U23.B6(MCU_SPI0_D1)
MCU_UART0_CTS_3V3: U23.D8(MCU_UART0_CTSN) U82.9(2A2)
MCU_UART0_RTS_3V3: U23.E8(MCU_UART0_RTSN) U82.7(1A2)
MCU_UART0_RX_3V3: U23.A9(MCU_UART0_RXD) U82.8(2A1)
MCU_UART0_TX_3V3: R611.2 U23.A8(MCU_UART0_TXD) U82.6(1A1)
MCU_UART1_CTS_3V3: J1.10 U23.B8(MCU_UART1_CTSN)
MCU_UART1_RTS_3V3: J1.13 U23.B9(MCU_UART1_RTSN)
MCU_UART1_RX_3V3: J1.11 U23.C9(MCU_UART1_RXD)
MCU_UART1_TX_3V3: J1.15 U23.D9(MCU_UART1_TXD)
MIPI_TCK: R194.1 U60.2(1B1)
MIPI_TDI_R: J33.5 R410.1
MIPI_TDO_R: J33.4 R450.2
MIPI_TMS_R: J33.2 R451.2
MIPI_TRC_CLK: J33.13 RA2.16
MIPI_TRC_CTL: J33.17 RA2.15
MIPI_TRC_DAT00: J33.19 RA2.14
MIPI_TRC_DAT01: J33.21 RA2.13
MIPI_TRC_DAT02: J33.23 RA2.12
MIPI_TRC_DAT03: J33.25 RA2.11
MIPI_TRC_DAT04: J33.27 RA2.10
MIPI_TRC_DAT05: J33.29 RA2.9
MIPI_TRC_DAT06: J33.31 RA4.16
MIPI_TRC_DAT07: J33.33 RA4.15
MIPI_TRC_DAT08: J33.35 RA4.14
MIPI_TRC_DAT09: J33.37 RA4.13
MIPI_TRC_DAT10: J33.39 RA4.12
MIPI_TRC_DAT11: J33.41 RA4.11
MIPI_TRC_DAT12: J33.43 RA4.10
MIPI_TRC_DAT13: J33.45 RA4.9
MIPI_TRC_DAT14: J33.47 RA6.16
MIPI_TRC_DAT15: J33.49 RA6.15
MIPI_TRC_DAT16: J33.51 RA6.14
MIPI_TRC_DAT17: J33.53 RA6.13
MIPI_TRC_DAT18: J33.55 RA6.12
MIPI_TRC_DAT19: J33.18 RA6.11
MIPI_TRC_DAT20: J33.20 RA6.10
MIPI_TRC_DAT21: J33.22 RA6.9
MIPI_TRC_DAT22: J33.24 R392.2
MIPI_TRC_DAT23: J33.26 R391.2
MIPI_TRST#_R: J33.8 R448.2
MMC0_CALPAD: R405.1 U23.F18(MMC0_CALPAD)
MMC0_CLK: R404.1 R456.2 R644.1 U44.M6(CLK)
MMC0_DS: R444.2 R446.2 U44.H5(DS)
MMC0_VCTRL_TP: TP74.1(TP) U23.F17(MMC0_VCTRL_TP)
MMC1_CLK: J37.5(CLK) R389.1 R645.1 R646.2 U49.1(IO1)
MMC1_CLK_R: R389.2 U23.L20(MMC1_CLK)
MMC1_CMD: J37.3(CMD) R485.2 U23.J19(MMC1_CMD) U49.2(IO2)
MMC1_D0: J37.7(DAT0) R479.2 U23.K21(MMC1_DAT0) U49.8(IO6)
MMC1_D1: J37.8(DAT1) R480.2 U23.L21(MMC1_DAT1) U49.7(IO5)
MMC1_D2: J37.1(DAT2) R483.2 U23.K19(MMC1_DAT2) U49.6(IO4)
MMC1_D3: J37.2(CD/DAT3) R484.2 U23.K18(MMC1_DAT3) U49.3(IO3)
MMC1_SD_EN: R416.1 U86.1(A) U91.7(P06)
MMC1_SD_LS_EN: R426.2 U39.3(ON) U86.4(Y)
MMC1_SDCD: J37.9(CD1) R481.2 U23.D19(MMC1_SDCD)
OSC0: C177.2 U59.88(OSC0) Y2.1
OSC1: C172.2 U59.89(OSC1) Y2.3
OSPI0_CSN0: R422.2 U23.L19(OSPI0_CSN0)
OSPI0_LBCLK: R591.1 R600.2
OSPI_CLK: R157.1 R167.1 U23.N20(OSPI0_CLK)
OSPI_CS: R168.1 R422.1 U40.C2(CS#)
OSPI_DQ0: R181.2 R440.1 U40.D3(DQ0)
OSPI_DQ1: R176.2 R433.1 U40.D2(DQ1)
OSPI_DQ2: R169.2 R423.1 U40.C4(DQ2)
OSPI_DQ3: R172.2 R425.1 U40.D4(DQ3)
OSPI_DQ4: R173.2 R432.1 U40.D5(DQ4)
OSPI_DQ5: R180.2 R441.1 U40.E3(DQ5)
OSPI_DQ6: R179.2 R442.1 U40.E2(DQ6)
OSPI_DQ7: R178.2 R443.1 U40.E1(DQ7)
OSPI_DQS: R152.1 R154.1 R155.2 U40.C3(DS)
OSPI_DQS_SOC: R152.2 R600.1 U23.N19(OSPI0_DQS)
OSPI_INTN: R156.1 R158.2 U23.L17(OSPI0_CSN3)
OSPI_RSTN: R414.1 U40.A4(RESET#) U85.4(Y)
PCIE_CLKREQN: J27.B12(RSVD4) R482.1
PCIE_MCU_PORZ: J34.3 R576.2 U35.6(C)
PCIE_PRSNT1#: J27.A1(PRSNT1#) J35.3 R437.2
PCIE_PRSNT2#_1: J27.B17(PRSNT2#_1) J35.2
PCIE_PRSNT2N: J35.1 R431.2
PCIE_RESET_OUTN: J34.1 U88.4(Y)
PCIE_RESETN: J27.A11(PERST#) J34.2
PCIE_SERDES_REFCLK0_N: J27.A14(REFCLK-) R665.1 R667.2
PCIE_SERDES_REFCLK0_P: J27.A13(REFCLK+) R666.1 R668.2
PCIE_TCK: J27.A5(JTAG2) TP85.1(TP)
PCIE_TDI: J27.A6(JTAG3) TP83.1(TP)
PCIE_TDO: J27.A7(JTAG4) TP95.1(TP)
PCIE_TMS: J27.A8(JTAG5) TP84.1(TP)
PCIE_TRSTN: J27.B9(JTAG1) TP94.1(TP)
PCIE_WAKEN: J27.B11(WAKE#) R486.1
PORZ: R171.2 R574.2 TP32.1(TP) U35.1(A)
PORZ_OUT: R348.2 R434.2 TP82.1(TP) U19.2(B) U23.E17(PORZ_OUT) U31.2(B) U69.2(B) U86.6(C)
PRG0_HSE_ETH1_CLK: J2.A17 R236.2
PRG0_HSE_ETH2_CLK: J2.B17 R235.2
PRG0_MDIO0_MDC: J2.A5 U23.P3(PRG0_MDIO0_MDC)
PRG0_MDIO0_MDIO: J2.A4 R19.1 U23.P2(PRG0_MDIO0_MDIO)
PRG0_PRU0_GPO9/CPSW_RGMII1_RX_C: U23.W6(PRG0_PRU0_GPO9) U75.6(A4)
PRG0_PRU0_GPO10/CPSW_RGMII1_RXC: U23.AA5(PRG0_PRU0_GPO10) U75.7(A5)
PRG0_PRU0GPO0: J2.B12 U23.Y1(PRG0_PRU0_GPO0)
PRG0_PRU0GPO1: J2.E8 U23.R4(PRG0_PRU0_GPO1)
PRG0_PRU0GPO2: J2.A8 U23.U2(PRG0_PRU0_GPO2)
PRG0_PRU0GPO3: J2.A9 U23.V2(PRG0_PRU0_GPO3)
PRG0_PRU0GPO4: J2.A13 U23.AA2(PRG0_PRU0_GPO4)
PRG0_PRU0GPO5: J2.C6 U23.R3(PRG0_PRU0_GPO5)
PRG0_PRU0GPO6: J2.D8 U23.T3(PRG0_PRU0_GPO6)
PRG0_PRU0GPO7: J2.B7 U23.T1(PRG0_PRU0_GPO7)
PRG0_PRU0GPO8: J2.A7 U23.T2(PRG0_PRU0_GPO8)
PRG0_PRU0GPO11: J2.B14 U23.Y3(PRG0_PRU0_GPO11)
PRG0_PRU0GPO12: J2.A14 U23.AA3(PRG0_PRU0_GPO12)
PRG0_PRU0GPO13: J2.C5 U23.R6(PRG0_PRU0_GPO13)
PRG0_PRU0GPO14: J2.C9 U23.V4(PRG0_PRU0_GPO14)
PRG0_PRU0GPO15: J2.D12 U23.T5(PRG0_PRU0_GPO15)
PRG0_PRU0GPO16: J2.E9 U23.U4(PRG0_PRU0_GPO16)
PRG0_PRU0GPO17: J2.B8 U23.U1(PRG0_PRU0_GPO17)
PRG0_PRU0GPO18: J2.B9 U23.V1(PRG0_PRU0_GPO18)
PRG0_PRU0GPO19: J2.B11 U23.W1(PRG0_PRU0_GPO19)
PRG0_PRU1_GPO7/CPSW_RGMII1_RD0: U23.W5(PRG0_PRU1_GPO7) U75.2(A0)
PRG0_PRU1_GPO9/CPSW_RGMII1_RD1: U23.Y5(PRG0_PRU1_GPO9) U75.3(A1)
PRG0_PRU1_GPO10/CPSW_RGMII1_RD2: U23.V6(PRG0_PRU1_GPO10) U75.4(A2)
PRG0_PRU1_GPO17/CPSW_RGMII1_RD3: U23.V5(PRG0_PRU1_GPO17) U75.5(A3)
PRG0_PRU1GPO0: J2.A12 U23.Y2(PRG0_PRU1_GPO0)
PRG0_PRU1GPO1: J2.A11 U23.W2(PRG0_PRU1_GPO1)
PRG0_PRU1GPO2: J2.D9 U23.V3(PRG0_PRU1_GPO2)
PRG0_PRU1GPO3: J2.C8 U23.T4(PRG0_PRU1_GPO3)
PRG0_PRU1GPO4: J2.B13 U23.W3(PRG0_PRU1_GPO4)
PRG0_PRU1GPO5: J2.D6 U23.P4(PRG0_PRU1_GPO5)
PRG0_PRU1GPO6: J2.E11 U23.R5(PRG0_PRU1_GPO6)
PRG0_PRU1GPO8: J2.B4 U23.R1(PRG0_PRU1_GPO8)
PRG0_PRU1GPO11: J2.D11 U23.W4(PRG0_PRU1_GPO11)
PRG0_PRU1GPO12: J2.B15 U23.Y4(PRG0_PRU1_GPO12)
PRG0_PRU1GPO13: J2.D5 U23.T6(PRG0_PRU1_GPO13)
PRG0_PRU1GPO14: J2.E12 U23.U6(PRG0_PRU1_GPO14)
PRG0_PRU1GPO15: J2.C11 U23.U5(PRG0_PRU1_GPO15)
PRG0_PRU1GPO16: J2.A15 U23.AA4(PRG0_PRU1_GPO16)
PRG1_ETH2_D0M: J21.B2(TD1-_2) U80.2(TD_M_A)
PRG1_ETH2_D0P: J21.B1(TD1+_2) U80.1(TD_P_A)
PRG1_ETH2_D1M: J21.B4(TD2-_2) U80.5(TD_M_B)
PRG1_ETH2_D1P: J21.B3(TD2+_2) U80.4(TD_P_B)
PRG1_ETH2_D2M: J21.B6(TD3-_2) U80.8(TD_M_C)
PRG1_ETH2_D2P: J21.B5(TD3+_2) U80.7(TD_P_C)
PRG1_ETH2_D3M: J21.B8(TD4-_2) U80.11(TD_M_D)
PRG1_ETH2_D3P: J21.B7(TD4+_2) U80.10(TD_P_D)
PRG1_ETH2_GPIO_1: R340.2 R341.1 R617.2 U80.22(JTAG_TDO/GPIO_1)
PRG1_ETH2_LED1: J21.B11 Q14.3(D)
PRG1_ETH2_LED2: J21.B14 Q21.3(D) R616.1
PRG1_ETH2_LED3: J21.B13 Q16.3(D) R615.1
PRG1_ETH2_LED_1000/RX_ER: R343.2 R386.1 R388.2 U23.AA13(PRG1_PRU1_GPO5) U80.46(LED_1/RX_ER)
PRG1_ETH2_LED_ACT: R324.1 R385.1 R387.2 U80.45(LED_2/GPIO_0)
PRG1_ETH2_LED_LINK: R562.2 R563.1 U23.U12(PRG1_PRU1_GPO8) U80.47(LED_0)
PRG1_ETH3_D0M: J21.A2(TD1-_1) U20.2(TD_M_A)
PRG1_ETH3_D0P: J21.A1(TD1+_1) U20.1(TD_P_A)
PRG1_ETH3_D1M: J21.A4(TD2-_1) U20.5(TD_M_B)
PRG1_ETH3_D1P: J21.A3(TD2+_1) U20.4(TD_P_B)
PRG1_ETH3_D2M: J21.A6(TD3-_1) U20.8(TD_M_C)
PRG1_ETH3_D2P: J21.A5(TD3+_1) U20.7(TD_P_C)
PRG1_ETH3_D3M: J21.A8(TD4-_1) U20.11(TD_M_D)
PRG1_ETH3_D3P: J21.A7(TD4+_1) U20.10(TD_P_D)
PRG1_ETH3_GPIO_1: R114.2 R115.1 R614.2 U20.22(JTAG_TDO/GPIO_1)
PRG1_ETH3_LED1: J21.A11 Q15.3(D)
PRG1_ETH3_LED2: J21.A14 Q20.3(D) R613.1
PRG1_ETH3_LED3: J21.A13 Q4.3(D) R612.1
PRG1_ETH3_LED_1000/RX_ER: R94.2 R96.1 R99.2 U20.46(LED_1/RX_ER) U23.V13(PRG1_PRU0_GPO5)
PRG1_ETH3_LED_ACT: R95.2 R97.1 R334.1 U20.45(LED_2/GPIO_0)
PRG1_ETH3_LED_LINK: R564.2 R565.1 U20.47(LED_0) U23.W13(PRG1_PRU0_GPO8)
PRG1_IEP0_EDC_LATCH_IN0: J17.1 U23.V7(PRG1_PRU0_GPO18)
PRG1_IEP0_EDC_LATCH_IN1: J15.1 U23.U13(PRG1_PRU0_GPO7)
PRG1_IEP0_EDC_SYNC_OUT0: J18.1 U23.W7(PRG1_PRU0_GPO19)
PRG1_IEP0_EDC_SYNC_OUT2: J16.1 U23.U7(PRG1_PRU0_GPO17)
PRG1_MDIO_MDC: R104.2 TP21.1(TP) U20.42(MDC) U23.Y6(PRG1_MDIO0_MDC) U27.8(B0)
PRG1_MDIO_MDIO: R103.1 TP22.1(TP) U20.41(MDIO) U23.AA6(PRG1_MDIO0_MDIO) U27.2(A0)
PRG1_PRU1GPO18: J2.E13 U23.Y13(PRG1_PRU1_GPO18)
PRG1_PRU1GPO19: J2.C12 U23.V12(PRG1_PRU1_GPO19)
PRG1_RGMII1_ETH3_CLK: R237.2 U20.20(XI)
PRG1_RGMII1_ETH3_CLK_OUT: TP17.1(TP) U20.40(CLK_OUT)
PRG1_RGMII1_ETH3_RBIAS: R110.2 U20.12(RBIAS)
PRG1_RGMII1_RD0: R108.1 R310.2 U20.33(RX_D0) U23.Y7(PRG1_PRU0_GPO0)
PRG1_RGMII1_RD1: R107.1 R308.2 U20.34(RX_D1) U23.U8(PRG1_PRU0_GPO1)
PRG1_RGMII1_RD2: U20.35(RX_D2) U23.W8(PRG1_PRU0_GPO2)
PRG1_RGMII1_RD3: U20.36(RX_D3) U23.V8(PRG1_PRU0_GPO3)
PRG1_RGMII1_RESETN: R102.1 U19.4(Y) U20.43(RESET_N)
PRG1_RGMII1_RX_CTL: R100.1 R101.2 U20.38(RX_CTRL/RX_DV) U23.Y8(PRG1_PRU0_GPO4)
PRG1_RGMII1_RXC: U20.32(RX_CLK) U23.AA7(PRG1_PRU0_GPO6)
PRG1_RGMII1_TD0: U20.28(TX_D0) U23.AA8(PRG1_PRU0_GPO11)
PRG1_RGMII1_TD1: U20.27(TX_D1) U23.U9(PRG1_PRU0_GPO12)
PRG1_RGMII1_TD2: U20.26(TX_D2) U23.W9(PRG1_PRU0_GPO13)
PRG1_RGMII1_TD3: U20.25(TX_D3) U23.AA9(PRG1_PRU0_GPO14)
PRG1_RGMII1_TX_CTL: U20.37(TX_CTRL/TX_EN) U23.Y9(PRG1_PRU0_GPO15)
PRG1_RGMII1_TXC: U20.29(GTX_CLK/TX_CLK) U23.V9(PRG1_PRU0_GPO16)
PRG1_RGMII2_ETH2_CLK: R238.2 U80.20(XI)
PRG1_RGMII2_ETH2_CLK_OUT: TP78.1(TP) U80.40(CLK_OUT)
PRG1_RGMII2_ETH2_RBIAS: R349.2 U80.12(RBIAS)
PRG1_RGMII2_FET_ENN: R121.1 U27.9(E\N\)
PRG1_RGMII2_FET_SEL: R120.1 U27.1(SEL) U91.13(P14)
PRG1_RGMII2_MDC: R369.2 U27.6(B) U80.42(MDC)
PRG1_RGMII2_MDIO: R370.1 U27.4(A) U80.41(MDIO)
PRG1_RGMII2_RD0: R126.2 R359.1 U23.W11(PRG1_PRU1_GPO0) U80.33(RX_D0)
PRG1_RGMII2_RD1: R128.2 R363.1 U23.V11(PRG1_PRU1_GPO1) U80.34(RX_D1)
PRG1_RGMII2_RD2: U23.AA12(PRG1_PRU1_GPO2) U80.35(RX_D2)
PRG1_RGMII2_RD3: U23.Y12(PRG1_PRU1_GPO3) U80.36(RX_D3)
PRG1_RGMII2_RESETN: R367.1 U31.4(Y) U80.43(RESET_N)
PRG1_RGMII2_RX_CTL: R135.1 R366.2 U23.W12(PRG1_PRU1_GPO4) U80.38(RX_CTRL/RX_DV)
PRG1_RGMII2_RXC: U23.U11(PRG1_PRU1_GPO6) U80.32(RX_CLK)
PRG1_RGMII2_TD0: U23.AA10(PRG1_PRU1_GPO11) U80.28(TX_D0)
PRG1_RGMII2_TD1: U23.V10(PRG1_PRU1_GPO12) U80.27(TX_D1)
PRG1_RGMII2_TD2: U23.U10(PRG1_PRU1_GPO13) U80.26(TX_D2)
PRG1_RGMII2_TD3: U23.AA11(PRG1_PRU1_GPO14) U80.25(TX_D3)
PRG1_RGMII2_TX_CTL: U23.Y11(PRG1_PRU1_GPO15) U80.37(TX_CTRL/TX_EN)
PRG1_RGMII2_TXC: U23.Y10(PRG1_PRU1_GPO16) U80.29(GTX_CLK/TX_CLK)
PRG1_RGMII_INTN: R105.1 R250.1 R368.1 R597.1 U20.44(INT_N/PWDN_N) U80.44(INT_N/PWDN_N)
PRG1_RGMII_INTN_RC: C491.1 R597.2 U23.C19(EXTINTN)
PRG_EARTH: C295.1 J21.SH1 J21.SH2 J21.SH3 J21.SH4 R304.1
PRI_INN: C252.2 R55.1 R262.2 U70.14(PRI_INN)
RESETSTATZ: R344.2 R435.2 TP68.1(TP) U23.F16(RESETSTATZ) U54.2(B) U85.2(B) U86.3(B) U88.2(B) U91.28(R\E\S\E\T\) U105.8(RESETN/SYNC)
SEL_XDS: U45.6(OE) U47.4(Y) U56.4(O\E\) U98.14(2\O\E\) U98.15(1\O\E\)
SEL_XDS110_INV: J25.8 J33.58 R183.1 R184.1 U37.14(2\O\E\) U37.15(1\O\E\) U46.4(O\E\) U47.2(A) U52.1(A) U53.1(A) U55.6(OE) U60.15(O\E\) U93.1(A) U94.1(A)
SERDES0_ATB_0: TP66.1(TP) U23.W15(SERDES0_ATB_0)
SERDES0_ATB_1: TP73.1(TP) U23.V16(SERDES0_ATB_1)
SERDES0_REXT: R338.1 U23.T13(SERDES0_REXT)
SERDES_REFCLK0_N: R622.2 R624.2 R665.2 R680.1
SERDES_REFCLK0_N_C: R333.1 R661.2 R680.2 U23.W16(SERDES0_REFCLK0N)
SERDES_REFCLK0_P: R623.2 R625.2 R666.2 R679.1
SERDES_REFCLK0_P_C: R346.1 R662.2 R679.2 U23.W17(SERDES0_REFCLK0P)
SERDES_RXN0: J27.A17(PERN0) U23.Y15(SERDES0_RX0_N)
SERDES_RXP0: J27.A16(PERP0) U23.Y16(SERDES0_RX0_P)
SERDES_TXN0: C100.1 J27.B15(PETN0)
SERDES_TXN0_C: C100.2 U23.AA16(SERDES0_TX0_N)
SERDES_TXP0: C102.1 J27.B14(PETP0)
SERDES_TXP0_C: C102.2 U23.AA17(SERDES0_TX0_P)
SHIELD: C478.1 J6.SH1 J6.SH2 J6.SH3 J6.SH4 R566.1
SOC_CLKIN: R137.1 R272.2
SOC_DVDD1V8: C97.1 C98.2 C359.1 C371.1 C379.1 C383.1 J13.2 R233.3 U23.E12(VMON_1P8_SOC) U23.J15(VDDS_MMC0#J15) U23.K14(VDDS_MMC0#K14) U23.K16(VMON_1P8_MCU) U23.M14(VDDSHV4#M14) U23.M15(VDDSHV4#M15)
SOC_DVDD3V3: C304.1 C309.1 C312.1 C319.1 C321.1 C326.1 C328.1 C331.1 C333.1 C337.1 C343.1 C351.1 C360.1 C361.1 C364.1 C366.2 C374.1 C376.1 C378.1 J19.2 R295.1 U23.F9(VDDSHV_MCU#F9) U23.F11(VDDSHV0#F11) U23.F13(VMON_3P3_MCU) U23.F14(VMON_3P3_SOC) U23.G8(VDDSHV_MCU#G8) U23.G10(VDDSHV_MCU#G10) U23.G12(VDDSHV0#G12) U23.G14(VDDSHV0#G14) U23.M7(VDDSHV1#M7) U23.N6(VDDSHV1#N6) U23.P7(VDDSHV1#P7) U23.P14(VDDSHV3#P14) U23.P15(VDDSHV3#P15) U23.R8(VDDSHV2#R8) U23.R10(VDDSHV2#R10) U23.R13(VDDA_3P3_USB0) U23.T9(VDDSHV2#T9)
SOC_EMU0: J39.1 R634.2 U23.D10(EMU0) U45.5(A1) U55.5(A1)
SOC_EMU1: J40.1 R635.2 U23.E10(EMU1) U45.4(A2) U55.4(A2)
SOC_I2C0_SCL: J2.E1 J5.3 R358.2 R598.1 U7.6(SCL) U66.14(SCL)
SOC_I2C0_SCL_RC: C492.1 R598.2 U23.A18(I2C0_SCL)
SOC_I2C0_SDA: J2.E2 J5.2 R354.2 R599.1 U7.5(SDA) U66.15(SDA)
SOC_I2C0_SDA_RC: C493.1 R599.2 U23.B18(I2C0_SDA)
SOC_I2C1_SCL: J27.B5(SMCLK) J36.5 R13.1 R265.2 R353.2 R659.1 TP25.1(TP) U1.5(SCL) U6.5(SCL) U11.2(A0) U11.5(SCL) U14.5(SCL) U16.1(A1) U16.5(SCL) U18.1(SCL) U23.C18(I2C1_SCL) U28.1(A1) U28.5(SCL) U29.1(SCL) U34.15(SCL) U51.7(SCLB) U91.29(SCL)
SOC_I2C1_SDA: J27.B6(SMDAT) J36.4 R12.1 R270.2 R357.2 R660.1 TP27.1(TP) U1.2(A0) U1.4(SDA) U6.4(SDA) U11.1(A1) U11.4(SDA) U14.4(SDA) U16.4(SDA) U18.6(SDA) U23.B19(I2C1_SDA) U28.2(A0) U28.4(SDA) U29.6(SDA) U34.2(SDA) U51.6(SDAB) U91.30(SDA)
SOC_I2C1_TA_SCL: J38.36 R495.2 U51.2(SCLA)
SOC_I2C1_TA_SDA: J38.38 R494.2 U51.3(SDAA)
SOC_MAIN_UART0_CTS_3V3: U23.B16(UART0_CTSN) U84.9(2A2)
SOC_MAIN_UART0_RTS_3V3: U23.A16(UART0_RTSN) U84.7(1A2)
SOC_MAIN_UART0_RX_3V3: U23.D15(UART0_RXD) U84.8(2A1)
SOC_MAIN_UART0_TX_3V3: R608.2 U23.C16(UART0_TXD) U84.6(1A1)
SOC_MAIN_UART1_RX_3V3: U23.E15(UART1_RXD) U89.8(2A1)
SOC_MAIN_UART1_TX_3V3: R609.2 U23.E14(UART1_TXD) U89.6(1A1)
SOC_MAIN_UART3_RX_3V3: U23.D16(UART1_CTSN) U89.9(2A2)
SOC_MAIN_UART3_TX_3V3: R610.2 U23.E16(UART1_RTSN) U89.7(1A2)
SOC_MMC0_CLK: R404.2 U23.G18(MMC0_CLK)
SOC_MMC0_CMD: R457.2 U23.J21(MMC0_CMD) U44.M5(CMD)
SOC_MMC0_DAT0: R161.2 U23.K20(MMC0_DAT0) U44.A3(DAT0)
SOC_MMC0_DAT1: R163.2 U23.J20(MMC0_DAT1) U44.A4(DAT1)
SOC_MMC0_DAT2: R165.2 U23.J18(MMC0_DAT2) U44.A5(DAT2)
SOC_MMC0_DAT3: R159.2 U23.J17(MMC0_DAT3) U44.B2(DAT3)
SOC_MMC0_DAT4: R160.2 U23.H17(MMC0_DAT4) U44.B3(DAT4)
SOC_MMC0_DAT5: R162.2 U23.H19(MMC0_DAT5) U44.B4(DAT5)
SOC_MMC0_DAT6: R164.2 U23.H18(MMC0_DAT6) U44.B5(DAT6)
SOC_MMC0_DAT7: R166.2 U23.G17(MMC0_DAT7) U44.B6(DAT7)
SOC_MMC0_DS: R446.1 U23.G19(MMC0_DS)
SOC_OSC0: TP65.1(TP) U23.G13(ATEST0)
SOC_OSPI_DQ0: R440.2 U23.M19(OSPI0_D0)
SOC_OSPI_DQ1: R433.2 U23.M18(OSPI0_D1)
SOC_OSPI_DQ2: R423.2 U23.M20(OSPI0_D2)
SOC_OSPI_DQ3: R425.2 U23.M21(OSPI0_D3)
SOC_OSPI_DQ4: R432.2 U23.P21(OSPI0_D4)
SOC_OSPI_DQ5: R441.2 U23.P20(OSPI0_D5)
SOC_OSPI_DQ6: R442.2 U23.N18(OSPI0_D6)
SOC_OSPI_DQ7: R443.2 U23.M17(OSPI0_D7)
SOC_POWER_MON_PORZ: R285.2 U41.1(A) U76.4(SENSE_OUT)
SOC_SPI0_CLK: R395.1 TP77.1(TP) U23.D13(SPI0_CLK) U83.2(CLK)
SOC_SPI0_CS0: R399.1 TP80.1(TP) U23.D12(SPI0_CS0) U83.1(CS)
SOC_SPI0_MISO: R398.1 TP79.1(TP) U23.A14(SPI0_D1) U83.4(DO)
SOC_SPI0_MOSI: R394.1 TP76.1(TP) U23.A13(SPI0_D0) U83.3(DI)
SOC_SPI1_CLK: J2.C1 U23.C14(SPI1_CLK)
SOC_SPI1_CS0: J2.D1 U23.B14(SPI1_CS0)
SOC_SPI1_CS1: J2.D2 U23.D14(SPI1_CS1)
SOC_SPI1_MISO: J2.B1 U23.A15(SPI1_D1)
SOC_SPI1_MOSI: J2.B2 U23.B15(SPI1_D0)
SOC_TCK: R147.2 R506.2 U23.B11(TCK)
SOC_TDI: U23.C11(TDI) U37.7(2A2) U98.4(1A1)
SOC_TDO: R323.1 U46.2(A1) U56.2(A1)
SOC_TMS: U23.C12(TMS) U37.6(2A1) U98.6(2A1)
SOC_TRST#: R322.1 U23.D11(TRSTN) U37.4(1A1) U98.7(2A2)
SOC_USB0_VBUS: R427.2 R436.1 U23.T14(USB0_VBUS)
SOC_VSENSE: TP30.1(TP) U23.D21(VSENSE)
SOC_WARM_RESETZ: R476.1 TP70.1(TP) U23.E18(RESET_REQZ) U50.2(3Y)
SUPERVISOR_DEBOUNCE_RSTN: C468.2 D10.2 Q9.2(S) R540.1 SW7.1 SW7.2 U57.2(A)
SUPERVISOR_MR_RSTN: U57.4(Y) U76.1(ENABLE)
SYNC1_OUT_TP: J12.1 U23.D18(ECAP0_IN_APWM_OUT)
SYS_BOOTMODE0: R529.1 SW2.1 U79.3(A1) U96.1(P00)
SYS_BOOTMODE1: R519.1 SW2.2 U79.4(A2) U96.2(P01)
SYS_BOOTMODE2: R514.1 SW2.3 U79.5(A3) U96.3(P02)
SYS_BOOTMODE3: R510.1 SW2.4 U79.6(A4) U96.4(P03)
SYS_BOOTMODE4: R503.1 SW2.5 U79.7(A5) U96.5(P04)
SYS_BOOTMODE5: R498.1 SW2.6 U79.8(A6) U96.6(P05)
SYS_BOOTMODE6: R489.1 SW2.7 U79.9(A7) U96.7(P06)
SYS_BOOTMODE7: R474.1 SW2.8 U79.10(A8) U96.8(P07)
SYS_BOOTMODE8: R473.1 SW3.1 U81.3(A1) U96.9(P10)
SYS_BOOTMODE9: R488.1 SW3.2 U81.4(A2) U96.10(P11)
SYS_BOOTMODE10: R497.1 SW3.3 U81.5(A3) U96.11(P12)
SYS_BOOTMODE11: R502.1 SW3.4 U81.6(A4) U96.12(P13)
SYS_BOOTMODE12: R509.1 SW3.5 U81.7(A5) U96.13(P14)
SYS_BOOTMODE13: R513.1 SW3.6 U81.8(A6) U96.14(P15)
SYS_BOOTMODE14: R518.1 SW3.7 U81.9(A7) U96.15(P16)
SYS_BOOTMODE15: R528.1 SW3.8 U81.10(A8) U96.16(P17)
SYSBOOT_BUF_ENZ: R434.1 R435.1 U90.1(A)
TCA6424_EXP_INT: R533.1 U96.32(I\N\T\)
TEMP_DIODE_P: TP75.1(TP) U23.F12(TEMP_DIODE_P)
TEST_GPIO1: Q17.1(G) R523.1 R545.1
TEST_GPIO2: R524.1 R546.1 U91.14(P15)
TEST_GPIO3: J30.1 R439.2 R525.1 R547.1 TP41.1(TP) U90.2(B)
TEST_GPIO4: R526.1 R548.1 TP40.1(TP) U96.28(R\E\S\E\T\)
TEST_LED1: R549.2 R553.2 U91.17(P20)
TEST_LED2: J1.7 R552.2 R554.2 U23.A7(MCU_SPI1_CS0)
TEST_PORZN: Q9.1(G) R521.1 R543.1
TEST_POWERDOWN: R412.1 R542.1
TEST_WARMRESETN: Q10.1(G) R522.1 R544.1
TM4C129_TCK: TP37.1(TP) U59.100(PC0/TCK/SWCLK)
TM4C129_TDI: TP36.1(TP) U59.98(PC2/TDI)
TM4C129_TDO: TP38.1(TP) U59.97(PC3/TDO/SWO)
TM4C129_TMS: TP35.1(TP) U59.99(PC1/TMS/SWDIO)
TMP1_ADD0: R68.2 R72.2 U18.5(ADD0)
TMP1_ADD1: R93.2 R98.2 U18.3(ADD1)
TMP2_ADD0: R132.1 R133.2 U29.5(ADD0)
TMP2_ADD1: R124.2 R125.2 U29.3(ADD1)
USB0_AB_DM: FL22.4 J24.2(D-) U38.1(D+)
USB0_AB_DP: FL22.3 J24.3(D+) U38.2(D-)
USB0_AB_ID: J23.5 J24.4(ID) U23.U16(USB0_ID) U38.3(ID)
USB0_DM: FL22.1 U23.AA20(USB0_DM)
USB0_DP: FL22.2 U23.AA19(USB0_DP)
USB0_DRVBUS: R151.1 U23.E19(USB0_DRVVBUS) U36.4(EN)
USB0_RCALIB: R605.1 TP67.1(TP) U23.U17(USB0_RCALIB)
USB0_VBUS: C140.1 J23.1 J24.1(VCC) R428.1 U36.6(OUT1) U36.7(OUT2) U36.8(OUT3) U38.6(VBUS)
USB1_SHIELD: C153.2 J24.6(SH1) J24.7(SH2) J24.8(SH3) J24.9(SH4) J24.10(SH5) R170.2
VCOMH: C473.1 J36.2
VIO_CAN: C3.1 C8.1 FB1.2 U3.5(VIO) U4.5(VIO)
VMAIN: C56.1 C65.2 C66.1 C81.1 C82.1 C123.1 C431.1 C432.1 C448.1 C449.1 C450.1 C452.1 D3.3(K) J27.A2(+12V#A2) J27.A3(+12V#A3) J27.B1(+12V#B1) J27.B2(+12V#B2) J27.B3(+12V#B3) R80.2 R408.2 R500.1 R604.1 R695.1 TP81.1(TP) U17.1(VIN) U24.5(D) U26.5(D) U97.2(VIN)
VMAIN_EN: C406.1 R408.1 R412.2 R577.1 SW1.2
VMON_0V85: R692.2 U103.2(B) U106.4(SENSE_OUT)
VMON_0V85_CT: C535.1 U106.5(CT)
VPHY_3V3_FT4232: C425.2 FB24.1 U87.4(VPHY)
VPLL_3V3_FT4232: C422.2 FB23.1 R417.2 U87.9(VPLL)
VPP_1V8: C243.1 TP52.1(TP) U23.G15(VPP) U72.1(OUT)
VPP_DDR_2V5: C201.1 FB11.1 TP47.1(TP) U62.1(OUT)
VPP_LDO_EN: R263.2 R582.2 TP53.1(TP) U91.16(P17)
VREF: C180.1 C453.2 R505.2 U59.9(VREFA+) U95.3(CATHODE)
VSENSE: C272.2 R279.2 R294.1 U17.6(VSENSE)
XDS110_DIR: R507.2 U98.2(1DIR) U98.3(2DIR)
XDS110_EMU0: R202.2 U55.8(B1) U59.42(PF0)
XDS110_EMU1: R203.2 U55.1(B2) U59.43(PF1)
XDS110_TCK: U59.35(PA2/SSI0CLK) U98.12(1B2)
XDS110_TDI: U59.38(PA5/SSI0XDAT1) U98.13(1B1)
XDS110_TDO: U56.7(B1) U59.37(PA4/SSI0XDAT0)
XDS110_TMS: U59.36(PA3/SSI0FSS) U98.11(2B1)
XDS110_TRST#: U59.40(PA6) U98.10(2B2)
XDS_RSTN: R198.1 R199.1 U59.70(R\S\T\)
XDS_SHIELD: FB8.1 J28.SH1 J28.SH2 J28.SH3 J28.SH4 J28.SH5 J28.SH6
XDS_USB_DM: J28.2(D-) U58.5(IO4) U59.93(PL7/USB0DM)
XDS_USB_DP: J28.3(D+) U58.4(IO3) U59.94(PL6/USB0DP)
XDS_USB_ID: J28.4(ID) R478.2 U58.2(IO2)
XDS_USB_VBUS: C195.1 J28.1(VBUS) R467.1 R469.1 U58.6(VCC) U61.1(IN1) U61.2(IN2) U61.8(EN)
N5126260: TP11.1(TP) U15.13(VDDA1P8#13) U15.48(VDDA1P8#48)
N15202140: R478.1 U59.95(PB0/USB0ID)
N15204440: C198.2 R204.2 R561.1 U61.5(NR/FB)
N15205319: C193.2 R200.1 U59.68(VBAT)
N15212041: R205.1 U59.59(RBAIS)
N15239696: C447.2 R467.2 U59.96(PB1/USB0VBUS)
N15241750: R468.1 R469.2 U59.1(PD0/AIN15)
N15242949: R466.1 U59.3(PD2/AIN13)
N15242980: LD22.2(ANODE) R466.2
N15243226: R462.1 U59.4(PD3/AIN12)
N15365714: J38.27 R543.2
N15365947: J38.30 R545.2
N15366015: J38.31 R546.2
N15366091: J38.32 R547.2
N15507744: C159.2 U43.2(NR/FB)
N15584817: R508.1 SW2.13
N15584821: R512.1 SW2.14
N15584825: R517.1 SW2.15
N15584829: R527.1 SW2.16
N15591045: R472.1 SW2.9
N15591049: R487.1 SW2.10
N15591053: R496.1 SW2.11
N15591057: R501.1 SW2.12
N15854407: R43.1 U14.3(ALERT)
N15854417: C47.2 R73.1 U14.8(VBUS) U14.9(VIN-)
N15854427: C47.1 R74.1 U14.10(VIN+)
N15854463: R28.1 U6.3(ALERT)
N15854467: C204.2 R216.1 U6.8(VBUS) U6.9(VIN-)
N15854483: C204.1 R215.1 U6.10(VIN+)
N15854545: R244.1 U11.3(ALERT)
N15854547: R122.1 U28.3(ALERT)
N15854553: C214.2 R229.1 U11.8(VBUS) U11.9(VIN-)
N15854557: C393.2 R350.1 U28.8(VBUS) U28.9(VIN-)
N15854581: C393.1 R352.1 U28.10(VIN+)
N15854603: C214.1 R228.1 U11.10(VIN+)
N15854737: R1.1 U1.3(ALERT)
N15854741: C203.2 R11.1 U1.8(VBUS) U1.9(VIN-)
N15854757: C203.1 R10.1 U1.10(VIN+)
N15854857: J4.2 R12.2
N15854859: J4.1 R13.2
N16248811: C256.1 R60.1 U70.20(Y7)
N16248833: C255.1 R61.1 U70.18(Y6)
N16248855: C262.1 R65.1 R272.1 U70.17(Y5)
N16248877: R235.1 U70.8(Y4)
N16248899: R236.1 U70.7(Y3)
N16248921: R237.1 U70.5(Y2)
N16248943: R238.1 U70.3(Y1)
N16248965: R239.1 U70.1(Y0)
N16303893: R515.1 SW3.11
N16303897: R511.1 SW3.12
N16303901: R504.1 SW3.13
N16303905: R499.1 SW3.14
N16303921: R530.1 SW3.9
N16303925: R520.1 SW3.10
N16679303: R206.2 R560.1 U59.60(PK7)
N16679944: R209.2 R557.1 U59.63(PK4)
N16679981: R207.2 R559.1 U59.61(PK6)
N16680014: R208.2 R558.1 U59.62(PK5)
N16753626: J33.6 R449.2
N16753680: J33.15 R409.2
N16754334: J33.12 R447.2
N16756061: J25.2 R685.1
N16814557: R445.2 U89.5(2DIR)
N16814563: R438.1 U89.4(1DIR)
N16814605: R400.2 U84.5(2DIR)
N16814611: R406.1 U84.4(1DIR)
N16814651: R397.2 U82.5(2DIR)
N16814659: R403.1 U82.4(1DIR)
N16879988: R38.1 U13.F9(ZQ)
N16880168: TP15.1(TP) U13.T7(NF/NC)
N16887346: R320.1 U23.H5(DDR0_CAL0)
N16887366: TP57.1(TP) U23.K2(DDR0_ATB0)
N16887368: TP13.1(TP) U23.K1(DDR0_ATB1)
N16887377: TP59.1(TP) U23.H3(DDR0_BG1)
N16887386: TP58.1(TP) U23.F3(DDR0_CKE1)
N16887395: TP60.1(TP) U23.E4(DDR0_CS1_N)
N16887404: TP62.1(TP) U23.F5(DDR0_ODT1)
N16937764: R147.1 U37.5(1A2)
N16938293: R506.1 U98.5(1A2)
N17211229: J38.33 R548.2
N17247526: LD16.2(ANODE) R421.2
N17247539: LD17.2(ANODE) R420.2
N17247599: LD18.2(ANODE) R419.2
N17247637: LD19.2(ANODE) R418.2
N17247662: LD14.2(ANODE) R381.2
N17247701: LD13.2(ANODE) R382.2
N17247743: LD12.2(ANODE) R383.2
N17247786: LD11.2(ANODE) R384.2
N17248427: R413.2 U34.7(A2)
N17248432: R402.2 U34.10(A1)
N17248439: R401.2 U34.9(A0)
N17546132: J38.26 R542.2
N17546158: J38.28 R544.2
N17682848: R74.2 R92.4
N17682861: R73.2 R92.1
N17683733: R215.2 R227.3
N17683748: R216.2 R227.2
N17685678: R228.2 R233.1
N17685693: R229.2 R233.4
N17685736: R351.1 R352.2
N17685749: R350.2 R351.4
N17686321: R10.2 R22.2
N17686333: R11.2 R22.3
N17786037: L1.1 U9.2(SW)
N17786049: R231.1 R232.2 U9.4(FB)
N17839730: C143.1 J23.2
N18116794: Q13.1(G) R286.2
N18116818: Q12.1(G) R230.1
N18116875: Q3.1(G) R30.1
N18117332: Q14.1(G) R324.2
N18117389: Q16.1(G) R343.1
N18275385: R459.1 U48.6(OE)
N18276744: C169.1 R190.2
N18280417: R195.2 U53.4(Y)
N18280437: R491.2 U93.4(Y)
N18280477: R194.2 U52.4(Y)
N18280857: R492.2 U94.4(Y)
N18289350: C277.1 U76.5(CT)
N18321769: R243.1 U70.31(OE)
N18546005: D1.1(CATHODE) D3.1(A1) D3.2(A2) F1.2 R64.1
N18546027: LD5.1(CATHODE) R64.2
N18546044: D2.1(K) LD5.2(ANODE)
N18867885: R325.2 U79.21(B1)
N18867903: R326.2 U79.20(B2)
N18867905: R327.2 U79.19(B3)
N18867915: R328.2 U79.18(B4)
N18867925: R329.2 U79.17(B5)
N18867943: R330.2 U79.16(B6)
N18867953: R331.2 U79.15(B7)
N18867955: R332.2 U79.14(B8)
N18968753: C141.1 FL7.3(O) U36.2(IN1) U36.3(IN2)
N18968782: R153.2 U36.5(O\C\)
N18977129: C433.1 U87.3(OSCO) Y3.2
N18977189: C439.1 U87.2(OSCI) Y3.1
N19031494: C215.1 U9.9(SS/TR)
N19312123: D7.3(C) R427.1 R428.2
N19753713: C116.2 D5.1(CATHODE) U30.11(HB2)
N19753729: C116.1 L5.1 U22.5(D) U26.1(S1) U26.2(S2) U26.3(S3) U30.10(SW2)
N19753760: L5.2 R111.1 R112.1
N19753772: R129.2 U26.4(G) U30.8(HOL2)
N19753820: R317.1 U30.13(LO2)
N19753822: R317.2 R321.2 U22.4(G)
N19753872: C85.1 R112.2 U30.4(CS2)
N19753878: C85.2 R109.2 U30.5(VOUT2)
N19753964: C125.1 R141.1
N19754006: C131.1 U30.30(SS1)
N19754159: R695.2 U30.25(VIN)
N19754185: C132.1 U30.1(SS2)
N19754201: C115.2 L6.2 U21.5(D) U24.1(S1) U24.2(S2) U24.3(S3) U30.21(SW1)
N19754203: C115.1 D4.1(CATHODE) U30.20(HB1)
N19754223: R130.2 U30.22(HO1)
N19754237: R130.1 U24.4(G) U30.23(HOL1)
N19754314: R318.1 R319.1 U21.4(G)
N19754320: R319.2 U30.19(LOL1)
N19754322: R318.2 U30.18(LO1)
N19754431: R129.1 U30.9(HO2)
N19754435: R321.1 U30.12(LOL2)
N19754522: L6.1 R116.2 R119.1
N19754526: C94.1 R113.2 U30.26(VOUT1)
N19754534: C94.2 R119.2 U30.27(CS1)
N19754630: C137.2 U30.32(RES)
N19754677: C136.1 R142.2
N20142928: C200.1 U62.2(NR/FB)
N20753582: C248.1 R261.2 R267.2
N23484157: C247.1 R53.1 U70.24(Y9)
N23484680: C257.1 R59.1 U70.22(Y8)
N24658557: LD20.2(ANODE) R462.2
N24754956: TP69.1(TP) U80.13(VDDA1P8_1) U80.48(VDDA1P8_2)
N24775601: TP19.1(TP) U20.13(VDDA1P8_1) U20.48(VDDA1P8_2)
N24776171: Q15.1(G) R334.2
N24776230: Q4.1(G) R99.1
N24826481: C245.1 R260.1 R266.2 U74.3(SENSE)
N24972917: R280.2 R295.3
N24972919: R281.2 R295.2
N24972921: C269.2 R281.1 U16.8(VBUS) U16.9(VIN-)
N24972925: C269.1 R280.1 U16.10(VIN+)
N24973001: R48.1 U16.3(ALERT)
N25209998: R268.1 U71.1(STANDBY#)
N25294505: LD6.2(ANODE) R80.1
N25395961: R323.2 U23.A12(TDO)
N25526660: R254.2 U70.12(XOUT)
N25657725: R345.1 U23.A19(EXT_REFCLK1)
N25657961: J36.3 R541.2
N25658118: R516.2 U99.3(OC)
N26002209: R157.2 U40.B2(CK)
N26002808: Q19.1(G) R552.1
N26002814: LD26.2(ANODE) R210.1
N26002874: Q18.1(G) R553.1
N26002883: LD23.2(ANODE) R197.1
N26004018: C49.1 R82.1 U17.7(COMP)
N26004022: C48.2 R82.2
N26004036: C54.1 L3.1 U17.2(SW)
N26004038: C54.2 U17.9(BOOT)
N26004052: C272.1 R277.2 R279.1
N26016842: L9.1 U97.9(SW)
N26016868: R535.1 TP98.1(TP) U97.7(PG)
N26016893: R500.2 U97.3(EN)
N26118637: R221.2 U4.1(TXD)
N26118639: R220.2 U4.4(RXD)
N26120249: R223.2 U3.1(TXD)
N26120251: R222.2 U3.4(RXD)
N26140693: R372.2 U81.21(B1)
N26140695: R373.2 U81.20(B2)
N26140697: R374.2 U81.19(B3)
N26140699: R375.2 U81.18(B4)
N26140701: R376.2 U81.17(B5)
N26140703: R377.2 U81.16(B6)
N26140705: R378.2 U81.15(B7)
N26140707: R379.2 U81.14(B8)
N26145534: Q5.1(G) R312.1
N26145544: LD7.2(ANODE) R305.1
N26145600: Q2.1(G) R20.1
N26145606: LD2.2(ANODE) R211.1
N26145666: Q1.1(G) R14.1
N26145672: LD3.2(ANODE) R15.1
N26145732: Q7.1(G) R136.1
N26145738: LD10.2(ANODE) R365.1
N26145798: Q6.1(G) R127.1
N26145804: LD8.2(ANODE) R360.1
N26145856: Q11.1(G) R217.1
N26145862: LD1.2(ANODE) R212.1
N26149805: R454.2 U90.4(Y)
N26149864: J30.2 R555.2
N26219977: R490.1 SW3.15
N26220001: R475.1 SW3.16
N26314477: C278.1 C279.1 C285.1 R298.2
N26314562: C291.1 C292.1 C296.1 R307.2
N26442461: R185.1 U51.5(EN)
N26454965: R171.1 U41.4(Y)
N26523524: R158.1 U40.A5(INT#)
N26648730: TP90.1(TP) U91.19(P22)
N26648748: TP88.1(TP) U91.20(P23)
N26648766: TP87.1(TP) U91.21(P24)
N26648784: TP86.1(TP) U91.22(P25)
N26648802: TP89.1(TP) U91.23(P26)
N26648820: TP91.1(TP) U91.24(P27)
N26733190: R361.2 R364.1 U32.4(FB)
N26733205: L7.1 U32.2(SW)
N26733231: C402.1 U32.9(SS/TR)
N26735382: C202.1 U5.9(SS/TR)
N26735416: R213.1 R214.2 U5.4(FB)
N26735457: L2.1 U5.2(SW)
N26735496: L8.1 U65.6(SW)
N26735653: R144.2 R145.1 U33.2(FB)
N26736579: L4.1 U25.6(SW)
N26736751: R57.2 U12.1(EN)
N26736805: R44.2 R49.1 U12.7(FB)
N26881621: LD21.1(CATHODE) R464.2
N27030520: R252.1 U71.3(OUTPUT)
N27215594: J14.11 R76.2
N27217693: FB19.2 J21.B9(VCC)
N27218087: J21.B12 R347.2
N27219244: FB14.2 J21.A9(VCC)
N27219552: J21.A12 R336.2
N27838027: R24.1 U10.6(OE)
N27914276: R577.2 U30.40(EN2)
N27928121: R578.1 U30.31(EN1)
N27928168: R579.1 R602.2 U17.8(EN)
N27943339: R580.1 U65.1(EN)
N27943633: R581.1 U5.6(EN)
N27943804: R582.1 U72.3(EN)
N27943890: R583.1 U33.4(EN)
N27943939: R584.1 U25.1(EN)
N27944274: R585.1 U9.6(EN)
N27944496: R586.1 U62.4(EN)
N27944776: R587.1 U32.6(EN)
N27944822: R588.1 U77.3(EN)
N27945052: R589.1 U100.3(EN)
N27977097: C133.2 R138.1 Y1.1
N27977103: C134.2 R139.1 Y1.3
N28035755: R591.2 U23.N21(OSPI0_LBCLKO)
N28118242: LD7.1(CATHODE) Q5.3(D)
N28118245: LD2.1(CATHODE) Q2.3(D)
N28118248: LD3.1(CATHODE) Q1.3(D)
N28118251: LD10.1(CATHODE) Q7.3(D)
N28118254: LD8.1(CATHODE) Q6.3(D)
N28118257: LD1.1(CATHODE) Q11.3(D)
N28118260: LD4.2(ANODE) R276.2
N28118377: LD9.2(ANODE) R362.2
N28118380: LD15.2(ANODE) R407.2
N28118607: LD25.2(ANODE) R556.2
N28118686: LD24.2(ANODE) R201.2
N28119618: LD23.1(CATHODE) Q18.3(D)
N28119621: LD26.1(CATHODE) Q19.3(D)
N28789368: TP101.1(TP) U91.12(P13)
N28853998: Q20.1(G) R614.1
N28854850: Q21.1(G) R617.1
N28887698: R624.1 R625.1 R632.1
N28906258: J40.2 R631.2
N28906289: J39.2 R630.2
N29283187: FB26.2 J14.2(VCC)
N248107881: C168.1 R189.2

Pads without a net: D7 2; J2 A26 A30 C27 D27; J3 2 19; J4 5; J7 9; J23 3 4; J25 17 18 19; J26 4; J27 A19 A21 A22 A25 A26 A29 A30 A32 B19 B20 B23 B24 B27 B28 B30 B31; J33 9 10 11 14 28 30 32 34 36 42 44 46 48 50 52 54 56 59 60; J36 9; J38 4 5 6 8 9 10 11 12 13 14 15 17 18 19 20 21 22 23 24 29 35; SW1 3; U2 4; U5 10; U7 1; U8 24; U9 10; U15 14 20 21 22 23; U20 14 15 16 17 19 21 23 24; U25 4; U30 39; U32 10; U38 5; U39 4; U40 A2 A3 B1 B5 C5; U42 1 2; U43 5; U44 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U47 1; U49 4 9; U57 1; U58 1; U59 2 5 6 11 12 13 14 15 18 19 20 21 22 23 24 25 27 29 30 31 32 33 34 41 44 45 46 49 50 53 54 56 57 65 67 71 72 73 74 75 76 77 78 81 82 83 84 85 86 91 92 102 103 104 105 106 107 108 109 110 111 112 116 117 118 119 120 121 123 124 125 126 127 128; U60 5 6 10 11 13 14; U61 7; U62 5; U63 4; U64 4; U66 5 6 7 9 10 11 12; U70 27 28; U75 11 12 13 14 15 16 18 19 20 21 22 23 24 25 26 27 28 29; U80 14 15 16 17 19 21 23 24; U83 6 7; U87 21 22 23 24 30 32 33 34 36 40 41 43 44 45 46 53 54 55 57 58 59; U92 6 7; U95 2 4 5; U96 17 18 19 20 21 22 23 24; U97 4; U105 5 6 13 14 17 18

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 3163 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3V3_AUX: length 3
  BOTTOM w0.147: J27.B10 18.78,28.47 R493.2
DGND: length 1062
  TOP w0.094: v1(115.06,34.35) 115.31,34.6 115.87,34.6 U44.N2 115.87,34.1 115.31,34.1 v1(115.06,34.35)
  TOP w0.147: J2.A18 v1(52.96,127.27)
  TOP w0.152: C91.2 73.66,78.25 ; U44.A6 118.45,40.67 118.45,40.76 ; C92.2 74.42,78.25 ; C387.2 106.79,68.86 v1(106.55,68.63) ; R154.2 95.85,50.63 v1(95.12,49.91) ; C93.2 75.18,78.25 ; v1(56.72,50.14) 56.7,50.12 FL19.2
  TOP w0.203: U44.E7 118.62,38.14 v1(118.89,37.87) ; U44.G5 117.12,37.85 v1(117.12,38.1) ; U59.55 v1(155.55,15.23) ; U46.3 90.88,33.45 ; U56.3 120.7,50.92 120.93,50.68 120.93,50.64 121.07,50.5 ; v1(116.98,32.77) 116.98,33.25 117.12,33.39 U44.P4 ; 152.91,12.9 152.75,13.06 U59.48 ; 143.89,23.76 143.89,24.02 144.2,24.33 U59.10 ; U44.K8 119.12,35.59 v1(119.37,35.34) ; U46.5 91.28,35.86 ; v1(147.05,21.59) 146.57,21.59 146.51,21.53 U59.17 ; U59.80 161.74,21.53 ; v1(119.64,37.09) 119.88,36.85 U44.H10 ; U59.64 v1(159.15,15.24) ; v1(118.62,33.26) 118.33,33.26 118.12,33.47 U44.P6 U44.N5 ; 118.45,40.76 v1(118.7,41.01) ; v1(88.59,85.93) 88.59,85.93 88.59,85.31 88.66,85.24 U23.P1 ; U59.58 v1(156.75,15.22) ; U56.6 120.7,53.39 v1(120.88,53.57) 121.1,53.35 U56.5 ; 90.88,35.9 U46.6 ; 161.84,15.64 161.55,15.93 U59.66 ; v1(152.03,32.01) C167.2 152.03,30.74 152.35,30.42 U59.114 ; U44.C4 v1(117.62,38.85)
  TOP w0.254: J2.B28 v1(40.26,128.54) ; U23.A5 v1(99.46,82.3) ; U16.2 v1(137.91,101.24) ; J2.A10 v1(63.12,127.27) ; U23.J9 v1(93.06,79.1) ; R36.2 v1(42.29,110) ; U40.B3 v1(99.31,45.08) ; J2.B16 v1(55.5,128.54) ; U45.2 99.82,34.94 100.06,34.7 C157.1 v1(101.71,34.7) ; v1(162.84,54.05) 162.82,54.07 R694.2 ; v1(55.45,86.66) 55.39,86.72 R121.2 ; J2.C18 v1(52.96,129.81) ; C124.2 42.31,60.1 v1(42.34,60.13) ; R100.2 43.43,89.42 v1(43.31,89.55) ; C145.1 v1(91.29,50.54) ; R66.1 83.95,97.68 v1(84.45,97.17) ; 100.86,58.82 100.89,58.79 C134.1 ; U23.L1 91.06,85.61 v1(91.69,86.25) ; 35.36,94.4 36.02,94.4 v1(36.5,93.93) ; R54.2 v1(48.72,102.94) ; J25.10 70.61,39.38 v1(70.99,39) ; U23.J16 v1(93.06,72.7) ; U47.3 109.11,33.43 109.2,33.52 R183.2 v1(109.98,34.3) ; v1(137.08,81.98) 136.88,82.18 Q5.2 ; v1(56.64,119.27) 56.25,118.87 U8.2 ; J2.D4 v1(70.74,131.08) ; v1(94.4,100.95) 94.91,100.95 94.99,101.03 R62.1 ; Q8.3 v1(128.61,25.12) ; J2.B30 v1(37.72,128.54) ; U23.Y14 v1(83.46,74.3) ; J2.B10 v1(63.12,128.54) ; U23.M10 v1(89.86,78.3) ; v1(161.93,61.23) 161.42,61.74 161.42,62.46 161.18,62.7 U30.17 161.18,66 160.92,66.26 159.88,66.26 v1(159.87,66.24) 159.27,66.84 C107.2 ; v1(161.93,61.23) v1(162.94,60.21) 162.94,59.7 163.17,59.47 U30.38 ; v1(161.93,61.23) 162.43,61.74 162.43,62.46 162.67,62.7 U30.14 162.67,65.28 162.67,65.29 162.67,65.71 162.67,65.71 162.67,65.79 163.41,66.52 163.41,66.68 C108.2 164.55,67.15 v1(164.67,67.03) ; v1(161.93,61.23) 161.42,60.72 161.42,60 161.68,59.74 U30.35 ; U49.5 49.35,30.62 49.64,30.34 49.64,29.71 v1(49.14,29.22) ; J2.C13 v1(59.31,129.81) ; C125.2 169.71,58.48 169.42,58.19 168.79,58.19 C130.2 v1(168.79,57.5) ; J2.B27 v1(41.53,128.54) ; v1(97.15,21.97) 96.8,21.97 C190.1 ; J2.C25 v1(44.07,129.81) ; C112.2 v1(32.38,66) ; v1(36.14,49.49) 36.14,50 36.04,50.11 R413.1 ; J2.D16 v1(55.5,131.08) ; J2.C4 v1(70.74,129.81) ; 122.5,100.2 122.52,100.18 C484.2 ; v1(53.59,103.52) R53.2 ; U23.J7 v1(93.06,80.7) ; C76.2 v1(32.51,82.12) ; LD9.1 v1(169.81,63.63) ; J2.C16 v1(55.5,129.81) ; v1(30.84,65.83) 30.84,66.13 C111.2 31.64,66.13 v1(31.64,65.83) ; v1(92.08,48.27) 91.95,48.15 C146.1 ; v1(136.37,40.94) 135.86,40.94 135.6,40.67 R175.1 ; v1(28.13,88.83) 27.47,88.16 U19.3 ; v1(92.77,31.87) 93.03,32.13 C163.1 ; U61.6 168.73,11.25 v1(168.4,11.57) ; C182.1 v1(74.42,21.74) ; v1(70.04,39) 70.04,39.61 69.34,40.3 J25.12 ; C135.1 155.17,54.68 155.14,54.65 v1(155.14,54.35) ; C118.2 v1(152.02,61.86) ; U43.3 v1(166.83,36.51) ; U23.L7 v1(91.46,80.7) ; v1(47.99,68.82) 47.99,68.52 C105.2 47.19,68.52 v1(47.19,68.82) ; J2.D20 v1(50.42,131.08) ; R93.1 74.89,91.92 v1(74.93,91.96) ; R21.2 61.2,120.97 v1(60.87,121.3) ; J2.E7 v1(66.93,132.35) ; 131.98,76.77 131.85,76.9 ; 131.98,76.77 133.16,76.77 U25.5 132.15,76.6 131.98,76.77 ; U23.P8 v1(88.26,79.9) ; C106.2 v1(32.38,67.5) ; J2.C19 v1(51.69,129.81) ; J2.C10 v1(63.12,129.81) ; v1(82.66,71.1) U23.AA18 U23.Y17 ; J2.A6 v1(68.2,127.27) ; 100.28,58.82 100.23,58.77 C133.1 ; J2.E22 v1(47.88,132.35) ; U2.2 83.24,125.86 83.85,126.47 83.85,126.65 v1(84.21,127.01) ; v1(119.38,59.82) 118.89,60.31 C149.2 ; v1(74.55,69.88) 74.04,69.88 73.96,69.8 v1(73.33,69.8) ; Q2.2 v1(159.7,122.38) ; C39.2 v1(32.64,101.48) ; U23.J14 v1(93.06,74.3) ; J2.C7 v1(66.93,129.81) ; U23.A6 v1(99.95,81.1) ; v1(112.83,58.5) 112.33,59.01 C148.2 113.12,59.12 113.18,59.18 v1(113.19,59.18) ; C483.2 121.63,100.22 121.63,100.22 ; v1(60.45,99.71) R60.2 ; C7.1 v1(123.19,125.74) ; U42.3 v1(168.98,40.03) ; U27.5 v1(48.35,85.6) ; R177.1 v1(74.42,36.84) ; C189.1 120.56,49.51 121.07,50.02 121.07,50.5 ; U104.3 116.14,103.27 v1(115,102.13) ; v1(44.31,119.68) 44.29,119.65 R23.2 ; v1(104.71,40.27) 102.11,40.27 U40.E5 ; v1(45.53,61.42) 45.47,61.36 45.07,61.36 R135.2 ; C73.2 v1(32.43,83.62) ; v1(88.59,85.93) 88.59,91.65 89.93,93 C61.2 ; C22.1 v1(123.83,119.14) ; R38.2 94.87,107.82 v1(94.4,107.35) ; U58.3 v1(169.9,22.39) ; U23.G9 v1(94.66,79.1) ; U13.H9 94.61,103.94 94.61,103.56 U13.K9 ; J2.C30 v1(37.72,129.81) ; J25.16 66.8,40.02 v1(66.17,39.38) ; v1(47.45,84.59) R107.2 R108.2 ; J2.D13 v1(59.31,131.08) ; U23.H20 U23.H21 93.46,68.58 93.44,68.57 v1(93.44,68.46) ; C144.1 v1(73.79,50.29) ; C67.2 v1(32.28,89.11) ; C137.1 v1(160.07,55.1) ; R31.2 v1(33.93,110.11) ; v1(151.26,124.73) 151.12,124.59 U6.7 ; U23.D1 96.77,85.22 v1(96.77,86.5) ; v1(39.4,107.52) 39.37,107.52 39.29,107.44 C36.2 ; v1(35.94,38.73) 36.58,39.37 R402.1 ; U9.1 32.38,116.05 32.31,115.98 U9.11 ; J2.B19 v1(51.69,128.54) ; U23.G7 v1(94.66,80.7) ; C150.2 115.42,60.31 115.32,60.41 v1(114.81,60.41) ; U23.M12 v1(89.86,75.9) ; C2.2 v1(18.94,128.52) ; U23.C15 v1(97.86,73.5) ; C43.2 v1(32.64,99.98) ; U23.T8 v1(86.66,79.9) ; C38.2 v1(32.64,102.98) ; J2.B3 v1(72.01,128.54) ; v1(105.54,53.23) 105.25,53.52 R644.2 ; U23.F8 v1(95.46,79.9) ; J2.A23 v1(46.61,127.27) ; v1(45.99,99.87) 46.05,99.93 C41.2 ; v1(72.96,91.71) 72.96,91.71 U18.2 ; C57.2 143.53,92.07 v1(143.76,91.84) ; C197.2 v1(165.23,9.03) ; v1(44.37,43.66) 44.32,43.61 U34.16 ; v1(97.92,68.09) 97.92,65.8 99.99,63.73 99.99,60.49 100.15,60.33 v1(100.15,59.82) ; C10.2 152.76,125.6 v1(152.78,125.58) ; U23.P10 v1(88.26,78.3) ; U60.7 100.53,10.18 v1(100.89,9.82) 100.6,9.53 U60.8 ; v1(101.72,31.15) C164.1 100.95,31.13 100.08,31.13 99.82,31.39 U48.2 ; U23.V17 v1(85.06,71.9) ; J2.E6 v1(68.2,132.35) ; U23.R12 v1(87.46,75.9) ; U23.G3 v1(94.66,83.9) ; R70.2 v1(32.94,98.48) ; v1(63.63,44.08) 64.26,43.45 J25.20 ; C161.2 v1(64,33.3) ; v1(37.47,91.02) R97.2 37.47,90.35 36.52,90.35 R96.2 ; R34.2 v1(39.1,110.11) ; U13.E3 U13.D2 ; U23.L9 v1(91.46,79.1) ; J2.D25 v1(44.07,131.08) ; C83.2 45.86,79.75 v1(45.86,79.04) ; 106.81,85.14 106.72,85.05 v1(106.72,83.52) ; R17.1 112.73,120.83 v1(112.07,120.83) ; C169.2 v1(78.26,30.23) ; 160.8,52.21 LD15.1 v1(159.77,52.21) ; U23.AA21 v1(82.66,68.7) ; v1(53.34,21.1) 53.48,21.1 53.98,20.6 LD24.1 53.98,19.81 v1(52.72,19.81) ; Q9.3 v1(128.42,20.99) ; U60.9 v1(106.95,9.53) ; J2.E10 v1(63.12,132.35) ; J2.B23 v1(46.61,128.54) ; R145.2 133.48,55.53 133.73,55.28 v1(133.73,55.24) ; C168.2 v1(72.67,30.23) ; J2.E29 v1(38.99,132.35) ; R167.2 91.9,44.08 v1(92.65,43.32) 95.38,43.32 95.63,43.58 U40.C1 ; U23.T16 v1(86.66,72.7) ; v1(85.98,48.15) 85.94,48.11 U37.9 ; C99.2 v1(38.08,73.67) ; 80.79,123.32 v1(80.79,122.43) ; R52.2 v1(45.92,103.96) ; v1(94.49,86.5) 94.49,85.33 U23.G1 ; C110.2 v1(45.74,67.61) ; U23.T10 v1(86.66,78.3) ; R148.1 v1(89.14,51.21) ; U23.F15 v1(95.46,73.5) ; U32.1 19.66,60.95 19.99,61.28 ; C172.1 163.78,26.74 ; J26.5 v1(172.43,39.48) ; v1(102.86,31.15) C165.1 ; U23.A21 v1(99.46,68.7) ; U23.H8 v1(93.86,79.9) ; U23.G16 v1(94.66,72.7) ; v1(160.27,9.16) 160.32,9.2 R209.1 R208.1 ; 90.88,33.45 91.12,33.21 91.12,32.42 C162.1 v1(90.97,31.52) ; U23.N7 v1(89.06,80.7) ; J2.D7 v1(66.93,131.08) ; v1(39.59,76.13) 39.35,75.89 C90.2 ; U17.3 v1(147.83,94.38) ; U23.R7 v1(87.46,80.7) ; U23.F10 v1(95.46,78.3) ; U23.L16 v1(91.46,72.7) ; J2.E28 v1(40.26,132.35) ; U23.A1 v1(99.46,85.5) ; U23.AA1 v1(82.66,85.5) ; J2.A16 v1(55.5,127.27) ; C4.1 v1(100.97,125.87) ; U23.N13 v1(89.06,75.1) ; J2.B26 v1(42.8,128.54) ; J2.D30 v1(37.72,131.08) ; U53.3 v1(77.31,28.68) ; J2.A25 v1(44.07,127.27) ; U23.N11 v1(89.06,77.5) ; U23.P18 v1(88.26,71.1) ; v1(62.99,98.82) R65.2 ; v1(40.89,95.26) 40.16,95.26 C52.2 ; U23.U3 v1(85.86,83.9) ; R16.2 v1(50.53,120.27) ; J28.5 172.67,22.34 v1(172.34,22) ; J2.B25 v1(44.07,128.54) ; v1(136.04,77.34) R117.1 135.64,76.59 135.15,76.1 U25.3 ; C80.2 v1(32.51,80.62) ; v1(45.86,80.51) 45.92,80.57 C78.2 ; U23.K8 v1(92.26,79.9) ; v1(143.13,124.6) C6.2 C5.1 ; U23.M8 v1(89.86,79.9) ; C89.2 v1(51.05,89.75) ; J24.5 5.17,55.53 v1(5.23,55.59) ; v1(46.86,86.51) 46.86,86.88 R120.2 ; R102.2 v1(32.77,87.9) ; v1(85.98,49.67) 85.92,49.61 U37.8 ; 135.38,61.61 135.38,61.62 ; Q3.2 29.36,112 v1(29.34,112.03) ; U23.W18 v1(84.26,71.1) ; U57.3 v1(123.17,22.35) ; J2.C20 v1(50.42,129.81) ; v1(61.72,99.71) R61.2 ; 90.88,35.9 90.88,36 v1(91.06,36.18) 91.28,35.96 91.28,35.86 ; U23.T11 v1(86.66,77.5) ; C179.1 v1(120.15,22.89) ; U23.N15 v1(89.06,73.5) ; U7.4 v1(109.44,120.18) ; C29.2 v1(8.51,113.93) ; v1(163.41,55.48) C138.2 ; J2.A24 v1(45.34,127.27) ; U5.1 98.16,118.94 U5.11 ; C194.1 v1(108.56,15.06) ; U23.T15 v1(86.66,73.5) ; U23.M6 v1(89.86,81.5) ; C132.2 v1(167.36,57.41) ; v1(66.83,22.49) C181.2 67.32,23.74 U51.4 ; v1(59.18,99.71) R59.2 ; C155.1 v1(90.97,37.98) ; U23.H11 v1(93.86,77.5) ; C156.1 v1(92.85,35.68) ; C68.2 v1(42.47,87.98) ; J2.E5 v1(69.47,132.35) ; v1(153.15,55.1) 154,55.1 C136.2 ; R206.1 R207.1 157.78,9.2 v1(157.73,9.16) ; J2.C17 v1(54.23,129.81) ; J2.B18 v1(52.96,128.54) ; C104.2 v1(45.74,69.07) ; U23.C10 v1(97.86,78.3) ; C192.1 v1(143.65,15.01) ; U32.11 20.82,60.58 20.95,60.72 ; U17.4 148.8,94.88 148.41,95.26 v1(148.34,95.26) ; R151.2 v1(32.46,55.64) ; C109.2 v1(136.14,65.8) ; v1(39.46,71.98) 39.28,72.16 C101.2 ; v1(42.29,75.52) 42.29,76.19 ; v1(134.61,61.62) 134.61,62.72 Q6.2 ; U23.AA15 v1(82.66,73.5) ; R110.1 v1(32.82,79.12) ; C131.2 v1(156.96,55.94) ; U23.Y19 v1(83.46,70.3) ; v1(124.84,112.41) C30.1 125.49,113.06 125.73,113.3 U10.2 ; Q1.2 v1(125.29,124.15) ; C114.2 v1(32.38,64.5) ; Q7.2 v1(8.4,60.99) ; U44.J5 v1(118.37,36.35) ; C183.1 v1(80.01,21.74) ; C1.2 v1(9.04,128.52) ; 161.74,21.53 161.8,21.59 ; J2.E16 v1(55.5,132.35) ; U23.K6 v1(92.26,81.5) ; J2.B5 v1(69.47,128.54) ; U52.3 v1(71.72,28.68) ; U23.C3 v1(97.86,83.9) ; U60.12 v1(106.95,11.48) ; C177.1 163.78,24.3 ; J2.E25 v1(44.07,132.35) ; U23.E11 v1(96.26,77.5) ; R29.2 v1(77.36,112.43) ; J2.E20 v1(50.42,132.35) ; J2.B6 v1(68.2,128.54) ; U23.W10 v1(84.26,78.3) ; U23.E13 v1(96.26,75.1) ; U23.P6 v1(88.26,81.5) ; U23.L3 v1(91.46,83.9) ; J2.D10 v1(63.12,131.08) ; U23.N9 v1(89.06,79.1) ; U23.R9 v1(87.46,79.1) ; U23.H6 v1(93.86,81.5)
  TOP w0.279: U50.4 v1(126.62,28.58)
  TOP w0.305: C117.1 v1(131.68,63.02) ; C51.2 42.66,95.28 v1(42.72,95.34) ; v1(51.08,49.31) 51.21,49.44 C524.2 ; 138.05,23.51 138.05,22.36 ; C35.2 40.75,107.44 40.77,107.46 v1(40.79,107.46) ; U1.7 85.86,125.74 v1(85.85,125.74) ; v1(141.75,94.91) 141.6,94.76 C55.1 ; v1(33.44,38.22) 33.44,38.75 33.65,38.96 R401.1 ; v1(136.65,99.46) 136.91,99.19 U16.7 ; U14.2 127.12,105.55 127.37,105.81 v1(127.38,105.81) 127.62,105.57 U14.1 ; R683.2 v1(57.68,56.2) ; v1(126.11,98.82) 126.11,99.2 126.12,99.21 U14.7 ; C521.2 v1(52.35,49.26) ; v1(49.94,49.36) 50.05,49.47 C533.1 ; C529.1 v1(80.06,39.73) ; U11.7 142.49,108.72 v1(142.49,108.73) ; 42.12,55.44 42.19,55.37 ; v1(44.7,56.18) 44.72,56.2 R682.2 ; C31.1 v1(156.84,111.27) ; R140.1 v1(103.66,60.77) ; C44.2 45.99,99.12 v1(45.99,98.41) ; v1(148.72,118.89) 148.76,118.85 U6.1 ; U28.7 138.06,68.71 v1(137.92,68.85) ; R684.2 v1(56.79,52.41) ; 132.5,83.69 v1(132.5,82.7) ; C532.1 v1(47.16,49.36)
  TOP w0.381: v1(174.88,91.07) 174.86,91.09 LD6.1 174.86,92.11 ; C50.2 134.26,97.66 v1(134.28,97.68) ; U13.G8 v1(93.6,105.75) ; SW7.3 v1(141.14,11.02) ; C526.2 C523.2 C519.2 49.45,61.78 49.41,61.81 v1(49.41,62.06) v1(49.41,62.82) ; C32.2 140.82,111.38 v1(140.84,111.36) ; v1(168.66,26.68) 169.9,26.68 v1(169.9,27.93) ; SW6.5 131.58,15.93 131.55,15.9 v1(131.55,15.33) ; U4.2 21.97,119.4 22.11,119.25 C24.1 v1(21.21,118.63) ; C175.2 162.8,26.67 v1(162.94,26.81) ; C143.2 v1(20.47,43.88) ; C143.2 18.47,43.88 18.14,43.55 v1(18.14,42.05) ; C143.2 v1(18.64,45.76) ; C159.1 v1(166.99,34.29) ; C49.2 v1(144.78,98.31) ; v1(16.26,127.34) 16.26,127.34 C3.2 ; SW7.5 v1(138.89,19.27) ; U13.C9 v1(94.4,108.95) ; SW4.4 v1(119.24,16.54) ; R132.2 121.16,61.33 v1(121.13,61.31) ; SW5.5 124.28,16.86 v1(123.83,16.4) ; SW5.3 v1(126.53,11.02) ; C26.2 v1(54.36,115.58) ; SW5.4 v1(126.53,16.61) ; Q20.2 14.59,88.89 v1(15.01,89.31) ; v1(158.65,101.26) D2.2 v1(161.24,101.26) ; U102.3 v1(129.48,102.65) 129.47,102.64 ; R124.1 v1(119.27,70.35) ; v1(53.35,62.82) 53.35,62.06 52.83,62.06 52.46,61.69 C517.2 C522.2 C525.2 ; U41.2 v1(140.21,40.48) ; 161.84,15.64 161.96,15.52 C193.1 v1(163.19,15.52) ; v1(95,104.95) 94.6,104.55 U13.H9 ; v1(43.03,20.56) C184.2 v1(44.53,21.99) ; R565.2 v1(34.16,91.63) ; R631.1 v1(166.4,40.44) ; v1(41.43,55.44) 41.5,55.37 42.19,55.37 ; R26.1 v1(112.85,116.52) ; C185.1 v1(163.86,20.59) ; v1(88.72,56.35) 89.28,56.91 C120.2 ; C53.1 v1(75.82,93.74) ; v1(88.11,61.81) 88.23,61.7 C121.2 88.23,60.71 v1(88.11,60.59) ; U13.A8 v1(93.6,110.55) ; C171.1 138.92,29.23 v1(138.81,29.34) ; SW4.5 116.99,16.6 v1(116.02,15.64) ; U13.D8 v1(93.6,108.15) ; U13.M9 v1(94.4,100.95) ; v1(153.16,11.7) C196.1 153.16,12.65 152.91,12.9 ; Q4.2 v1(8.19,89.34) ; C42.1 86.03,100.29 86.16,100.15 v1(87.21,100.15) U13.N1 ; U29.2 122.43,68.59 v1(122.17,68.85) ; 143.89,23.76 143.89,23.4 143.51,23.02 C180.2 v1(142.39,23.02) ; U103.3 v1(121.18,108.88) ; U39.2 114.3,62.32 113.59,63.04 v1(113.59,63.8) ; C178.1 v1(118.29,51.25) ; C170.2 v1(116.44,29.59) ; v1(138.07,20.99) C188.1 138.07,22.35 138.05,22.36 ; 63.2,111.35 63.19,111.35 ; R205.2 v1(155.11,9.2) ; v1(54.76,50.12) 53.51,50.12 C509.2 53.47,50.12 52.37,50.12 C521.2 52.33,50.12 51.22,50.12 C524.2 ; C187.2 v1(166.41,20.63) ; v1(43.33,51.39) 43.39,51.45 44.28,51.45 44.55,51.18 C513.2 C520.2 C527.2 ; U34.8 34.11,48.07 v1(33.6,48.39) ; U13.T1 v1(87.21,97.75) ; C113.1 119.02,65.78 119,65.81 v1(118.97,65.81) 118.8,65.98 R606.2 ; U13.D2 v1(88.01,108.15) ; U31.3 v1(30.61,61.61) ; Q10.3 v1(124.44,20.86) ; C173.1 v1(120.65,28.72) ; C48.1 v1(143.51,98.31) ; U13.H1 v1(87.21,104.95) ; U13.E1 v1(87.21,107.35) ; C494.1 133.44,98.09 v1(133.42,98.07) ; SW7.4 v1(142.35,17.77) ; U13.K1 v1(87.21,102.55) ; U3.2 12.07,119.4 12.21,119.25 C23.1 v1(11.31,118.63) ; U13.E8 v1(93.6,107.35) ; v1(123.48,99.84) 123.46,99.82 C45.2 ; SW4.3 v1(119.24,11.21) ; C158.2 v1(163.85,34.29) ; v1(162.43,22.24) C191.2 161.8,21.59 ; C186.2 v1(165.15,20.59) ; U13.A2 v1(88.01,110.55) ; U54.3 v1(117.41,22.94) ; R198.2 v1(164.34,19.06) ; C151.1 v1(141.99,45.94) ; v1(46.23,53.37) 46.05,53.19 R681.2 ; C17.2 84.09,121.95 v1(84.07,121.97) ; R40.1 R45.2 v1(53.34,105.68) ; C485.1 v1(126.12,47.9) ; C479.2 v1(113.26,110.12) ; R68.1 v1(74.8,98.82) ; SW6.4 v1(133.83,16.3) ; U13.E9 v1(94.4,107.35) ; U13.F1 v1(87.21,106.55) ; C495.1 v1(124.06,102.73) ; 140.44,30.24 v1(139.45,30.24) ; 140.44,32.4 v1(139.58,32.4) ; U35.2 v1(126.75,51.97) ; C27.1 v1(106.62,116.39) ; SW6.3 v1(133.83,11.03) ; C128.2 v1(25.91,60.72) ; C174.2 v1(140.97,26.3) ; R630.1 v1(162.1,41.12) ; C8.2 v1(26.99,124.8) ; C166.2 v1(148.24,32.11) ; C176.2 v1(140.97,25.03) ; R8.1 v1(8.19,124.8) ; C189.1 v1(120.56,48.85) ; R9.1 v1(18.09,124.8) ; U13.B2 v1(88.01,109.75)
  TOP w0.508: C123.2 149.34,59.25 ; 149.34,59.25 v1(148.69,58.6) ; 149.34,59.25 149.06,59.25 v1(148.69,59.61) ; 15.76,10.68 LD25.1 v1(14.61,10.68)
  L05_PWR1 w0.114: TP63.1 119.38,80.74 119.66,80.46 120.75,80.46 121.51,79.69 121.51,78.88 119.13,76.49 119.13,74.72 111.82,67.41 111.67,67.41 109.07,64.81 97.71,64.81 94.79,67.73 90.73,67.73 89.81,68.65 89,68.65 87.86,69.79 87.86,71.21 87.86,71.21 87.86,74.47 88.09,74.7 88.43,74.7 88.66,74.93 88.66,76.2 88.82,76.37 89.4,76.37 v1(89.86,75.9) ; TP54.1 105.77,95.6 105.77,96.56 105.69,96.64 104.8,96.64 104.06,95.9 104.06,93.59 98.42,87.95 89.53,87.95 87.06,85.47 87.06,80.92 87.06,80.92 87.06,80.48 87.24,80.3 87.68,80.3 87.86,80.3 v1(88.26,79.9)
  BOTTOM w0.14: C372.2 90.57,74.31 90.68,74.42 90.68,74.62 90.93,74.88 90.93,75.37 C391.2 90.56,75.5 C475.2
  BOTTOM w0.203: U82.10 143.69,53.43 v1(143.89,53.23) 143.69,53.03 U82.11 ; U68.8 v1(77.34,116.22) ; U89.11 150.82,40.22 v1(150.62,40.02) 150.82,39.82 U89.10 ; v1(7.95,54.93) 7.78,54.76 U38.4 ; U100.2 14.44,17.4 14.44,16.45 C471.2 ; U89.1 153.15,40.9 153.16,40.91 153,41.07 U89.16 153,41.76 v1(153.16,41.92) ; U84.11 136.71,51.76 v1(136.91,51.96) 136.71,52.16 U84.10 ; v1(77.85,116.22) 77.74,116.33 U68.4 ; U82.1 141.62,52.48 141.77,52.33 U82.16 141.77,51.36 v1(141.6,51.2) ; v1(134.49,50.18) 134.78,50.47 U84.16 134.78,51.16 134.63,51.31 U84.1
  BOTTOM w0.254: R364.2 20.7,62.12 v1(21.08,61.74) ; R531.1 v1(9.62,19.92) ; R257.2 R262.1 v1(66.17,102.88) ; C275.2 40.86,95.23 v1(40.89,95.26) ; C457.1 v1(70.92,21.74) ; v1(117.62,38.85) 117.52,38.95 C430.2 ; U74.2 172.37,102.47 v1(172.34,102.5) ; v1(95.46,79.9) 95.58,80.02 C314.2 ; C206.2 72.63,121.16 v1(72.52,121.05) ; C438.2 119.71,37.16 v1(119.64,37.09) ; R645.2 v1(95.35,57.95) ; C375.2 v1(86.66,73.5) ; v1(37.34,57.1) R385.2 37.34,57.77 36.39,57.77 R386.2 ; v1(91.46,72.7) 91.47,72.7 C381.2 ; C389.2 45.74,68.37 v1(45.74,69.07) ; C359.2 96.38,75.22 v1(96.26,75.1) 96.01,75.35 C361.2 ; v1(2.67,27.07) 2.79,26.94 C448.2 v1(3.83,28.31) ; v1(31.74,82.3) 31.74,81.95 C305.2 31,81.95 v1(31,82.3) ; C397.2 v1(32.38,64.5) ; C302.2 93.74,81.62 v1(93.86,81.5) ; C349.2 39.41,75.95 v1(39.59,76.13) ; v1(105.5,76.77) 104.83,77.44 C299.2 104.64,78.32 C300.2 ; R430.2 34.04,41.92 v1(33.91,42.05) ; v1(93.06,79.1) 93.18,78.98 C329.2 ; U62.3 89.39,128.9 v1(89.41,128.92) ; v1(56.77,34.69) 56.99,34.91 57.79,34.91 U91.25 ; C322.2 93.98,79.78 v1(93.86,79.9) 93.74,80.02 C317.2 ; v1(71.86,101.98) 72.1,101.74 R268.2 ; v1(156.84,105.55) 156.84,106.28 R49.2 ; J38.16 v1(75.91,15.06) ; C277.2 v1(131.7,96.41) ; U87.13 v1(136.45,44.94) ; C238.2 39.25,107.38 v1(39.4,107.52) ; v1(10.92,25.16) C449.2 C450.2 ; v1(47.16,49.36) 45.37,47.57 C147.2 ; v1(86.66,79.9) 86.78,80.03 C319.2 ; v1(93.06,74.3) 92.81,74.55 C368.2 ; v1(93.06,74.3) 93.18,74.18 C373.2 ; v1(93.06,74.3) C370.2 ; U97.6 59.55,20.95 59.53,20.97 59.53,21.16 59.44,21.26 v1(59.44,21.73) 59.55,21.84 U97.5 ; R555.1 v1(58.17,12.46) ; C416.1 v1(131.35,46.5) ; v1(74.93,121.68) 75.46,121.15 C208.2 ; U81.13 v1(71.39,56.39) ; C388.2 73.15,69.98 v1(73.33,69.8) ; v1(77.75,79.32) 77.98,79.55 C340.2 ; v1(174.24,96.66) C271.1 173.35,97.31 173.32,97.34 U74.4 ; C266.2 45.96,98.44 v1(45.99,98.41) ; R436.2 v1(7.87,39.89) ; R636.2 v1(85.26,24.94) ; C432.2 v1(9.53,40.15) ; R251.2 41.87,107.46 v1(40.79,107.46) ; C241.2 93.48,105.87 v1(93.6,105.75) ; J36.8 v1(4.45,19.31) ; C88.2 72.53,73.85 v1(72.77,73.61) 72.94,73.78 R338.2 ; C119.2 107.06,72.48 v1(107.31,72.23) ; R283.2 v1(126.49,97.04) ; v1(77.09,79.39) 76.71,79.77 C327.2 ; v1(80.07,107.14) 80.79,106.42 C244.2 ; C401.2 v1(42.34,60.13) ; R445.1 153.42,35.99 v1(153.24,35.81) ; C420.1 v1(131.35,44.97) ; C232.2 94.52,107.47 v1(94.4,107.35) ; R359.2 R363.2 v1(45.75,63.52) ; v1(87.46,79.1) 87.34,79.22 C326.2 ; C385.2 39.22,72.22 v1(39.46,71.98) ; R605.2 72.84,72.5 v1(73.28,72.06) ; U79.12 v1(64.02,69.75) ; C344.2 88.94,77.38 v1(89.06,77.5) 89.18,77.62 C339.2 ; C407.1 v1(138.7,52.73) ; v1(118.62,33.26) 118.73,33.16 C443.2 ; v1(89.06,80.7) 88.94,80.82 C312.2 ; v1(45.74,67.61) 45.8,67.55 C394.2 ; U90.3 108.97,35.95 v1(109.09,35.83) 109.2,35.72 R453.2 ; C252.1 v1(66.05,101.61) ; C278.2 C279.2 108.4,95.87 C285.2 108.43,96.55 107.9,97.07 107.24,97.07 TP54.1 ; R474.2 v1(89.95,25) ; v1(2.24,90.67) C295.2 2.24,89.74 v1(3.52,89.74) ; Q21.2 16.25,85.81 16.59,85.47 v1(16.59,84.96) ; R541.1 11.3,17.29 v1(11.56,17.54) ; C260.2 56.75,100.83 v1(56.77,100.85) ; C261.2 v1(32.64,99.98) ; R61.2 v1(61.72,99.71) ; C224.2 88.13,109.87 v1(88.01,109.75) ; R518.2 R513.2 R509.2 R502.2 R497.2 ; R518.2 R528.2 ; R518.2 v1(110.57,23.41) ; C301.2 v1(32.51,82.12) ; U93.3 79.65,27.55 v1(80.06,27.14) ; C462.1 v1(7.47,19.46) ; Q19.2 v1(96.86,17.37) ; J33.61 v1(63.63,44.08) J33.62 v1(69.85,44.08) J33.63 J33.64 ; v1(87.21,104.95) 87.09,105.07 C242.2 ; C371.2 v1(89.06,75.1) ; v1(89.06,75.1) 88.82,74.86 C357.2 ; v1(89.06,75.1) 88.94,75.22 C362.2 ; R322.2 97.91,78.36 v1(97.86,78.3) ; v1(48.34,99.62) C263.2 v1(47.46,98.83) ; v1(93.06,80.7) 93.18,80.82 C310.2 ; C395.2 v1(32.38,66) ; v1(88.65,127.01) 88.66,127 C200.2 ; C313.2 v1(32.51,80.62) ; R622.1 78.44,75.61 R333.2 ; C289.2 94.01,77.65 v1(93.86,77.5) 93.74,77.38 C347.2 ; v1(48.59,80) C316.2 v1(47.71,79.22) ; v1(93.6,110.55) 93.72,110.67 C222.2 ; v1(124.21,92.85) 126.11,92.85 126.9,93.64 U76.2 ; R349.1 v1(32.69,69) ; C220.2 45.82,113.84 v1(45.72,113.93) ; J33.57 v1(76.72,45.49) ; U70.16 62.89,104.56 v1(63.12,104.79) 62.85,105.06 U70.15 ; C437.2 v1(118.89,37.87) ; v1(20.85,38.48) C435.2 C436.2 ; C423.1 149.95,41.92 v1(149.97,41.94) ; R554.1 v1(93.95,13.27) ; U87.35 148.06,45.44 C419.1 148.74,45.46 v1(148.84,45.35) ; U70.9 62.24,108.61 v1(62.48,108.85) ; v1(31.63,39.76) 31.86,39.98 R437.1 ; U74.6 171.42,99.66 171.74,99.97 v1(172.59,99.97) ; C465.1 123.83,17.3 v1(123.83,16.4) ; C398.2 88.72,61.2 v1(88.11,60.59) ; C431.2 v1(11.05,40.15) ; R65.2 v1(62.99,98.82) ; C376.2 95.28,73.68 v1(95.46,73.5) 95.58,73.62 C374.2 ; C311.2 91.58,80.82 v1(91.46,80.7) 91.34,80.82 C308.2 ; C415.2 C418.2 v1(99.31,45.08) ; C400.2 93.32,68.59 v1(93.44,68.46) ; C320.2 v1(45.86,79.04) ; v1(70.23,65.55) 70.36,65.67 R356.1 ; J33.16 66.22,39.44 v1(66.17,39.38) ; C253.2 v1(32.64,101.48) ; U87.25 140.97,47.26 v1(140.97,47.26) ; C378.2 88.82,73.26 v1(89.06,73.5) ; v1(132.33,55.13) 132.44,55.24 R400.1 v1(133.73,55.24) ; C259.2 v1(45.99,99.87) ; v1(89.06,73.5) 89.18,73.62 C379.2 ; v1(89.06,73.5) C396.2 ; Q18.2 v1(99.18,15.24) ; R292.2 v1(57.52,95.01) ; C298.2 87.29,80.87 v1(87.46,80.7) ; R301.2 v1(28.13,88.83) ; R563.2 v1(34.04,56.99) ; C424.1 v1(154.69,42.81) ; v1(33.66,10.05) 33.93,10.33 J37.13 ; v1(142.75,35.45) 143.11,35.81 143.23,35.81 143.47,36.04 U87.51 ; C284.2 v1(56.75,91.35) ; v1(88.26,78.3) 88.14,78.42 C333.2 ; C399.2 87.76,62.17 v1(88.11,61.81) ; C428.2 v1(115.06,40.33) C427.2 ; J37.6 v1(39,23.14) ; R218.2 57.06,119.68 v1(56.64,119.27) ; v1(117.12,38.1) 116.15,38.1 R444.1 ; C493.2 105.28,66.56 v1(104.75,66.56) ; Q12.2 v1(28.43,110.65) ; v1(92.26,81.5) 92.14,81.62 C303.2 ; v1(89.86,78.3) 89.74,78.42 C332.2 ; U94.3 73.62,26.76 v1(74.17,26.21) ; C442.1 v1(139.97,34.32) ; C337.2 96.14,77.62 v1(96.26,77.5) 96.14,77.38 C343.2 ; U70.21 59.44,103.01 v1(59.56,102.88) ; R240.2 v1(43.05,112.93) ; C221.1 135.74,112.65 v1(135.76,112.66) ; v1(141.32,58.05) 141.08,57.81 C403.2 ; R532.1 v1(98.9,19.86) U96.25 ; v1(139.19,56.15) 139.45,55.89 R397.1 ; R241.2 v1(49.78,110.12) ; C406.2 v1(171.43,54.61) ; C463.1 v1(7.47,18.14) ; R249.2 v1(43.64,108.22) ; C297.2 v1(32.43,83.62) ; R549.1 v1(103.8,17.4) ; 80.39,15.51 80.41,15.49 J38.7 ; v1(94.49,86.5) 94.31,86.68 94.31,88.21 94.49,88.39 94.49,94.61 94.54,94.67 94.54,95.58 94.49,95.63 94.49,95.93 94.11,96.31 C270.1 ; v1(87.21,107.35) 87.09,107.47 C233.2 ; v1(88.26,79.9) 88.34,79.99 C315.2 ; C227.1 86.28,108.87 C228.2 v1(85.47,108.35) R247.2 ; R497.2 R488.2 ; R497.2 v1(105.49,23.41) ; Q11.2 v1(26.7,122.79) ; v1(78.36,18.67) 78.35,18.66 R638.2 ; v1(103.38,66.31) 102.85,66.31 102.6,66.56 C492.2 ; C276.2 v1(48.41,94.77) ; C318.2 92.14,80.02 v1(92.26,79.9) ; U71.2 v1(71.12,102.5) ; U100.2 15.04,18.1 v1(15.37,18.43) ; C234.2 v1(73.13,108.07) ; J38.34 v1(66.91,15.06) ; J37.11 33.83,20.13 v1(33.78,20.08) ; C451.2 39.64,26.18 39.46,26 v1(39.46,25.48) ; D7.1 v1(4.89,37.03) ; U66.3 109.59,119.53 109.44,119.67 v1(109.44,120.18) U7.4 ; C309.2 89.98,81.38 v1(89.86,81.5) ; C404.2 v1(79.99,57.4) ; C412.1 v1(139.43,50.92) 140.24,50.92 C409.1 ; R468.2 144.91,31.34 v1(144.87,31.38) ; v1(87.21,97.75) 87.09,97.87 C268.2 ; U81.12 v1(71.39,54.89) ; R691.2 116.2,109.35 115.94,109.6 v1(115.01,109.6) 115.01,108.92 114.45,108.35 U106.2 ; C383.2 92.83,72.94 v1(93.06,72.7) ; v1(11.61,88.06) 11.56,88.11 C287.2 11.83,89.42 12.19,89.42 12.22,89.39 12.67,89.39 v1(13.03,89.03) ; C304.2 88.38,81.62 v1(88.26,81.5) ; U70.25 56.23,104.56 v1(56.01,104.79) 56.28,105.06 U70.26 ; U87.47 v1(144.96,39.44) ; C209.2 v1(102.69,122.48) ; R304.2 v1(4.57,90.01) ; v1(176.5,104.5) 176.42,104.41 C245.2 R260.2 ; v1(94.4,108.95) 94.52,109.07 C229.2 95.17,109.07 95.38,108.87 95.38,108.47 95.54,108.31 C230.2 ; C325.2 88.94,79.22 v1(89.06,79.1) ; v1(99.95,81.1) 100.11,80.95 R320.2 ; C213.1 v1(73.53,117.36) ; C429.1 v1(156.34,39.77) ; C535.2 v1(108.61,107.97) ; C306.2 v1(45.86,80.51) ; C444.1 v1(60.43,31.15) ; v1(165.23,9.03) 164.72,9.54 R561.2 ; U86.2 32.51,44.85 32.89,44.46 v1(33.53,44.46) ; C352.2 C390.2 ; C392.2 v1(32.38,67.5) ; v1(87.21,102.55) 87.09,102.67 C250.2 ; R299.2 v1(13.98,89.39) ; J38.40 v1(63.91,15.1) ; C413.1 v1(145.67,50.05) ; C331.2 95.21,78.55 v1(95.46,78.3) 95.58,78.42 C328.2 ; U70.4 59.44,107.83 v1(59.69,107.58) ; U85.3 v1(107.13,42.81) ; C446.2 46.5,29.75 v1(46.61,29.64) ; R254.1 v1(66.17,105.42) ; v1(88.01,110.55) 87.89,110.67 C223.2 ; C323.2 89.98,79.78 v1(89.86,79.9) ; R53.2 v1(53.59,103.52) ; v1(117.14,74.64) 116.71,75.07 C365.2 ; v1(10.14,10.19) C474.2 v1(8.64,8.9) ; R405.2 v1(105.54,53.23) ; C382.2 v1(94.66,72.7) ; R59.2 v1(59.18,99.71) ; C249.2 v1(32.64,102.98) ; U77.2 46.41,93.68 v1(46.74,93.36) ; v1(58.8,35.7) 59.07,35.43 R452.1 ; C360.2 87.34,75.78 v1(87.46,75.9) 87.58,76.02 C356.2 ; v1(70.23,120.03) 70.54,120.33 U63.2 ; C350.2 86.38,76.94 86.66,77.21 v1(86.66,77.5) ; U87.10 133.86,43.44 133.49,43.81 C422.1 v1(132.1,43.81) ; U66.1 v1(112.07,120.83) ; v1(42.47,87.98) 42.44,88.01 C293.2 ; U87.11 v1(136.45,43.94) ; v1(37.49,74.82) C369.2 ; C307.2 94.78,80.82 v1(94.66,80.7) ; C330.2 91.34,78.98 v1(91.46,79.1) 91.58,79.22 C324.2 ; R315.2 v1(113.82,76.37) ; J38.25 v1(71.41,15.06) ; C355.2 89.74,76.02 v1(89.86,75.9) 90.18,75.58 C475.2 ; Q13.2 v1(32.62,94.11) ; v1(87.21,106.55) 87.33,106.67 C239.2 ; v1(31.13,101.66) 31.13,101.31 C258.2 31.87,101.31 v1(31.87,101.66) ; C358.2 v1(81.39,77.25) ; C470.1 v1(25.65,16.27) ; v1(94.66,79.1) 94.78,79.22 C321.2 ; U87.1 v1(136.33,38.94) ; U87.5 v1(136.37,40.94) ; v1(77.36,112.43) 77.57,112.64 C218.2 ; 143.74,104.11 142.82,103.19 U72.2 142.49,102.86 v1(142.49,102.76) ; U79.11 v1(64.49,68.77) ; v1(144.63,32.46) 144.5,32.59 C441.2 ; Q14.2 v1(10.27,68.43) ; v1(56.26,108.22) 56.42,108.06 U70.32 ; R60.2 v1(60.45,99.71) ; C236.2 93.72,107.23 v1(93.6,107.35) ; C433.2 v1(132.33,37.56) C439.2 ; C405.2 v1(79.99,54.01) ; Q15.2 v1(1.49,73.19) ; v1(37.79,93.8) C281.2 ; v1(57.53,21.73) 57.55,21.75 U97.1 ; C473.2 v1(10.54,15.76) ; U87.15 v1(136.45,45.94) ; R409.1 v1(64.64,51.83) ; U81.11 72.46,53.92 72.26,54.12 v1(72.24,54.12) ; C425.1 v1(133.59,41.91) ; C456.1 v1(76.51,21.74) ; R341.2 v1(41.15,72.6) ; R473.2 v1(105.15,24.97) ; C380.2 v1(86.66,72.7) ; R346.2 R623.1 ; C421.2 v1(27.05,42.94) ; v1(44.83,107.33) 44.9,107.4 U69.3 ; Q16.2 v1(2.49,79.07) ; R245.2 v1(68.83,107.58)
  BOTTOM w0.279: U98.8 v1(129.35,56.95) ; U98.9 v1(129.35,55.45)
  BOTTOM w0.305: v1(40.79,107.46) 40.77,107.46 40.7,107.39 40.18,107.39 C237.2 ; C274.2 v1(42.72,95.34) ; v1(50.19,51.39) 50.46,51.66 50.46,52.59 50.53,52.66
  BOTTOM w0.33: C338.2 93.74,77.1 C347.2 ; C345.2 C346.2 91.18,76.95 C342.2 ; C390.2 C351.2 ; C353.2 C352.2
  BOTTOM w0.381: v1(132.33,48.44) 133.2,48.44 C414.1 ; R294.2 v1(158.1,93.5) ; C180.2 v1(142.39,23.02) ; C434.2 v1(104.27,36.72) ; C225.1 C226.1 ; C226.1 C34.1 ; C226.1 64.77,110.62 65.04,110.89 v1(65.41,110.89) ; C417.2 v1(110.87,44.89) ; C440.1 v1(135.4,34.58) ; v1(83.19,23.43) R529.2 R519.2 R514.2 R510.2 R503.2 R498.2 ; v1(100.9,62.94) 100.73,63.11 C491.2 ; C466.1 v1(132.47,16.53) ; J37.10 47.05,24.33 v1(47.88,23.5) ; R367.2 v1(27.32,61.85) ; v1(114.48,16.45) 114.63,16.6 D11.1 ; U83.5 117.43,51.62 v1(117.35,51.7) ; Q9.3 v1(128.42,20.99) ; R263.1 145.53,102.88 v1(145.53,103.64) ; C445.1 v1(126.64,31.49) ; C467.1 v1(116.02,16.71) ; v1(67.56,70.5) 66.81,71.25 U79.13 ; C291.2 C292.2 117.36,79.49 C296.2 117.98,79.44 119.41,80.87 119.41,81.47 119.38,81.5 TP63.1 ; R507.1 v1(122.89,60.12) ; C468.1 v1(138.29,16.16) ; U99.2 24.38,22.34 C455.2 24.74,22.26 25.16,22.26 v1(25.4,22.49) ; C267.2 C264.2 C254.2 C251.2 C246.2 C244.2 ; U67.8 v1(47.37,115.75) ; C408.1 v1(130.94,51.83) ; U64.2 38.66,117.1 38.35,116.79 C216.2 37.61,116.08 v1(36.9,116.8) ; v1(123.14,58.61) C461.1 ; v1(132.08,91.96) 132.06,91.98 C283.1 ; v1(110.51,110.16) C534.1 111.52,110.16 ; v1(112.85,116.52) 112.6,116.28 U66.8 ; U92.5 v1(128.31,28.38) ; C447.1 v1(160.99,31.34) ; D9.1 v1(129.29,16.65) ; C212.2 70.23,119.46 v1(70.23,120.03) ; U95.1 v1(148.86,24.65) ; v1(136.8,15.86) 136.8,16.7 136.73,16.78 D10.1 ; R498.2 R489.2 ; R498.2 v1(89.53,23.41) ; U88.3 v1(39.18,44.02) ; C294.2 101.09,87.14 ; C426.2 v1(34.69,40.76) ; C410.1 v1(113.54,52.15) ; C207.1 43.79,122.33 v1(43.81,122.34) ; C464.1 v1(123.89,52.49) ; R371.2 v1(29.21,60.21) ; C411.1 v1(60.96,49.42) ; D8.1 v1(121.92,16.35)
  BOTTOM w0.457: C211.2 142.44,118.79 U65.5 ; J37.14 48.22,9.16 v1(50.04,9.16) ; C488.2 107.41,85.79 107.29,85.67 ; C377.2 v1(117.16,73.8)
  BOTTOM w0.508: J37.12 33.85,13.93 v1(33.78,13.86) ; C487.2 113.39,79.98 v1(114.12,79.25) ; C384.2 C388.2
  vias: v1(1.63,63.57) v1(13.21,16.78) v1(13.21,15.13) v1(14.61,15.13) v1(15.37,23.51) v1(16.21,47.77) v1(17.02,23.38) v1(17.02,21.86) v1(17.42,47.77) v1(18.64,47.77) v1(19.86,47.77) v1(20.65,50.69) v1(20.78,49.29) v1(21.08,62.75) v1(21.08,47.77) v1(21.08,46.75) v1(22.1,62.75) v1(22.1,61.74) v1(22.1,47.77) v1(22.43,49.29) v1(22.45,34.85) v1(22.9,37.61) v1(23.11,61.74) v1(24.81,27.75) v1(26.81,26.18) v1(27.97,27.98) v1(29.32,25.81) v1(29.53,40.04) v1(29.72,43.43) v1(29.94,45.1) v1(29.97,114.82) v1(29.97,113.81) v1(30.48,115.97) v1(30.51,27.94) v1(30.56,50.56) v1(30.86,24.26) v1(30.99,114.82) v1(30.99,113.93) v1(31.01,38) v1(31.35,47.22) v1(31.57,49.29) v1(31.7,50.56) v1(31.77,42.29) v1(31.86,25.81) v1(32.84,52.08) v1(33.05,27.94) v1(33.48,52.08) v1(33.66,46.52) v1(34.11,52.08) v1(34.16,23.5) v1(35.34,123.2) v1(35.34,122.19) v1(36.19,46.72) v1(36.36,123.2) v1(36.36,122.19) v1(37.08,23.11) v1(37.31,83.71) v1(37.31,82.49) v1(37.31,81.27) v1(37.31,80.05) v1(37.34,41.27) v1(37.38,123.2) v1(37.38,122.19) v1(37.47,103.01) v1(37.47,101.23) v1(37.47,99.46) v1(37.59,67.64) v1(37.59,66.25) v1(37.59,64.85) v1(37.72,37.72) v1(38.53,83.71) v1(38.53,82.49) v1(38.53,81.27) v1(38.53,80.05) v1(38.68,49.49) v1(38.73,46.72) v1(38.99,67.64) v1(38.99,66.25) v1(38.99,64.85) v1(39.24,103.01) v1(39.24,101.23) v1(39.24,99.46) v1(39.75,83.71) v1(39.75,82.49) v1(39.75,81.27) v1(39.75,80.05) v1(39.93,39.17) v1(40.21,40.56) v1(40.39,67.64) v1(40.39,66.25) v1(40.39,64.85) v1(40.74,44.22) v1(40.89,49.61) v1(41.02,103.01) v1(41.02,101.23) v1(41.02,99.46) v1(40.97,83.71) v1(40.97,82.49) v1(40.97,81.27) v1(40.97,80.05) v1(41.07,41.2) v1(42.14,44.5) v1(42.42,46.71) v1(42.7,51.39) v1(43.31,45.8) v1(43.97,51.39) v1(44.07,96.72) v1(44.5,50.37) v1(44.89,91.58) v1(45.02,90.69) v1(45.19,48.51) v1(45.47,96.72) v1(45.47,95.07) v1(46.25,45.62) v1(46.46,50.24) v1(47.04,25.77) v1(48.46,43.59) v1(48.9,26.54) v1(49.41,63.58) v1(49.61,39.04) v1(49.96,55.88) v1(50.11,53.7) v1(50.16,24.77) v1(50.67,63.73) v1(51.13,54.71) v1(51.13,53.7) v1(51.36,44.88) v1(51.89,65.48) v1(52.02,47.78) v1(52.15,55.6) v1(52.15,54.71) v1(52.15,53.7) v1(52.45,99.46) v1(52.45,98.31) v1(52.45,96.03) v1(52.45,94.88) v1(52.45,93.74) v1(52.45,92.6) v1(52.64,61.1) v1(52.63,58.56) v1(52.98,64.26) v1(53.09,39.04) v1(53.24,62.1) v1(53.19,42.15) v1(53.34,46.79) v1(53.39,67.01) v1(53.35,63.58) v1(53.72,34.69) v1(53.72,33.16) v1(53.72,31.64) v1(53.72,26.05) v1(53.72,25.03) v1(53.72,24.02) v1(54.61,44.25) v1(54.69,65.73) v1(54.74,26.05) v1(54.74,25.03) v1(54.74,24.02) v1(54.83,61.54) v1(54.75,59) v1(54.94,45.62) v1(55.09,47.9) v1(55.19,68.55) v1(55.24,34.69) v1(55.24,33.16) v1(55.24,31.64) v1(55.35,50.09) v1(55.8,64.14) v1(55.98,42.21) v1(56.48,67.53) v1(56.64,118.12) v1(56.64,116.98) v1(56.64,47.93) v1(56.74,45.87) v1(56.72,41.02) v1(56.77,33.16) v1(56.77,31.64) v1(56.89,44.58) v1(57.04,58.77) v1(57.12,70.74) v1(57.56,65.72) v1(57.61,56.87) v1(57.78,119.27) v1(57.78,118.12) v1(57.78,116.98) v1(58.24,56.96) v1(58.28,69.32) v1(58.42,107.58) v1(58.42,106.31) v1(58.42,105.04) v1(58.37,53.9) v1(58.55,21.73) v1(58.72,39.98) v1(58.93,119.27) v1(58.93,118.12) v1(58.93,116.98) v1(59.08,72.59) v1(59.05,55.89) v1(59.69,106.31) v1(59.69,105.04) v1(60.54,11.13) v1(60.54,10.12) v1(60.96,107.58) v1(60.96,106.31) v1(60.96,105.04) v1(61.5,12.24) v1(61.5,9.01) v1(61.9,73.08) v1(61.93,70.46) v1(62.52,12.24) v1(62.52,9.01) v1(65.53,70.5) v1(66.55,70.5) v1(68.43,30.49) v1(68.58,70.5) v1(69.6,70.5) v1(69.7,73.61) v1(72.9,55.64) v1(73.53,113.3) v1(73.66,119.27) v1(73.79,121.05) v1(73.91,114.7) v1(73.91,55.64) v1(74.55,113.04) v1(74.93,55.64) v1(75.18,72.28) v1(75.31,116.09) v1(75.9,71.68) v1(75.95,55.64) v1(76.83,116.22) v1(76.96,55.64) v1(77.09,78.17) v1(77.22,77.1) v1(77.67,69.88) v1(78.21,72.69) v1(78.31,78.17) v1(78.64,69.88) v1(78.74,77.1) v1(78.89,108.79) v1(78.99,116.35) v1(79.32,107.95) v1(79.63,119.01) v1(79.78,17.61) v1(79.78,16.59) v1(79.78,15.58) v1(80.01,117.87) v1(80.47,107.7) v1(80.61,121.56) v1(80.8,17.61) v1(80.8,16.59) v1(80.8,15.58) v1(80.87,72.06) v1(81.04,61.06) v1(81.05,73.33) v1(81.38,34.67) v1(81.8,61.5) v1(84.8,12.24) v1(84.8,9.01) v1(85.82,12.24) v1(85.82,9.01) v1(86.78,11.13) v1(86.78,10.12) v1(86.94,48.86) v1(87.88,49.67) v1(87.88,48.15) v1(90.04,128.92) v1(90.68,128.92) v1(92.46,132.22) v1(92.46,127.14) v1(93.34,132.22) v1(93.34,130.95) v1(93.34,126.76) v1(95.75,24.76) v1(95.75,23.36) v1(95.75,21.97) v1(97.15,24.76) v1(97.15,23.36) v1(98.42,57.23) v1(98.55,24.76) v1(98.55,23.36) v1(98.55,21.97) v1(99.31,117.59) v1(99.31,116.57) v1(99.31,115.56) v1(100.33,117.59) v1(100.33,116.57) v1(100.33,115.56) v1(100.38,55.26) v1(100.84,59.39) v1(102.23,90.69) v1(102.23,89.47) v1(102.23,88.25) v1(102.87,57.29) v1(104.23,56.53) v1(104.28,76.77) v1(105.33,68.63) v1(105.5,83.52) v1(105.5,82.81) v1(106.72,82.81) v1(106.72,76.77) v1(107.94,76.77) v1(109.09,76.72) v1(110.38,76.77) v1(110.46,91.22) v1(111.38,95.87) v1(112.64,95.87) v1(114.05,89.17) v1(118.36,73.37) v1(118.36,72.15) v1(121.92,102.62) v1(122.56,101.6) v1(125.55,56.96) v1(125.55,55.44) v1(126.57,56.2) v1(127.46,56.83) v1(127.58,55.44) v1(131.21,77.88) v1(131.34,79.53) v1(132.1,77.88) v1(132.36,79.53) v1(132.61,80.55) v1(132.84,60.85) v1(132.86,77.88) v1(133.73,60.85) v1(134.24,59.96) v1(136.65,60.59) v1(140.84,99.33) v1(140.84,97.8) v1(141.92,57.23) v1(141.99,97.8) v1(142.62,98.57) v1(143.26,106.06) v1(144.37,116.04) v1(144.4,115.05) v1(144.4,114.13) v1(144.65,106.06) v1(144.65,104.41) v1(145.57,14.02) v1(146.43,101.49) v1(146.43,100.47) v1(146.43,99.46) v1(146.43,98.44) v1(146.81,91.07) v1(146.81,90.31) v1(146.81,89.42) v1(147.32,95.26) v1(147.32,93.49) v1(147.45,101.49) v1(147.45,100.47) v1(147.45,99.46) v1(147.45,98.44) v1(148.34,93.49) v1(148.26,80.91) v1(148.26,79.9) v1(149.06,77.09) v1(149.28,80.91) v1(149.28,79.9) v1(150.07,77.09) v1(150.22,60.81) v1(151.61,85.83) v1(152.76,86.81) v1(152.76,85.79) v1(153.77,86.81) v1(153.77,85.79) v1(153.77,84.77) v1(154.79,86.81) v1(154.79,85.79) v1(154.79,84.77) v1(155.32,105.55) v1(155.68,86.81) v1(155.68,85.79) v1(155.68,84.77) v1(156.08,105.55) v1(156.24,80.03) v1(158.88,109.87) v1(158.88,108.85) v1(158.88,107.84) v1(158.88,106.82) v1(159.89,109.87) v1(159.89,108.85) v1(159.89,107.84) v1(159.89,106.82) v1(160.91,62.24) v1(160.91,61.23) v1(160.91,60.21) v1(161.93,62.24) v1(161.93,60.21) v1(162.81,86.76) v1(162.81,85.74) v1(162.81,84.72) v1(162.94,62.24) v1(162.94,61.23) v1(163.83,86.76) v1(163.83,85.74) v1(163.83,84.72) v1(163.88,23.92) v1(164.95,86.68) v1(165.23,37.61) v1(165.74,37.61) v1(165.96,86.68) v1(166.12,14.75) v1(166.12,9.67) v1(166.24,37.61) v1(166.98,86.68) v1(166.98,85.66) v1(166.98,84.65) v1(167.13,14.87) v1(167.77,12.59) v1(167.77,10.56) v1(167.87,86.68) v1(167.87,85.66) v1(167.87,84.65) v1(168.85,45.61) v1(169.04,12.59) v1(169.04,10.56) v1(169.61,46.37) v1(170.79,33.09) v1(172.01,33.09) v1(173.23,34.3) v1(173.23,33.09) v1(173.53,105.28) v1(173.71,104.17) v1(173.71,103.15) v1(174.04,100.63) v1(174.04,99.62) v1(174.04,98.6) v1(174.32,108.5) v1(174.32,107.23) v1(174.32,105.96) v1(174.55,105.28) v1(175.06,100.63) v1(175.06,99.62) v1(175.06,98.6) v1(175.59,108.5) v1(175.59,107.23) v1(175.59,105.96) v1(175.56,105.28) v1(176.5,108.52) v1(176.5,107.25) v1(176.5,105.98)
