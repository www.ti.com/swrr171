# Allegro board PROC101B_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XDS_USB_ID: length 22.2
  TOP w0.147: U58.2 v1(169.16,23.38)
  TOP w0.254: J28.4 172.32,22.99 v1(171.96,22.62)
  BOTTOM w0.147: v1(169.16,23.38) 169.93,23.38 170.69,22.62 v1(171.96,22.62) 172.72,22.62 173.23,23.13 173.23,25.03 172.47,25.8 168.54,25.8 166.89,27.44 R478.2
XDS_USB_VBUS: length 6.4
  TOP w0.147: U58.6 170.5,24.31 170.43,24.38 v1(170.43,24.83)
  TOP w0.254: U61.2 166.02,11.9 165.61,12.31 v1(165.61,12.59) ; U61.8 v1(171.03,12.55) ; v1(172.47,25.14) 172.67,24.94 J28.1
  BOTTOM w0.254: R467.1 162.22,31.34 v1(162.26,31.38) ; v1(143.64,31.38) 143.68,31.34 R469.1
  vias: v1(164.47,13.6) v1(164.59,12.84)
N5126260: length 13.1
  TOP w0.147: U15.13 36.49,97.14 36.39,97.04 v1(35.94,97.04) ; U15.48 v1(35.81,104.73) 34.28,104.73 TP11.1
  L03_SIG1 w0.091: v1(35.94,97.04) 35.94,97.48 35.81,97.61 v1(35.81,104.73)
N15202140: length 2.3
  TOP w0.147: U59.95 v1(159.3,27.53)
  BOTTOM w0.147: R478.1 159.39,27.44 v1(159.3,27.53)
N15204440: length 14.2
  TOP w0.254: U61.5 169.95,8.93 169.21,8.19 163.53,8.19 162.94,8.78 162.94,9.52 C198.2 R204.2 v1(162.05,10.81)
  BOTTOM w0.254: v1(162.05,10.81) 162.05,9.84 162.35,9.54 C198.2
N15205319: length 3.2
  TOP w0.147: U59.68 161.72,16.73 161.95,16.5 C193.2 163.29,16.5 163.31,16.52 R200.1
N15212041: length 4.2
  TOP w0.147: U59.59 157.15,13.01 155.56,11.41 155.56,11.17 R205.1
N15239696: length 3.2
  TOP w0.147: U59.96 160.65,28.58 v1(160.91,28.84)
  BOTTOM w0.147: v1(160.91,28.84) 160.91,28.89 160.99,28.97 C447.2 R467.2
N15241750: length 3.2
  TOP w0.147: v1(145.03,28.84) 145.25,28.63 U59.1
  BOTTOM w0.147: v1(145.03,28.84) 144.91,28.97 R468.1 R469.2
N15242949: length 6.6
  TOP w0.147: v1(140.95,28.49) 141.48,27.95 143.38,27.95 144.21,27.13 U59.3
  BOTTOM w0.147: R466.1 v1(140.95,28.49)
N15242980: length 2.7
  TOP w0.147: v1(141.99,28.97) 142.19,29.18 LD22.2
  BOTTOM w0.147: R466.2 141.86,30.17 141.86,29.1 v1(141.99,28.97)
N15243226: length 10.2
  TOP w0.147: U59.4 144.1,26.73 143.26,27.57 141.1,27.57 140.08,28.59 v1(140.08,29.22)
  BOTTOM w0.147: R462.1 140.82,31.74 140.08,31 v1(140.08,29.22)
N15365714: length 4.4
  BOTTOM w0.147: J38.27 70.41,15.12 71.15,15.85 72.48,15.85 72.62,15.99 R543.2
N15365947: length 3.3
  BOTTOM w0.147: R545.2 70.29,16.54 69.82,16.07 69.82,15.78 68.91,14.87 J38.30
N15366015: length 3
  BOTTOM w0.147: R546.2 69.19,15.79 68.41,15.01 J38.31
N15366091: length 2.7
  BOTTOM w0.147: J38.32 67.91,15.13 68.05,15.26 R547.2
N15507744: length 1.6
  TOP w0.147: C159.2 165.74,35.34 U43.2
N15584817: length 2.2
  TOP w0.147: SW2.13 v1(87,28.21)
  BOTTOM w0.147: R508.1 v1(87,28.21)
N15584821: length 2.2
  TOP w0.147: SW2.14 v1(85.73,28.21)
  BOTTOM w0.147: R512.1 v1(85.73,28.21)
N15584825: length 2.2
  TOP w0.147: SW2.15 v1(84.46,28.21)
  BOTTOM w0.147: R517.1 v1(84.46,28.21)
N15584829: length 2.2
  TOP w0.147: SW2.16 v1(83.19,28.21)
  BOTTOM w0.147: R527.1 v1(83.19,28.21)
N15591045: length 2.2
  TOP w0.147: SW2.9 v1(92.07,28.21)
  BOTTOM w0.147: R472.1 v1(92.07,28.21)
N15591049: length 2.2
  TOP w0.147: SW2.10 v1(90.8,28.21)
  BOTTOM w0.147: R487.1 v1(90.8,28.21)
N15591053: length 2.2
  TOP w0.147: SW2.11 v1(89.53,28.21)
  BOTTOM w0.147: R496.1 v1(89.53,28.21)
N15591057: length 2.2
  TOP w0.147: SW2.12 v1(88.27,28.21)
  BOTTOM w0.147: R501.1 v1(88.27,28.21)
N15854407: length 1.9
  TOP w0.147: U14.3 126.62,106.42 R43.1
N15854417: length 5.3
  TOP w0.147: 126.89,98.52 127.12,98.75 U14.9 ; 126.89,98.52 C47.2 126.34,97.93 126.32,97.91 R73.1 ; 126.89,98.52 126.62,98.79 U14.8
N15854427: length 3.8
  TOP w0.147: R74.1 128.7,97.91 128.68,97.93 C47.1 127.87,98.57 127.62,98.82 U14.10
N15854463: length 1.8
  TOP w0.147: U6.3 R28.1
N15854467: length 7.8
  TOP w0.147: v1(150.24,124.35) 150.49,124.35 150.62,124.22 U6.8 150.62,122.06 150.5,121.93 150.24,121.93 150.12,122.05 U6.9
  BOTTOM w0.147: R216.1 149.29,122.51 149.61,122.82 C204.2 150.18,123.84 150.24,123.9 v1(150.24,124.35)
N15854483: length 6.7
  TOP w0.147: U6.10 149.62,124.49 v1(150.24,125.11)
  BOTTOM w0.147: v1(150.24,125.11) 151.16,124.19 C204.1 151.76,122.82 152.04,122.55 R215.1
N15854545: length 2.8
  TOP w0.147: U11.3 v1(147.19,108.22)
  BOTTOM w0.147: R244.1 146.62,108.09 146.74,108.22 v1(147.19,108.22)
N15854547: length 1.7
  TOP w0.147: R122.1 138.54,72.93 138.56,72.91 U28.3
N15854553: length 33.1
  TOP w0.147: v1(139.84,107.72) U11.9 142.24,107.72 142.37,107.85 142.37,108.09 142.24,108.22 U11.8
  BOTTOM w0.147: v1(139.84,107.72) 139.51,108.04 139.14,108.04 138.39,107.29 126.15,107.29 125.86,107.58 125.86,112.16 126.62,112.92 127.76,112.92 128.78,113.93 128.78,115.97 129.67,116.85 C214.2 131.08,115.84 R229.1
N15854557: length 10.5
  TOP w0.147: U28.8 138.56,66.44 138.69,66.31 138.95,66.31 139.06,66.42 U28.9 139.06,68.48 v1(138.94,68.59)
  BOTTOM w0.147: R350.1 134.47,68.3 135.96,66.82 138.56,66.82 138.83,67.09 C393.2 138.94,67.56 v1(138.94,68.59)
N15854581: length 9
  TOP w0.147: U28.10 139.56,68.2 v1(139.95,68.59)
  BOTTOM w0.147: v1(139.95,68.59) 139.81,68.45 C393.1 139.81,66.86 139.83,66.84 139.83,66.69 139.57,66.44 135.64,66.44 135.13,66.94 R352.1
N15854603: length 33.7
  TOP w0.147: U11.10 139.43,107.22 v1(139.32,107.33)
  BOTTOM w0.147: R228.1 132.68,115.57 132.06,116.18 C214.1 132.06,117.51 131.83,117.74 129.41,117.74 128.27,116.6 128.27,114.19 127.64,113.55 126.62,113.55 125.35,112.28 125.35,107.58 125.95,106.99 138.98,106.99 v1(139.32,107.33)
N15854737: length 1.8
  TOP w0.147: U1.3 R1.1
N15854741: length 5.7
  TOP w0.147: R11.1 86.36,123.19 U1.8 86.36,125.24 v1(86.74,125.62) 86.86,125.5 U1.9
  BOTTOM w0.147: C203.2 86.51,124.94 86.42,125.03 86.42,125.3 v1(86.74,125.62)
N15854757: length 5.4
  TOP w0.147: R10.1 87.52,123.06 87.38,123.2 87.38,123.29 87.36,123.31 U1.10 87.36,125.35 v1(87.63,125.62)
  BOTTOM w0.147: C203.1 87.48,125.47 v1(87.63,125.62)
N15854857: length 2.1
  TOP w0.254: R12.2 131.7,124.73
N15854859: length 2.4
  TOP w0.254: R13.2 129.29,123.42 129.16,123.55 J4.1
N16248811: length 3.3
  TOP w0.147: R60.1 v1(60.45,102)
  BOTTOM w0.147: U70.20 59.94,103.14 60.07,103.01 60.07,102.38 v1(60.45,102) R60.1
N16248833: length 3.4
  TOP w0.147: R61.1 v1(61.72,102)
  BOTTOM w0.147: R61.1 v1(61.72,102) 61.21,102.5 61.21,102.88 60.94,103.16 U70.18
N16248855: length 6.5
  TOP w0.147: R65.1 v1(62.99,101.23)
  BOTTOM w0.147: U70.17 62.24,103.76 62.99,103.01 v1(62.99,101.23) R65.1 63.61,100.45 63.72,100.34 R272.1
N16248877: length 2.7
  BOTTOM w0.147: R235.1 61.44,110.11 U70.8
N16248899: length 2.4
  BOTTOM w0.147: U70.7 60.94,110.43 61.21,110.7 R236.1
N16248921: length 2.3
  BOTTOM w0.147: R237.1 59.94,110.7 59.94,110.7 U70.5
N16248943: length 2.4
  BOTTOM w0.147: U70.3 58.94,110.43 58.67,110.7 R238.1
N16248965: length 2.5
  BOTTOM w0.147: R239.1 57.4,110.5 57.94,109.97 U70.1
N16303893: length 2.2
  TOP w0.147: SW3.11 v1(109.3,28.23)
  BOTTOM w0.147: v1(109.3,28.23) R515.1
N16303897: length 2.2
  TOP w0.147: SW3.12 v1(108.03,28.23)
  BOTTOM w0.147: v1(108.03,28.23) R511.1
N16303901: length 2.2
  TOP w0.147: SW3.13 v1(106.76,28.23)
  BOTTOM w0.147: v1(106.76,28.23) R504.1
N16303905: length 2.2
  TOP w0.147: SW3.14 v1(105.49,28.23)
  BOTTOM w0.147: v1(105.49,28.23) R499.1
N16303921: length 2.2
  TOP w0.147: SW3.9 v1(111.84,28.23)
  BOTTOM w0.147: v1(111.84,28.23) R530.1
N16303925: length 2.2
  TOP w0.147: SW3.10 v1(110.57,28.23)
  BOTTOM w0.147: v1(110.57,28.23) R520.1
N16679303: length 4.5
  TOP w0.147: v1(156.51,11.57) 157.55,12.62 U59.60
  TOP w0.203: v1(156.51,11.57) R206.2
  BOTTOM w0.203: v1(156.51,11.57) R206.2
N16679944: length 5
  TOP w0.147: v1(160.32,11.66) 159.86,11.66 158.75,12.77 U59.63
  TOP w0.203: v1(160.32,11.66) R209.2
  BOTTOM w0.203: v1(160.32,11.66) R209.2
N16679981: length 4.1
  TOP w0.147: v1(157.78,11.57) 157.78,12.38 157.95,12.55 U59.61
  TOP w0.203: v1(157.78,11.57) R207.2
  BOTTOM w0.203: v1(157.78,11.57) R207.2
N16680014: length 4.4
  TOP w0.147: v1(159.05,11.66) 158.35,12.35 U59.62
  TOP w0.203: R208.2 v1(159.05,11.66)
  BOTTOM w0.203: v1(159.05,11.66) R208.2
N16753626: length 4.8
  BOTTOM w0.147: J33.6 63.72,39.42 65.02,38.12 65.02,37.68 65.49,37.21 R449.2
N16753680: length 4.3
  BOTTOM w0.147: J33.15 66.22,49.36 65.39,50.2 R409.2
N16754334: length 5.9
  BOTTOM w0.147: J33.12 65.22,38.88 66.01,38.09 67.15,38.09 68.03,37.21 R447.2
N16756061: length 1.5
  TOP w0.147: R685.1 76.35,41.48 76.32,41.51 J25.2
N16814557: length 1.4
  BOTTOM w0.147: U89.5 153,38 R445.2
N16814563: length 2.2
  BOTTOM w0.147: R438.1 154.05,38.64 154.05,39.13 153.76,39.42 U89.4
N16814605: length 2.4
  BOTTOM w0.147: U84.5 134.78,53.36 133.88,54.26 R400.2
N16814611: length 2.2
  BOTTOM w0.147: R406.1 133.1,53.1 133.65,52.56 U84.4
N16814651: length 2
  BOTTOM w0.147: R397.2 141.08,54.64 141.29,54.43 U82.5
N16814659: length 2.4
  BOTTOM w0.147: U82.4 140.62,53.83 140.34,54.12 140.34,54.51 140.22,54.62 R403.1
N16879988: length 2.8
  TOP w0.147: R38.1 94.69,106.84 U13.F9
N16880168: length 7.1
  TOP w0.147: TP15.1 97.03,95.65 96.79,95.89 95.8,95.89 95.69,95.99 95.69,96.35 95.18,96.86 93.4,96.86 92.57,97.69 92.57,97.7 92.4,97.86 U13.T7
N16887346: length 7.4
  TOP w0.147: U23.H5 v1(93.86,82.3)
  BOTTOM w0.114: v1(93.86,82.3) 94.05,82.3 94.45,81.9 95.62,81.9 95.86,81.67 95.86,81.65 95.86,81.65 95.86,81.34 95.86,81.31 96.07,81.1 98.81,81.1
  BOTTOM w0.147: R320.1 99.13,80.79 98.81,81.1
N16887366: length 0.6
  TOP w0.147: U23.K2 v1(92.26,84.7)
N16887368: length 4.4
  TOP w0.147: U23.K1 91.84,85.12 91.84,85.76 93.58,87.5 v1(94.87,87.5)
N16887377: length 0.6
  TOP w0.147: U23.H3 v1(93.86,83.9)
N16887386: length 0.6
  TOP w0.147: U23.F3 v1(95.46,83.9)
N16887395: length 0.6
  TOP w0.147: U23.E4 v1(96.26,83.1)
N16887404: length 0.6
  TOP w0.147: U23.F5 v1(95.46,82.3)
N16937764: length 1.8
  TOP w0.147: R147.1 86.87,51.9 86.69,51.72 U37.5
N16938293: length 1.5
  BOTTOM w0.147: U98.5 126.82,58.68 126.82,58.68 R506.1
N17211229: length 2.9
  BOTTOM w0.147: R548.2 66.9,15.82 67.41,15.31 J38.33
N17247526: length 2.3
  TOP w0.147: LD16.2 v1(36.35,75.93)
  BOTTOM w0.147: v1(36.35,75.93) R421.2
N17247539: length 2.5
  TOP w0.147: LD17.2 v1(34.32,75.93)
  BOTTOM w0.147: v1(34.32,75.93) 34.64,75.61 34.64,75.48 34.82,75.3 R420.2
N17247599: length 2.3
  TOP w0.147: LD18.2 v1(32.28,75.9)
  BOTTOM w0.147: R419.2 v1(32.28,75.9)
N17247637: length 2.4
  TOP w0.147: LD19.2 v1(30.25,75.95)
  BOTTOM w0.147: R418.2 v1(30.25,75.95)
N17247662: length 2.2
  TOP w0.147: LD14.2 52.12,71.4 v1(51.99,71.53)
  BOTTOM w0.147: v1(51.99,71.53) R381.2
N17247701: length 2.1
  TOP w0.147: LD13.2 50.93,70.69 v1(51,70.61)
  BOTTOM w0.147: v1(51,70.61) 50.64,70.25 R382.2
N17247743: length 2.2
  TOP w0.147: LD12.2 v1(22.66,90.18)
  BOTTOM w0.147: v1(22.66,90.18) 22.66,89.58 22.53,89.45 R383.2
N17247786: length 2.1
  TOP w0.147: v1(19.61,89.04) 19.9,89.33 LD11.2
  BOTTOM w0.147: R384.2 19.75,88.9 v1(19.61,89.04)
N17248427: length 2.9
  TOP w0.147: R413.2 37.02,50.28 36.7,49.97 U34.7
N17248432: length 2.2
  TOP w0.147: R402.2 36.83,40.91 36.7,41.04 U34.10
N17248439: length 2.8
  TOP w0.147: U34.9 35.43,41.93 34.91,41.4 34.28,41.4 33.69,40.81 R401.2
N17546132: length 5.1
  BOTTOM w0.147: R542.2 73.76,15.99 73.28,15.51 71.6,15.51 71.6,15.51 71.22,15.51 70.91,15.2 J38.26
N17546158: length 3.3
  BOTTOM w0.147: R544.2 71.42,16.54 69.91,15.04 J38.28
N17682848: length 2.8
  TOP w0.147: R92.4 129.31,96.26 129.29,96.29 R74.2
N17682861: length 2.8
  TOP w0.147: R92.1 125.71,96.04 125.73,96.06 R73.2
N17683733: length 3.4
  BOTTOM w0.147: R227.3 R215.2
N17683748: length 3.4
  BOTTOM w0.147: R227.2 R216.2
N17685678: length 1.8
  BOTTOM w0.147: R228.2 132.72,113.83 132.99,113.55 R233.1
N17685693: length 1.7
  BOTTOM w0.147: R229.2 130.68,113.93 130.24,113.49 R233.4
N17685736: length 2
  BOTTOM w0.147: R352.2 133.5,66.91 132.84,66.25 R351.1
N17685749: length 2
  BOTTOM w0.147: R351.4 132.88,69 133.5,68.38 R350.2
N17686321: length 1.6
  TOP w0.147: R22.2 88.83,121.46 88.9,121.53 R10.2
N17686333: length 1.4
  TOP w0.147: R11.2 86.11,121.4 86.08,121.38 R22.3
N17786037: length 2.1
  TOP w0.254: 33.15,118.76 32.86,118.48 U9.2
N17786049: length 4.7
  TOP w0.254: v1(34.42,116.6) 34.29,116.48 U9.4
  BOTTOM w0.254: v1(34.42,116.6) 33.38,115.57 R231.1 33.38,113.92 33.4,113.9 R232.2
N18116794: length 1.9
  BOTTOM w0.147: Q13.1 33.47,95.43 33.73,95.17 R286.2
N18116818: length 2.1
  BOTTOM w0.147: Q12.1 28.37,113.3 27.69,113.3 27.59,113.39 R230.1
N18116875: length 1.4
  TOP w0.147: Q3.1 33.23,112 R30.1
N18117332: length 1.2
  BOTTOM w0.147: Q14.1 R324.2
N18117389: length 1.4
  BOTTOM w0.147: Q16.1 R343.1
N18275385: length 1.8
  TOP w0.147: U48.6 94.88,31.89 v1(94.64,32.13)
  BOTTOM w0.147: R459.1 v1(94.64,32.13)
N18276744: length 1.5
  TOP w0.147: R190.2 C169.1
N18280417: length 2
  TOP w0.254: U53.4 R195.2
N18280437: length 2.9
  BOTTOM w0.147: R491.2 79.67,26.04 79.21,25.58 U93.4
N18280477: length 2
  TOP w0.254: U52.4 R194.2
N18280857: length 2.2
  BOTTOM w0.147: R492.2 75.06,25.66 74.15,24.75 U94.4
N18289350: length 2.3
  BOTTOM w0.147: U76.5 130.61,93.64 130.73,93.76 131.5,93.76 C277.1
N18321769: length 2.2
  BOTTOM w0.147: U70.31 55.84,107.56 55.23,108.18 R243.1
N18546005:
  vias: v1(167.46,100.48) v1(167.46,99.47) v1(168.48,100.48) v1(168.48,99.47) v1(169.49,101.5) v1(169.49,100.48) v1(169.49,99.47) v1(170.51,101.5) v1(170.51,100.48) v1(170.51,99.47)
N18546027: length 3.8
  TOP w0.381: R64.2 161.56,94.13 160.99,94.13 159.83,92.98 LD5.1
N18546044: length 2.1
  TOP w0.381: LD5.2 159.78,96.98 D2.1
N18867885: length 3.8
  BOTTOM w0.147: U79.21 68.81,73.4 69.5,74.09 70.21,74.09 70.83,74.71 R325.2
N18867903: length 3
  BOTTOM w0.147: R326.2 69.56,74.71 68.31,73.47 U79.20
N18867905: length 2.7
  BOTTOM w0.147: U79.19 67.81,73.64 68.33,74.15 R327.2
N18867915: length 2.6
  BOTTOM w0.147: U79.18 67.31,73.89 67.06,74.15 R328.2
N18867925: length 2.9
  BOTTOM w0.147: U79.17 66.81,73.72 65.82,74.71 R329.2
N18867943: length 3.7
  BOTTOM w0.147: U79.16 66.31,73.65 65.91,74.06 65.21,74.06 64.55,74.71 R330.2
N18867953: length 4.2
  BOTTOM w0.147: R331.2 63.28,74.71 64.34,73.65 65.43,73.65 65.81,73.27 U79.15
N18867955: length 4.8
  BOTTOM w0.147: U79.14 65.31,72.92 64.96,73.27 63.45,73.27 62.01,74.71 R332.2
N18968782: length 1.5
  TOP w0.254: U36.5 R153.2
N18977129: length 5.6
  BOTTOM w0.147: Y3.2 132.02,39.13 C433.1 132.83,39.94 U87.3
N18977189: length 8.9
  BOTTOM w0.147: U87.2 133.4,39.44 133.17,39.21 133.17,35.91 132.93,35.67 C439.1 131.89,35.67 131.55,35.33 Y3.1
N19031494: length 2.4
  TOP w0.254: U9.9 30.87,116.98 v1(30.86,116.98)
  BOTTOM w0.254: v1(30.86,116.98) 30.35,116.98 30.12,117.22 C215.1
N19312123: length 3.3
  BOTTOM w0.147: R427.1 R428.2 3.92,41.58 3.94,41.57 D7.3
N19753713: length 8.5
  TOP w0.254: D5.1 165.45,69.73 166.22,68.96 C116.2 165.57,64.65 165.56,64.66 165.23,64.66 164.85,64.28 U30.11
N19753729: length 7.8
  TOP w0.147: 168.78,68.85 168.78,65.8 168.5,65.51
  TOP w0.305: C116.1 166.03,63.48 U30.10
  TOP w0.508: C116.1 166.65,63.67 168.5,65.51
N19753760: length 2.7
  TOP w0.254: R112.1 174.39,78.25 174.5,78.35 175.51,78.35 175.73,78.14 R111.1
N19753772: length 18.4
  TOP w0.147: v1(169,63.23) 168.81,63.04 R129.2 167.3,63.04 166.73,62.48 U30.8
  TOP w0.254: 166.89,75.67 v1(166.93,75.71)
  TOP w0.305: U26.4 166.89,75.67
  L08_SIG2 w0.091: v1(166.93,75.71) 167.74,74.89 167.74,64.49 v1(169,63.23)
N19753820: length 23.7
  TOP w0.254: U30.13 v1(163.17,65.5)
  L08_SIG2 w0.091: v1(170.71,79.32) 170.63,79.32 169.79,80.16 166.75,80.16 163.17,76.59 v1(163.17,65.5)
  BOTTOM w0.147: v1(170.71,79.32) 170.71,79.04 170.18,78.51 R317.1
N19753822: length 6.2
  TOP w0.305: U22.4 v1(165.9,77.91)
  BOTTOM w0.147: R321.2 166.57,77.24 v1(165.9,77.91) 166.51,78.51 R317.2
N19753872: length 26.4
  TOP w0.147: v1(166.69,60.06) 166.26,60.48 U30.4
  TOP w0.254: v1(171.73,77.56) 171.74,77.57 C85.1 172.85,78.23 R112.2
  L08_SIG2 w0.091: v1(166.69,60.06) 167.12,60.49 167.12,62.12 166.4,62.85 166.4,76.5 167.34,77.44 171.61,77.44 v1(171.73,77.56)
N19753878: length 27.2
  TOP w0.147: v1(166.69,61.4) 166.26,60.98 U30.5
  TOP w0.254: R109.2 172.84,79.21 C85.2 171.74,79.77 v1(171.73,79.78)
  L08_SIG2 w0.091: v1(171.73,79.78) 171.42,79.48 171.42,78.18 171.02,77.77 167.18,77.77 165.84,76.43 165.84,62.25 v1(166.69,61.4)
N19753964: length 1.2
  TOP w0.147: R141.1 168.16,60.14 168.17,60.16 C125.1
N19754006: length 2.7
  TOP w0.147: U30.30 158.34,58.98 157.73,58.37 157.48,58.37 156.96,57.85 C131.1
N19754159: length 3.4
  TOP w0.305: U30.25 158.28,61.48 158.21,61.56 157.92,61.56
  TOP w0.381: 157.92,61.56 157.24,61.56 156.37,60.69 R695.2
N19754185: length 1.8
  TOP w0.147: U30.1 165.65,58.98 166.44,58.18 C132.1
N19754201: length 3.9
  TOP w0.305: U30.21 157.97,63.48 C115.2
  TOP w0.508: 155.5,64.8 156.35,63.95 C115.2
N19754203: length 8.2
  TOP w0.254: D4.1 157.69,68.92 157.51,68.73 C115.1 158.23,64.93 158.88,64.28 U30.20
N19754223: length 1.5
  TOP w0.147: R130.2 158.2,63.02 158.24,62.98 U30.22
N19754237: length 17.3
  TOP w0.147: U30.23 156.95,62.48 156.67,62.19 v1(156.55,62.19) 156.55,63 R130.1
  TOP w0.305: U24.4 154.58,72.14 v1(156.34,70.39)
  BOTTOM w0.254: v1(156.55,62.19) 156.55,62.7 156.34,62.92 v1(156.34,70.39) 156.34,72.79
N19754314: length 4.6
  TOP w0.305: v1(154.97,80.65) 155.15,80.47 U21.4
  BOTTOM w0.147: R318.1 155.65,79.97 v1(154.97,80.65) 154.38,80.06 R319.1
N19754320: length 17.8
  TOP w0.254: v1(159.6,65.24) 159.85,65.24 160.18,64.92 U30.19
  L08_SIG2 w0.091: v1(159.6,65.24) 159.23,65.61 159.23,74.45 157.08,76.6 v1(154.81,76.6)
  BOTTOM w0.147: v1(154.81,76.6) 154.38,77.02 R319.2
N19754322: length 18.4
  TOP w0.254: v1(160.62,65.37) 160.68,65.31 U30.18
  L08_SIG2 w0.091: v1(155.83,77.35) 159.26,77.35 161.16,75.44 161.16,65.92 v1(160.62,65.37)
  BOTTOM w0.147: v1(155.83,77.35) 155.65,77.52 R318.2
N19754431: length 3.7
  TOP w0.147: U30.9 166.72,62.98 167.07,63.32 167.07,63.32 167.63,63.88 R129.1
N19754435: length 22.2
  TOP w0.254: v1(164.63,65.5) 164.12,65.5 163.67,65.05 U30.12
  L08_SIG2 w0.091: v1(170.81,78.21) 170.69,78.21 170.08,78.81 167.72,78.81 165.18,76.27 165.18,66.04 v1(164.63,65.5)
  BOTTOM w0.147: R321.1 170.31,77.24 170.81,77.75 v1(170.81,78.21)
N19754522: length 2.9
  TOP w0.254: 144.5,74.02 144.5,74.71 144.75,74.97 R119.1
N19754526: length 25.3
  TOP w0.147: U30.26 158.19,60.98 158.15,61.02 157.74,61.02 v1(157.68,60.96)
  TOP w0.254: R113.2 147.63,75.94 C94.1 149.2,75.94 v1(149.26,75.88)
  L08_SIG2 w0.091: v1(157.68,60.96) 157.7,60.97 157.7,73.89 155.7,75.88 v1(149.26,75.88)
N19754534: length 24.8
  TOP w0.147: U30.27 158.2,60.48 157.93,60.21 v1(157.73,60.21)
  TOP w0.254: 148.71,74.97 R119.2 ; 148.71,74.97 148.72,74.97 v1(149.26,74.97) ; 148.71,74.97 C94.2
  L08_SIG2 w0.091: v1(149.26,74.97) 155.52,74.97 157.25,73.24 157.25,60.7 v1(157.73,60.21)
N19754630: length 1.5
  TOP w0.147: C137.2 160.07,57.2 160.18,57.31 U30.32
N19754677: length 1.1
  TOP w0.147: R142.2 154.11,56.14 C136.1
N20142928: length 1.7
  BOTTOM w0.254: C200.1 89.64,126.74 90.04,127.14 U62.2
N20753582: length 2.5
  BOTTOM w0.254: C248.1 R261.2 R267.2
N23484157: length 3.5
  TOP w0.147: v1(55.88,103.52) R53.1
  BOTTOM w0.147: U70.24 56.9,103.76 56.65,103.52 v1(55.88,103.52) R53.1
N23484680: length 3.2
  TOP w0.147: v1(59.18,102) R59.1
  BOTTOM w0.147: U70.22 58.94,102.24 v1(59.18,102) R59.1
N24658557: length 2.8
  TOP w0.147: LD20.2 v1(143.38,32.4)
  BOTTOM w0.147: R462.2 142.35,32.53 142.48,32.4 v1(143.38,32.4)
N24754956: length 11.7
  TOP w0.147: v1(35.52,62.91) 36.24,63.62 v1(36.24,70.96)
  BOTTOM w0.147: v1(35.52,62.91) 35.68,62.75 U80.48 ; U80.13 v1(36.24,70.96) 35.35,70.96 TP69.1
N24775601: length 13.6
  TOP w0.147: U20.48 35.33,85.37 35.33,85.37 v1(34.75,85.37) 34.75,85.95 34.33,86.37 TP19.1 ; U20.13 v1(36.37,77.15)
  BOTTOM w0.147: v1(34.75,85.37) 36.37,83.75 v1(36.37,77.15)
N24776171: length 1.4
  BOTTOM w0.147: R334.2 Q15.1
N24776230: length 1.4
  TOP w0.147: Q4.1 10.09,89.43 R99.1
N24826481: length 4.3
  BOTTOM w0.147: U74.3 173.95,101.48 174.34,101.87 R266.2 R260.1 C245.1
N24972917: length 1.8
  BOTTOM w0.147: R280.2 138.94,94.43 R295.3
N24972919: length 1.8
  BOTTOM w0.147: R281.2 137.41,94.52 R295.2
N24972921: length 6.8
  TOP w0.147: U16.8 137.41,97.02 137.52,96.92 137.81,96.92 137.91,97.02 U16.9 137.91,98.97 v1(137.69,99.2)
  BOTTOM w0.147: R281.1 137.41,96.94 137.69,97.21 C269.2 v1(137.69,99.2)
N24972925: length 4.5
  TOP w0.147: U16.10 138.41,99.06 v1(138.68,99.33)
  BOTTOM w0.147: R280.1 138.94,96.94 138.67,97.21 C269.1 138.67,98.42 138.68,98.44 v1(138.68,99.33)
N24973001: length 1.8
  TOP w0.147: U16.3 R48.1
N25209998: length 1.8
  BOTTOM w0.14: R268.1 73.64,102.68 73.66,102.69 U71.1
N25294505: length 1.6
  TOP w0.254: LD6.2 R80.1
N25395961: length 2.8
  TOP w0.147: U23.A12 99.91,76.3 99.94,76.34 v1(100.4,76.34)
  BOTTOM w0.147: v1(100.4,76.34) 100.4,77.05 100.58,77.23 R323.2
N25526660: length 3
  BOTTOM w0.147: U70.12 63.5,106.56 63.88,106.19 64.24,106.19 64.41,106.02 R254.2
N25657725: length 1.6
  TOP w0.147: U23.A19 v1(99.65,70.7)
  BOTTOM w0.147: v1(99.65,70.7) 100.01,70.34 R345.1
N25657961: length 4.8
  BOTTOM w0.147: R541.2 9.11,17.29 8.43,16.6 6.13,16.6 5.92,16.81 J36.3
N25658118: length 1.8
  BOTTOM w0.147: U99.3 R516.2
N26002209: length 4
  TOP w0.147: R157.2 96.52,45.86 U40.B2
N26002808: length 1.9
  BOTTOM w0.147: Q19.1 94.86,16.66 R552.1
N26002814: length 1.9
  TOP w0.147: LD26.2 R210.1
N26002874: length 2.1
  BOTTOM w0.147: R553.1 102.34,14 101.89,14.46 Q18.1
N26002883: length 1.8
  TOP w0.147: LD23.2 R197.1
N26004018: length 3.4
  TOP w0.254: C49.1 144.78,96.03 144.51,95.75 R82.1 145.34,95.14 145.6,94.88 U17.7
N26004022: length 1.3
  TOP w0.254: R82.2 143.53,95.8 143.51,95.82 C48.2
N26004036: length 12.8
  TOP w0.147: 150.22,94.17 150.13,94.17 ; 149.85,93.89 149.83,93.88
  TOP w0.254: 150.37,93.87 150.36,93.88
  TOP w0.305: v1(151,93.74) 150.87,93.88 149.85,93.88 ; 150.13,94.17 149.85,93.89 149.85,93.88 ; 149.85,93.88 150.19,93.54 ; 149.85,93.88 U17.2
  TOP w0.381: C54.1 v1(142.62,93.87)
  BOTTOM w0.381: v1(142.62,93.87) 145.03,93.87 146.05,92.85 150.11,92.85 v1(151,93.74)
N26004038: length 1.8
  TOP w0.254: C54.2 145.54,93.87 145.55,93.88 U17.9
N26004052: length 2.3
  BOTTOM w0.381: C272.1 R279.1 R277.2
N26016842: length 1.6
  BOTTOM w0.305: 58.04,19.06 58.05,19.07 U97.9
N26016868: length 4.2
  BOTTOM w0.147: TP98.1 60.81,18.56 60.79,18.54 R535.1 59.44,19.55 59.05,19.94 U97.7
N26016893: length 1.9
  BOTTOM w0.147: R500.2 58.55,24.04 U97.3
N26118637: length 2.9
  TOP w0.147: U4.1 v1(20.7,121.93)
  BOTTOM w0.147: R221.2 v1(20.7,121.93)
N26118639: length 2.9
  TOP w0.147: U4.4 v1(24.51,121.93)
  BOTTOM w0.147: R220.2 v1(24.51,121.93)
N26120249: length 2.9
  TOP w0.147: U3.1 v1(10.8,121.93)
  BOTTOM w0.147: R223.2 v1(10.8,121.93)
N26120251: length 2.9
  TOP w0.147: U3.4 v1(14.6,121.93)
  BOTTOM w0.147: R222.2 v1(14.6,121.93)
N26140693: length 3.1
  BOTTOM w0.147: U81.21 76.18,57.94 76.68,58.43 77.54,58.43 78.19,59.09 R372.2
N26140695: length 2.3
  BOTTOM w0.147: R373.2 76.85,59.09 75.68,57.91 U81.20
N26140697: length 1.9
  BOTTOM w0.147: U81.19 75.18,58.02 75.69,58.54 R374.2
N26140699: length 1.8
  BOTTOM w0.147: R375.2 74.42,58.54 74.68,58.28 U81.18
N26140701: length 2.2
  BOTTOM w0.147: R376.2 73.19,59.09 74.18,58.1 U81.17
N26140703: length 2.9
  BOTTOM w0.147: U81.16 73.68,58.06 73.21,58.53 72.48,58.53 71.92,59.09 R377.2
N26140705: length 4.1
  BOTTOM w0.147: U81.15 73.18,58.06 73.06,58.18 70.87,58.18 70.61,58.43 R378.2
N26140707: length 4.1
  BOTTOM w0.147: R379.2 69.38,59.09 69.86,58.61 69.93,58.61 71.12,57.42 72.21,57.42 72.26,57.37 U81.14
N26145534: length 1.6
  TOP w0.147: v1(133.75,82.08) 133.85,82.18 Q5.1
  BOTTOM w0.147: v1(133.75,82.08) 133.85,81.99 R312.1
N26145544: length 2.7
  TOP w0.147: v1(133.1,86.23) 133.14,86.28 LD7.2
  BOTTOM w0.147: R305.1 133.6,86.28 133.55,86.23 v1(133.1,86.23)
N26145600: length 1.6
  TOP w0.147: R20.1 157.75,120.72 157.8,120.77 Q2.1
N26145606: length 2.5
  TOP w0.147: LD2.2 v1(156.46,126)
  BOTTOM w0.14: v1(156.46,126) R211.1
N26145666: length 1.5
  TOP w0.147: R14.1 126.09,121.39 126.02,121.46 Q1.1
N26145672: length 1.4
  TOP w0.147: R15.1 121.94,121.2 121.92,121.22 LD3.2
N26145732: length 1.4
  TOP w0.147: R136.1 10.05,59.03 9.99,59.09 Q7.1
N26145738: length 3.8
  TOP w0.147: LD10.2 v1(9.73,62)
  BOTTOM w0.147: R365.1 8.8,61.95 8.84,62 v1(9.73,62)
N26145798: length 1.6
  TOP w0.147: Q6.1 133.83,64.72 133.78,64.77 R127.1
N26145804: length 2.7
  TOP w0.147: v1(138.81,61.72) LD8.2
  BOTTOM w0.147: R360.1 v1(138.81,61.72)
N26145856: length 1.9
  BOTTOM w0.147: R217.1 29.36,121.51 29.27,121.6 Q11.1
N26145862: length 3.5
  TOP w0.147: LD1.2 32.85,126.25 33.27,125.83 v1(33.27,124.98)
  BOTTOM w0.147: R212.1 v1(33.27,124.98)
N26149805: length 1.9
  BOTTOM w0.147: U90.4 106.17,35.42 106.19,35.4 R454.2
N26149864: length 2.5
  BOTTOM w0.147: R555.2 56.28,11.32 56.13,11.18 J30.2
N26219977: length 2.2
  TOP w0.147: SW3.15 v1(104.22,28.23)
  BOTTOM w0.147: v1(104.22,28.23) R490.1
N26220001: length 2.2
  TOP w0.147: SW3.16 v1(102.95,28.23)
  BOTTOM w0.147: v1(102.95,28.23) R475.1
N26314477: length 4
  BOTTOM w0.147: 109.4,96.62 109.41,96.61 109.41,96.55
  BOTTOM w0.254: R298.2 109.4,96.56 109.41,96.55 C285.1 109.41,94.66 C279.1 C278.1
N26314562: length 4.1
  BOTTOM w0.381: C291.1 C292.1 116.32,80.66 C296.1 116.4,79.37 R307.2
N26442461: length 2.4
  TOP w0.147: U51.5 R185.1
N26454965: length 1.7
  TOP w0.147: R171.1 141.9,44.14 141.85,44.09 U41.4
N26523524: length 2.3
  TOP w0.147: U40.A5 101.47,45.58 101.75,45.86 R158.1
N26648730: length 2.7
  BOTTOM w0.147: U91.19 54.49,36.45 53.09,37.86 TP90.1
N26648748: length 2.6
  BOTTOM w0.147: U91.20 54.99,36.71 54.22,37.49 54.22,37.98 TP88.1
N26648766: length 3.9
  BOTTOM w0.147: TP87.1 54.38,38.63 54.38,38.52 55.5,37.41 U91.21
N26648784: length 2.7
  BOTTOM w0.147: TP86.1 56,37.76 U91.22
N26648802: length 2.2
  BOTTOM w0.147: TP89.1 56.5,37.71 U91.23
N26648820: length 2.1
  BOTTOM w0.147: U91.24 57,36.92 57.17,37.1 57.28,37.1 TP91.1
N26733190: length 4.7
  TOP w0.254: U32.4 17.78,60.08 v1(17.65,59.96)
  BOTTOM w0.254: v1(17.65,59.96) 18.69,60.99 R364.1 18.69,62.64 18.67,62.66 R361.2
N26733205: length 2.8
  TOP w0.254: 18.41,57.4 18.53,57.4 19.21,58.08 U32.2
N26733231: length 2.4
  TOP w0.254: v1(21.21,59.58) 21.2,59.58 U32.9
  BOTTOM w0.254: v1(21.21,59.58) 21.72,59.58 21.95,59.34 C402.1
N26735382: length 2.4
  TOP w0.254: U5.9 97.16,117.46 v1(97.16,117.46)
  BOTTOM w0.254: C202.1 96.92,116.72 97.16,116.95 v1(97.16,117.46)
N26735416: length 3.6
  TOP w0.254: U5.4 97.66,120.89 v1(97.54,121.02)
  BOTTOM w0.254: R213.1 98.31,120.75 98.04,121.02 v1(97.54,121.02) 97.63,121.11 R214.2
N26735457: length 2.1
  TOP w0.254: U5.2 95.66,119.46 95.38,119.75
N26735496: length 5.4
  BOTTOM w0.254: U65.6 138.6,119.39 138.56,119.44
N26735653: length 3.5
  TOP w0.254: R144.2 132.09,56.42 132.18,56.51 R145.1 133.5,57.04 U33.2
N26736579: length 6.5
  TOP w0.254: U25.6 130.8,76.1 129.22,74.52 127.53,74.52
N26736751: length 1.9
  TOP w0.254: R57.2 154.43,103.73 155.11,104.4 U12.1
N26736805: length 2.7
  TOP w0.254: U12.7 155.76,107.26 v1(155.96,107.46)
  BOTTOM w0.147: R49.1 156.65,107.46 v1(155.96,107.46) 155.6,107.46 155.27,107.13 R44.2
N26881621: length 2.9
  TOP w0.147: LD21.1 138.08,30.46 v1(138.3,30.24)
  BOTTOM w0.147: v1(138.3,30.24) 137.72,30.24 137.07,30.89 R464.2
N27030520: length 2.1
  BOTTOM w0.147: U71.3 70.25,105.81 70.23,105.79 R252.1
N27215594: length 29.8
  TOP w0.147: R76.2 v1(29.44,96.7)
  L08_SIG2 w0.091: J14.11 4.52,93.88 6.45,91.95 13.16,91.95 14.45,93.24 21.89,93.24 25.35,96.7 v1(29.44,96.7)
N27217693: length 4.2
  BOTTOM w0.147: FB19.2 23.1,72.18 23.01,72.09 J21.B9
N27218087: length 5.1
  BOTTOM w0.147: R347.2 6.03,76.93 7.55,75.4 9.07,75.4 9.92,74.54 J21.B12
N27219244: length 4.4
  BOTTOM w0.147: FB14.2 25.41,78.27 24.96,78.71 23.03,78.71 23.01,78.69 J21.A9
N27219552: length 2.2
  BOTTOM w0.147: R336.2 7.61,74.85 J21.A12
N27838027: length 1.8
  TOP w0.147: U10.6 126.23,118.74 R24.1
N27914276: length 1.7
  TOP w0.254: R577.2 164.17,56.82 U30.40
N27928121: length 2
  TOP w0.147: U30.31 159.68,57.43 158.81,56.56 R578.1
N27928168: length 6.6
  TOP w0.254: R579.1 R602.2 142.01,95.73 142.52,95.22 142.52,94.91 142.95,94.49 145.17,94.49 145.28,94.38 U17.8
N27943339: length 1.3
  BOTTOM w0.254: R580.1 146.42,120.14 U65.1
N27943633: length 1.7
  TOP w0.254: v1(96.52,120.76) 96.66,120.62 U5.6
  BOTTOM w0.147: R581.1 v1(96.52,120.76)
N27943804: length 1.5
  BOTTOM w0.254: R582.1 143.78,102.87 143.24,102.33 U72.3
N27943890: length 2.5
  TOP w0.147: R583.1 138.04,55.39 137.04,56.39 U33.4
N27943939: length 1.5
  TOP w0.254: R584.1 135.27,74.66 135.19,74.74 135.19,74.74 134.83,75.1 U25.1
N27944274: length 1.6
  TOP w0.254: U9.6 34.02,117.48 v1(34.16,117.62)
  BOTTOM w0.254: R585.1 33.77,117.22 v1(34.16,117.62)
N27944496: length 1.2
  BOTTOM w0.254: R586.1 U62.4
N27944776: length 1.7
  TOP w0.254: v1(17.91,58.94) 18.05,59.08 U32.6
  BOTTOM w0.254: R587.1 18.57,58.94 v1(17.91,58.94)
N27944822: length 1.2
  BOTTOM w0.147: U77.3 47.17,94.84 R588.1
N27945052: length 1.2
  BOTTOM w0.254: R589.1 14.14,18.86 U100.3
N27977097: length 4.7
  TOP w0.147: Y1.1 99.38,56.21 99.21,56.38 99.21,58.1 99.32,58.21 99.33,58.21 99.44,58.32 C133.2 99.44,59.2 99.19,59.45 R138.1
N27977103: length 2.4
  TOP w0.147: R139.1 101.75,59.67 C134.2 101.75,58.35 Y1.3
N28035755: length 3.8
  TOP w0.147: U23.N21 89.46,68.62 89.35,68.51 89.35,66.87 89.15,66.67 v1(89.15,66.04)
  BOTTOM w0.147: R591.2 v1(89.15,66.04)
N28118242: length 2.7
  TOP w0.147: Q5.3 136.02,84.28 136.23,84.5 LD7.1
N28118245: length 2.6
  TOP w0.147: LD2.1 159.55,124.66 158.75,123.86 Q2.3
N28118248: length 2.3
  TOP w0.147: Q1.3 123.8,123.2 123.01,124 LD3.1
N28118251: length 3.3
  TOP w0.381: Q7.3 7.2,61.52 7.63,61.95 LD10.1
N28118254: length 2.9
  TOP w0.147: Q6.3 136.81,64.44 137.32,64.95 LD8.1
N28118257: length 3.2
  TOP w0.147: LD1.1 28.9,126.25 28.78,126.38 v1(28.32,126.38)
  BOTTOM w0.147: Q11.3 v1(28.32,126.38)
N28118260: length 7.2
  TOP w0.254: LD4.2 v1(151.26,103.01)
  BOTTOM w0.254: v1(151.26,103.01) 151.26,98.31 151.51,98.06 R276.2
N28118377: length 2.8
  TOP w0.147: LD9.2 172.71,63.68 v1(172.71,64.91)
  BOTTOM w0.147: v1(172.71,64.91) 172.19,64.39 R362.2
N28118380: length 2.8
  TOP w0.147: v1(163.83,52.21) LD15.2
  BOTTOM w0.147: R407.2 163.07,52.97 v1(163.83,52.21)
N28118607: length 2.8
  TOP w0.147: LD25.2 v1(18.8,10.68)
  BOTTOM w0.14: R556.2 v1(18.8,10.68)
N28118686: length 1.2
  TOP w0.381: R201.2 LD24.2
N28119618: length 2.6
  TOP w0.147: LD23.1 101.8,17.24 101.33,16.76 v1(100.82,16.76)
  BOTTOM w0.147: Q18.3 100.62,16.56 v1(100.82,16.76)
N28119621: length 3.2
  TOP w0.147: LD26.1 95.38,12.73 v1(95.91,13.27)
  BOTTOM w0.147: v1(95.91,13.27) Q19.3
N28789368: length 2.8
  TOP w0.147: TP101.1 50.47,33.17 50.7,32.94 v1(51.82,32.94)
  BOTTOM w0.147: U91.12 51.84,32.91 v1(51.82,32.94)
N28853998: length 1.4
  TOP w0.147: R614.1 16.49,89.05 Q20.1
N28854850: length 3.5
  BOTTOM w0.147: Q21.1 13.38,86.55 14,87.17 R617.1
N28887698: length 11.1
  BOTTOM w0.147: R632.1 79.22,68.66 78.74,69.14 77.11,69.14 76.19,70.05 R625.1 75.64,70.05 75.29,70.41 75.29,71.81 75.77,72.29 75.77,73.41 75.51,73.66 75.51,75 76.12,75.61 R624.1
N28906258: length 2.2
  TOP w0.147: R631.2 J40.2
N28906289: length 2.2
  TOP w0.147: R630.2 J39.2
N29283187: length 5.6
  TOP w0.147: FB26.2 J14.2
N248107881: length 1.5
  TOP w0.147: R189.2 C168.1

## Copper pours and planes (outline as drawn)
DGND on BOTTOM (solid shape): 53.43,92.3 51.47,92.3 51.47,99.75 53.43,99.75
DGND on BOTTOM (solid shape): 57.02,31.39 53.47,31.39 53.47,34.94 57.02,34.94
DGND on BOTTOM (solid shape): 98.92,21.59 95.37,21.59 95.37,25.14 98.92,25.14
DGND on BOTTOM (solid shape): 104.53,67.63 104.59,67.72 104.7,67.7 104.77,67.63 104.77,66.85 106.07,66.85 106.07,66.01 104.45,66.01 104.18,66.28 104.18,66.39 104.53,66.39
DGND on BOTTOM (solid shape): 51.64,63.18 51.64,62.47 53.61,60.51 55.07,60.51 55.13,60.46 55.19,60.42 55.22,60.4 55.22,60.32 52.36,60.32 50.52,62.17 50.52,63.93 50,64.45 49.98,64.56 50.07,64.62 50.2,64.62
DGND on BOTTOM (solid shape): 143.61,58.25 143.63,58.14 143.54,58.08 142.41,58.08 142.41,57.22 141.89,56.7 141.89,55.04 141.36,55.04 141.36,55.27 141.66,55.27 141.66,56.52 140.68,56.52 140.68,57.4 140.85,57.56 140.85,58.05 141.21,58.41 143.45,58.41
DGND on BOTTOM (solid shape): 66.63,15.7 67.13,15.19 67.13,14.88 66.4,14.88 66.32,14.92 66.3,15.01 66.22,15.4 65.85,15.53 65.82,15.53 65.77,15.58 65.89,15.7 66.28,15.7 66.28,15.96 66.63,15.96
DGND on BOTTOM (solid shape): 73.34,93.14 73.45,93.16 73.51,93.07 73.51,91.23 73.45,91.13 73.34,91.15 73.01,91.48 72.02,91.48 70.88,90.33 70.78,90.33 70.68,90.4 70.71,90.51
DGND on BOTTOM (solid shape): 107.32,70.42 107.32,68.35 108.28,67.39 109.54,67.39 109.54,67.2 109.52,67.13 109.45,67.1 109.3,67.06 109.18,66.97 107.41,66.97 107.41,66.96 107.35,66.95 107.32,67 107.32,68.02 105.16,68.02 105.03,68.14 105.03,68.36 104.84,68.55 104.87,68.61 104.87,70.83 106.91,70.83
DGND on BOTTOM (solid shape): 139.34,57.48 139.45,57.5 139.51,57.41 139.51,56.54 140.49,56.54 140.49,55.27 140.8,55.27 140.8,54.53 141.01,54.32 141.02,54.27 140.97,54.23 140.96,54.23 140.96,54.1 140.74,54.1 140.61,54.23 140.61,54.62 140.33,54.9 140.27,54.9 140.27,55.25 139.03,55.25 139.03,56.06 139.01,56.08 139.01,57.16
DGND on BOTTOM (solid shape): 58.24,37.41 58.34,37.38 60.18,35.55 60.18,35.03 59.19,35.03 59.19,34.73 59.11,34.73 59.07,34.69 58.57,34.69 58.57,34.87 57.45,34.87 57.45,36.49 57.27,36.49 57.27,36.81 57.29,36.83 57.4,36.83 57.53,36.96 57.56,36.96 57.94,37.03 58.17,37.34
DGND on BOTTOM (solid shape): 49.02,103.24 49.07,103.21 49.06,103.16 49.01,103.11 49.01,102.15 48.42,102.15 48.42,102.68 48.39,102.79 48.33,102.88 48.22,103 48.13,103.06 48.02,103.08 47.74,103.08 47.55,102.89 47.49,102.88 47.46,102.92 47.46,102.96 47.41,103.02 47.41,103.04 47.61,103.24
DGND on BOTTOM (solid shape): 101.44,67.64 101.51,67.73 101.62,67.7 101.76,67.59 101.93,67.54 101.96,67.53 101.98,67.49 101.98,67.37 103.28,67.37 103.28,66.39 103.63,66.39 103.63,66.05 103.93,65.74 103.96,65.63 103.86,65.57 102.73,65.57 101.44,66.86
DGND on BOTTOM (solid shape): 73.47,121.99 73.56,121.92 73.54,121.81 72.62,120.89 72.62,118.2 72.17,117.75 72.1,117.75 72.02,117.79 72,117.88 72.01,117.97 72,118.07 72,118.44 72.19,118.44 72.19,119.69 72,119.69 72,119.87 71.69,120.17 71.69,121.5 71.52,121.5 71.52,121.67 71.37,121.81 71.35,121.92 71.44,121.99
DGND on BOTTOM (solid shape): 87.95,52.25 88.06,52.28 88.13,52.18 88.13,51.99 88.33,51.78 86.05,49.49 86.02,49.49 85.58,49.05 85.47,49.03 85.4,49.12 85.4,49.71 86.1,50.4 86.1,50.73 86.32,50.73 86.42,50.75 86.51,50.81 86.64,50.94 86.7,51.03 86.72,51.14 86.72,51.36 86.94,51.36 87.05,51.38 87.14,51.44
DGND on BOTTOM (solid shape): 19.89,67.61 20.02,67.6 23.31,64.31 25.13,64.31 25.52,64.7 25.91,64.31 26.58,64.31 26.96,64.7 27.35,64.31 31.71,64.31 32.23,64.84 33.39,64.84 33.39,64.15 21.3,64.15 19.89,65.56 19.5,65.56 19.4,65.63 19.43,65.74 19.94,66.54 19.85,67.49
DGND on BOTTOM (solid shape): 99.18,70.61 99.27,70.63 99.34,70.57 99.43,70.45 99.56,70.38 99.58,70.38 99.9,70.06 99.94,70.06 99.94,68.87 100,68.87 100.09,68.81 100.07,68.7 97.35,65.98 97.24,65.96 97.17,66.05 97.17,66.19 97.66,66.68 97.66,68.17 97.34,68.5 97.34,70.12 97.35,70.14 97.42,70.19 97.51,70.16 97.55,70.12 98.69,70.12
DGND on BOTTOM (solid shape): 58.75,40.52 58.86,40.5 61.94,37.41 61.94,36.91 61.88,36.81 61.77,36.83 58.74,39.86 57.89,39.86 57.71,40.04 57.68,40.11 57.7,40.19 57.73,40.22 57.75,40.26 57.84,40.31 57.93,40.26 58.37,40.07 58.68,40.43
DGND on BOTTOM (solid shape): 17.74,71.23 22.62,66.35 24.5,66.35 24.89,66.73 25.28,66.35 25.95,66.35 26.33,66.73 26.72,66.35 27.39,66.35 27.77,66.73 28.16,66.35 28.83,66.35 29.22,66.73 29.6,66.35 33.39,66.35 33.39,65.64 31.9,65.64 31.37,65.12 27.73,65.12 27.73,65.79 27.3,66.22 26.63,66.22 26.24,65.83 25.86,66.22 25.19,66.22 24.76,65.79 24.76,65.12 23.64,65.12 18.6,70.16 16.59,70.16 16.03,70.72 16.03,71.12 16.09,71.21 16.19,71.2 16.94,70.99 17.65,71.33 17.66,71.34 17.74,71.34
DGND on BOTTOM (solid shape): 94.77,61.75 94.83,61.84 94.94,61.82 95.12,61.64 95.12,60.45 95.04,59.97 95.48,59.76 95.57,59.74 95.61,59.66 95.61,55.89 90.57,50.86 90.54,50.88 90.5,50.91 90.44,50.98 90.47,51.07 94.94,55.54 94.94,56.38 95.29,56.38 95.29,57.55 94.04,57.55 94.04,57.24 93.83,57.24 93.83,58.54 94.77,58.54
DGND on BOTTOM (solid shape): 41.18,39.74 41.21,39.69 41.21,38.94 43.11,38.94 43.21,38.88 43.19,38.77 41.7,37.28 40.51,37.28 40.41,37.35 40.45,37.47 40.52,38.03 39.96,38.11 39.75,38.11 38.97,38.89 38.95,39 39.04,39.06 39.81,39.06 39.81,39.74
DGND on BOTTOM (solid shape): 80.17,54.6 80.19,54.25 80.43,54.02 80.27,53.86 80.21,53.77 80.19,53.67 80.19,53.37 80.3,53.26 80.32,53.15 80.23,53.08 79.3,53.08 78.99,52.77 78.99,51.35 78.77,51.35 78.77,53.71 78.56,53.92 78.47,53.98 78.37,54 78.07,54 77.78,53.71 77.78,52.95 77.69,52.95 77.68,52.98 77.65,53.04 77.62,53.08 77.62,54.45 78.38,54.45 78.38,54.56 78.63,54.56 78.63,54.4 79.87,54.4 79.87,54.48 79.9,54.55 79.98,54.58 80.05,54.59 80.12,54.6
DGND on BOTTOM (solid shape): 45.62,101.06 45.65,101.11 45.7,101.1 45.72,101.08 46.23,101.08 46.33,100.98 46.33,98.31 46.68,97.97 46.7,97.85 46.61,97.79 45.24,97.79 45.17,97.86 45.14,97.95 45.21,98.02 45.41,98.18 45.48,98.43 45.5,98.5 45.58,98.53 45.59,98.53 45.59,99.73 45.58,99.73 45.5,99.76 45.47,99.84 45.48,99.89 45.5,99.96 45.58,99.99 45.62,99.99
DGND on BOTTOM (solid shape): 92.86,48.94 92.94,48.97 93.01,48.93 93.05,48.88 93.1,48.84 93.14,48.77 93.11,48.69 90.83,46.41 90.83,41.79 90.29,41.24 90.17,41.22 90.11,41.32 90.11,46.78 90.15,46.86 90.23,46.88 90.7,47.14 90.5,47.64 90.44,47.71 90.47,47.8 91.17,48.51 92.43,48.51
DGND on BOTTOM (solid shape): 119.74,67.42 119.85,67.44 119.92,67.35 119.92,66.16 118.86,65.1 118.76,65.08 118.69,65.16 118,65.41 118.24,64.71 118.33,64.65 118.3,64.54 118.14,64.38 116.94,64.38 116.85,64.44 116.87,64.55
DGND on BOTTOM (solid shape): 48.59,100.21 48.63,100.12 48.74,99.82 49.03,99.68 49.05,99.68 49.08,99.65 49.11,99.54 49.01,99.48 48.69,99.31 48.64,98.94 48.63,98.85 48.54,98.8 48.49,98.8 48,98.32 47.1,98.32 46.89,98.54 46.89,100.02 48.08,100.02 48.08,100.12 48.12,100.2 48.22,100.21 48.36,100.19 48.49,100.23
DGND on BOTTOM (solid shape): 79.38,58.81 79.49,58.83 79.55,58.74 79.55,58.61 79.86,58.3 80.94,58.3 80.94,57.61 80.48,57.61 80.27,57.4 80.21,57.31 80.19,57.2 80.19,56.9 80.26,56.83 80.2,56.77 80.17,56.79 80.07,56.82 79.98,56.83 79.9,56.86 79.87,56.93 79.87,57.01 78.63,57.01 78.63,56.75 78.46,56.75 78.44,56.73 78.38,56.76 78.38,56.84 77.62,56.84 77.62,56.91 77.64,56.94 77.67,56.96 78.05,57.21 77.96,57.65 77.94,57.76 78.03,57.83 78.4,57.83
DGND on BOTTOM (solid shape): 126.87,53.15 126.98,53.17 127.04,53.07 127.04,51.42 124.98,49.36 124.98,49.31 124.92,49.21 124.82,49.23 124.74,49.27 124.66,49.3 124.59,49.37 124.61,49.47 125.92,50.77 125.92,51.32 125.95,51.4 126.04,51.42 126.5,51.76 126.17,52.23 126.09,52.3 126.12,52.4
DGND on BOTTOM (solid shape): 38.87,107.82 42.26,107.82 42.35,107.75 42.32,107.64 42.19,107.42 42.22,107.16 42.21,107.07 42.13,107.02 41.29,107.02 41.29,106.76 41.22,106.67 41.11,106.7 40.98,106.8 40.81,106.85 40.78,106.86 40.77,106.9 40.77,107 39.57,107 39.57,106.79 39.43,106.79 39.43,107 38.21,107 38.21,108.02 38.1,108.02 38.03,108.05 38,108.12 37.97,108.28 37.89,108.41 37.87,108.52 37.96,108.58 38.11,108.58
DGND on BOTTOM (solid shape): 55.19,95.24 55.19,94.39 55.49,94.39 55.49,93.9 56.44,92.96 57.16,92.96 57.38,92.74 57.38,91.35 55.92,89.89 52.91,89.89 52.82,89.95 52.84,90.06 52.96,90.38 52.8,90.67 52.76,90.78 52.86,90.85 53.66,90.85 53.66,91.57 54.87,91.57 54.87,91.7 55.19,91.7 55.19,91.4 55.36,91.4 55.36,91.35 55.77,90.94 56.18,91.35 56.18,91.4 56.36,91.4 56.36,92.65 55.19,92.65 55.19,92.36 54.87,92.36 54.87,95.24 54.98,95.24 55.08,95.35
DGND on BOTTOM (solid shape): 76.27,85.96 76.36,85.91 76.36,85.8 76.71,85.19 77.06,85.8 77.06,85.91 77.15,85.96 86.77,85.96 87.52,85.21 87.54,85.1 87.45,85.03 87.36,85.02 87.28,84.98 74.16,84.98 73.94,85.21 73.94,85.23 73.91,85.53 73.72,85.77 73.68,85.88 73.78,85.96
DGND on BOTTOM (solid shape): 151.23,41.82 151.23,41.61 151.39,41.44 151.39,41.03 150.99,41.03 150.99,40.9 150.09,40.9 148.41,39.21 147.47,39.21 147.47,41.59 147.64,41.59 147.64,41.3 148.81,41.3 148.81,42.55 148.72,42.55 148.64,42.58 148.61,42.66 148.21,43.09 147.8,42.66 147.78,42.58 147.7,42.55 147.64,42.55 147.64,42.27 147.47,42.27 147.47,42.93 147.5,43 147.57,43.03 147.88,43.19 147.96,43.53 147.98,43.61 148.06,43.65 148.63,43.65 148.64,43.66 149.38,43.66
DGND on BOTTOM (solid shape): 69.59,67.7 69.62,67.75 69.68,67.74 69.74,67.68 69.74,66.6 71.01,66.6 71.01,65.62 71.35,65.62 71.35,65.61 71.38,65.52 71.42,65.45 71.42,65.41 71.4,65.38 71.24,64.92 71.63,64.63 71.71,64.59 71.73,64.51 71.72,64.43 71.72,64.35 71.7,64.26 71.62,64.23 71.02,64.23 71.02,65.03 70.74,65.31 70.46,65.31 70.36,65.29 70.27,65.23 70.14,65.11 69.93,65.33 69.97,65.37 69.97,66.19 69.61,66.54 69.32,66.54 69.24,66.58 69.22,66.66 69.22,66.73 69.59,67.1
DGND on BOTTOM (solid shape): 66.45,51.25 66.45,49.78 66.38,49.68 66.27,49.7 65.5,50.47 65.27,50.47 65.27,50.78 64.28,50.78 64.28,52.45 64,52.74 64.17,52.91 64.17,53.3 63.97,53.5 63.88,53.56 63.77,53.58 63.6,53.58 63.6,53.75 63.58,53.86 63.52,53.95 63.4,54.07 63.31,54.13 63.2,54.15 63.03,54.15 63.03,54.32 63.01,54.43 62.95,54.52 62.83,54.64 62.74,54.7 62.64,54.72 62.46,54.72 62.46,54.89 62.44,55 62.38,55.09 62.26,55.2 62.17,55.26 62.07,55.28 61.7,55.28 61.7,55.48 61.68,55.58 61.62,55.67 57.52,59.77 57.52,59.81 57.55,59.89 57.62,59.92 57.78,59.92
DGND on BOTTOM (solid shape): 52.3,40.74 52.4,40.68 52.38,40.57 52.27,40.46 48.62,36.81 48.62,32.32 48.57,31.78 49.1,31.67 49.2,31.67 49.25,31.58 49.25,30.49 48.9,30.13 48.79,30.11 48.72,30.2 48.72,30.82 47.95,30.82 47.65,31.12 47.65,31.34 47.69,31.42 47.78,31.43 48.24,31.63 48.16,32.12 48.16,32.64 48.16,32.64 48.16,37.85 51.05,40.74
DGND on BOTTOM (solid shape): 123.96,95 124.01,94.91 124.36,94.52 124.81,94.79 124.82,94.83 127.99,94.83 128.07,94.74 128.1,94.63 128,94.57 127.75,94.57 127.75,93.71 128.85,93.71 128.85,93.57 127.75,93.57 127.75,93.42 127.3,93.42 126.12,92.24 124.5,92.24 124.26,92.37 124,92.31 123.9,92.31 123.85,92.4 123.85,93.65 122.83,94.66 122.82,94.78 122.93,94.83 123.41,94.81 123.86,94.99
DGND on BOTTOM (solid shape): 25.78,35.55 25.87,35.5 26.17,35.13 26.61,34.95 26.69,34.88 26.66,34.78 26.49,34.61 26.49,33.39 26.15,33.04 24.55,33.04 24.46,33.11 24.48,33.22 24.76,34.19 24.07,34.92 24.03,34.93 24.03,35.04 24.09,35.13 24.19,35.12 25.03,34.97 25.69,35.5
DGND on BOTTOM (solid shape): 132.42,88.43 138.09,88.43 138.09,86.72 138.05,86.63 137.95,86.62 137.76,86.65 137.57,86.59 137.56,86.58 137.42,86.58 137.39,86.61 136.26,86.61 136.26,86.9 134.11,86.9 134.11,86.56 133.48,86.56 133.44,86.51 133.39,86.51 133.38,86.52 132.94,86.61 132.69,86.24 132.63,86.15 132.52,86.17 127.34,91.35 124.53,91.35 124.41,91.47 124.39,91.55 124.43,91.62 124.47,91.65 124.5,91.69 126.35,91.69 127.53,92.86 127.75,92.86 127.75,92.71 130.3,92.71 130.3,92.81 130.4,92.81 130.5,92.72 130.5,91.98 130.66,91.98 130.66,91.93 130.97,91.57 131.41,91.76 131.48,91.82 131.48,91.98 131.67,91.98 131.67,93.18 132.42,93.18
DGND on BOTTOM (solid shape): 87.88,98.86 87.85,98.85 87.7,98.42 88.12,98.25 88.21,98.23 88.26,98.15 88.26,98.08 88.23,98.03 88.18,98.03 87.67,97.75 88.18,97.48 88.19,97.48 88.26,97.48 88.26,97.4 87.9,97.05 86.8,97.05 85.9,96.15 85.9,95.98 85.64,95.98 85.64,95.34 85.15,95.34 84.4,96.09 84.4,97.94 85.16,97.94 85.16,98.31 86.34,98.31 86.39,98.36 86.5,98.38 86.56,98.28 86.56,98.05 87.3,98.05 87.3,98.18 87.44,98.32 87.53,98.49 87.51,98.68 87.5,98.71 87.58,98.8 87.59,98.8 87.74,98.94 87.88,98.94
DGND on BOTTOM (solid shape): 57.55,85.44 68.45,85.44 68.53,85.39 68.53,85.28 68.48,85.15 68.48,85.01 68.46,84.93 68.38,84.89 56.18,84.89 55.73,84.45 55.73,84.01 56.22,83.52 60.64,83.52 60.94,83.22 60.94,83.2 60.72,82.98 53.63,82.98 50.96,85.66 50.93,85.75 51,85.82 51.23,86.43 50.58,86.49 50.57,86.47 50.49,86.47 50.49,86.6 50.68,86.79 50.7,86.79 50.91,86.85 51.05,87 51.14,87.05 51.23,87 51.72,86.83 51.98,87.28 52,87.37 52.08,87.4 55.59,87.4
DGND on BOTTOM (solid shape): outline of 120 points within 130.76,73.97 135.09,86.85
DGND on BOTTOM (solid shape): 22.72,68.54 24.24,68.54 24.62,68.92 25.01,68.54 25.68,68.54 26.07,68.92 26.45,68.54 27.12,68.54 27.51,68.92 27.9,68.54 28.57,68.54 28.95,68.92 29.34,68.54 30.01,68.54 30.39,68.92 30.78,68.54 30.87,68.54 30.87,68.48 30.87,68.47 31.14,67.91 31.65,68.26 31.71,68.35 31.82,68.32 32.29,67.85 33.39,67.85 33.39,67.15 30.8,67.15 30.71,67.2 30.71,67.31 30.65,67.81 30.14,67.85 30.04,67.85 29.98,67.93 29.55,68.35 28.88,68.35 28.5,67.97 28.11,68.35 27.44,68.35 27.05,67.97 26.67,68.35 26,68.35 25.61,67.97 25.22,68.35 24.55,68.35 24.13,67.93 24.13,67.15 22.95,67.15 19.29,70.81 19.27,70.93 19.36,70.99 19.73,71.04 20.05,71.21
DGND on BOTTOM (solid shape): 53.53,117.8 53.55,117.69 53.46,117.62 53.2,116.93 53.89,117.19 53.96,117.28 54.06,117.26 54.11,117.21 59.58,117.21 59.86,116.92 59.89,116.82 59.8,116.75 59.47,116.53 59.48,116.14 59.48,116.04 59.4,115.99 57.01,115.99 56.12,116.88 54.37,116.88 54.17,116.68 51.15,116.68 51.06,116.74 51.08,116.85 51.17,117.29 50.8,117.54 50.78,117.54 50.42,117.9 50.4,118.01 50.49,118.07 53.25,118.07
DGND on BOTTOM (solid shape): 55.54,42.45 56.91,42.45 58.31,41.04 58.34,40.93 58.25,40.87 58.07,40.81 57.93,40.67 57.84,40.62 57.75,40.67 57.37,40.87 57.02,40.6 56.95,40.54 56.86,40.56 55.74,41.68 52.37,41.68 52.28,41.74 52.29,41.84 52.35,42.22 52.07,42.48 52.05,42.49 52.01,42.53 52.13,42.65 52.25,42.53 52.34,42.47 52.45,42.45 52.61,42.45 52.72,42.47 52.81,42.53 52.93,42.65 53.05,42.53 53.14,42.47 53.25,42.45 53.42,42.45 53.52,42.47 53.61,42.53 53.73,42.65 53.86,42.53 53.95,42.47 54.05,42.45 54.22,42.45 54.32,42.47 54.41,42.53 54.54,42.65 54.66,42.53 54.75,42.47 54.85,42.45 55.02,42.45 55.13,42.47 55.22,42.53 55.34,42.65
DGND on BOTTOM (solid shape): 113.95,131.71 114.04,131.65 114.01,131.54 113.7,131.04 113.68,130.45 113.64,130.25 113.55,130.07 113.54,130.01 113.53,129.93 113.4,129.81 113.4,128.87 113.33,128.78 113.22,128.82 111.38,128.9 111.8,127.1 111.85,127.04 111.9,126.97 111.9,126.87 111.81,126.82 109.56,126.82 108.88,127.5 108.88,129.46 108.96,129.54 109.04,129.55 109.17,129.6 109.31,129.62 110.71,130.08 110.52,131.54 110.5,131.65 110.59,131.71
DGND on BOTTOM (solid shape): 124.11,131.71 124.2,131.65 124.17,131.54 123.84,130.95 123.89,130.28 123.87,130.14 123.82,130.01 123.81,129.93 123.42,129.54 123.42,129.04 123.36,128.95 123.25,128.97 121.43,128.74 122.11,127.05 122.15,127.04 122.15,126.66 118.94,123.45 118.83,123.42 118.77,123.52 118.77,127.33 119.02,127.59 119.02,129.44 119.12,129.54 119.2,129.55 119.33,129.6 119.47,129.62 120.87,130.08 120.68,131.54 120.66,131.65 120.75,131.71
DGND on BOTTOM (solid shape): 148.64,16.43 148.7,16.53 148.81,16.51 149.61,15.71 149.61,15.62 149.55,15.52 149.44,15.54 148.74,15.25 149.44,14.97 149.55,14.99 149.61,14.89 149.61,13.29 149.56,13.25 149.54,13.25 149.38,13.21 149.24,13.1 149.16,13.07 149.08,13.11 148.94,13.23 148.75,13.28 148.73,13.28 148.32,13.69 144.86,13.69 144.77,13.76 144.79,13.87 146.92,15.99 147.4,15.99 147.7,15.86 148,15.99 148.01,16.01 148.08,16.01 148.08,15.86 148.02,15.79 147.99,15.79 147.71,15.09 148.41,15.38 148.41,15.4 148.64,15.63
DGND on BOTTOM (solid shape): 119.03,131.71 119.12,131.65 119.09,131.54 118.76,130.95 118.81,130.28 118.79,130.14 118.74,130.01 118.73,129.93 118.47,129.67 118.47,128.9 118.4,128.8 118.28,128.84 116.45,128.89 116.88,127.1 116.96,126.99 117.03,126.86 117.07,126.8 117.92,125.95 117.92,122.08 117.85,121.98 117.74,122.01 113.96,125.79 113.96,129.54 114.15,129.61 114.36,129.63 115.78,130.07 115.6,131.54 115.58,131.65 115.67,131.71
DGND on BOTTOM (solid shape): 64.87,72.95 64.87,71.5 69.57,71.5 69.57,70.81 71.08,70.81 71.08,70.19 69.57,70.19 69.57,69.5 65.37,69.5 65.37,68.05 65.43,68.05 65.43,67.99 65.43,67.98 65.52,67.58 65.91,67.47 66,67.45 66.04,67.37 66.04,67.33 65.83,67.12 65.81,67.12 65.57,67.05 65.43,66.85 65.36,66.78 65.26,66.81 63.63,68.44 63.61,68.5 63.66,68.53 63.74,68.53 63.93,68.73 63.99,68.82 64.02,68.93 64.02,69.21 63.49,69.73 63.99,70.23 63.99,70.51 63.97,70.62 63.91,70.71 63.79,70.82 63.7,70.88 63.6,70.9 63.32,70.9 62.81,70.4 62.73,70.48 62.64,70.54 62.53,70.56 62.37,70.56 62.26,70.54 62.17,70.48 61.88,70.19 61.62,70.45 61.62,70.74 61.66,70.78 61.71,70.77 61.75,70.73 62.03,70.73 62.14,70.75 62.23,70.81 62.35,70.93 62.55,70.73 62.83,70.73 62.94,70.75 63.03,70.81 63.23,71.01 63.23,71.43 63.26,71.47 63.32,71.46 63.36,71.42 63.64,71.42 63.74,71.44 63.83,71.5 63.95,71.62 64.01,71.71 64.03,71.82 64.03,72.75 63.96,72.82 63.93,72.9 63.98,72.98 64.84,72.98
DGND on BOTTOM (solid shape): outline of 90 points within 70.28,52.81 80.43,57.14
DGND on BOTTOM (solid shape): 96.83,90.36 96.94,90.38 97.01,90.29 97.01,85.12 97.05,85.08 97,85.03 96.99,85.03 96.74,84.63 97.14,84.38 97.2,84.38 97.2,84.22 97.14,84.23 96.73,83.9 97.14,83.58 97.2,83.58 97.2,83.42 97.14,83.43 96.95,83.42 96.8,83.31 96.71,83.27 96.63,83.32 96.56,83.41 96.48,83.48 96.43,83.56 96.46,83.64 96.58,83.99 96.31,84.23 96.3,84.23 96.21,84.32 96.26,84.37 96.28,84.37 96.59,84.75 96.18,85.03 96.12,85.02 96.12,85.18 96.18,85.18 96.56,85.36 96.45,85.77 96.41,85.84 96.44,85.92 96.46,85.94 96.46,90.36 96.83,90.36
DGND on BOTTOM (solid shape): 93.87,67.36 93.97,67.33 94.71,66.59 94.71,66.58 95.44,65.85 95.44,62.89 96.28,62.05 96.28,53.98 94.67,52.37 94.57,52.34 94.5,52.42 94.02,52.72 93.71,52.23 93.69,52.15 93.61,52.11 93.2,51.79 93.44,51.33 93.5,51.26 93.47,51.16 91.96,49.65 91.05,49.65 91.05,50.55 96.16,55.66 96.16,61.91 93.97,64.11 93.78,64.11 93.75,64.13 93.75,64.16 93.54,64.5 93.14,64.5 93.03,64.5 92.98,64.59 92.98,64.96 93.05,65.06 93.16,65.03 93.78,65.03 93.68,65.64 93.68,65.96 93.88,66.31 93.68,66.66 93.68,67.06 93.76,67.16 93.8,67.28
