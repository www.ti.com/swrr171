# Allegro board PROC101B_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PRG1_IEP0_EDC_LATCH_IN1: length 61.4
  TOP w0.147: U23.U13 v1(85.86,75.1)
  L08_SIG2 w0.091: v1(85.86,75.1) 86.28,75.53 86.28,76.6 87.06,77.37 87.06,78.51 86.85,78.71 86.41,78.71 86.26,78.87 86.26,82.5 86.03,82.73 85.59,82.73 85.43,82.89 85.43,83.35 85.27,83.52 84.84,83.52 84.58,83.77 82.85,83.77 82.47,83.39 81.34,83.39 77.59,87.14 75.44,87.14 71.96,90.62 71.96,96.45 70.02,98.39 58.34,98.39 56.7,100.02 54.73,100.02 53.75,99.05 53.75,97.32 55.43,95.65 57.91,95.65 58.17,95.39 J15.1
PRG1_IEP0_EDC_SYNC_OUT0: length 25.7
  TOP w0.147: U23.W7 v1(84.26,80.7)
  L08_SIG2 w0.091: J18.1 67.82,94.12 67.82,91.82 74.93,84.71 77.98,84.71 81.99,80.7 v1(84.26,80.7)
PRG1_IEP0_EDC_SYNC_OUT2: length 57.2
  TOP w0.147: U23.U7 v1(85.86,80.7)
  L08_SIG2 w0.091: v1(85.86,80.7) 85.46,81.11 85.46,82.43 85.16,82.73 84.84,82.73 84.63,82.93 84.63,83.29 84.42,83.5 83.12,83.5 82.7,83.08 81.36,83.08 77.61,86.83 77.53,86.83 77.48,86.88 75.42,86.88 71.77,90.53 71.77,96.37 69.94,98.2 58.21,98.2 56.61,99.8 54.82,99.8 53.97,98.96 53.97,97.41 55.55,95.84 57.72,95.84 58.39,96.5 61.63,96.5 J16.1
PRG1_MDIO_MDC: length 61.8
  TOP w0.147: v1(39.32,86.89) 39.1,87.11 R104.2 38.71,86.55 39.37,85.9 U20.42 ; v1(71.91,84.42) 77.87,84.42 78.44,83.85 79.62,82.66 80.19,82.66 81.35,81.5 83.46,81.5 U23.Y6 ; U27.8 v1(51.58,87.21)
  L08_SIG2 w0.091: v1(71.91,84.42) 63.41,84.42 61.82,86 57.51,86 57.25,86.26 57.25,86.77 57.51,87.02 59.79,87.02 60.02,87.25 60.02,87.5 59.84,87.68 52.04,87.68 v1(51.58,87.21) 51.58,87.59 50.5,88.66 49.39,88.66 46.91,91.14 42.06,91.14 40.55,89.63 40.55,88.12 v1(39.32,86.89)
PRG1_MDIO_MDIO: length 50.3
  TOP w0.147: U27.2 49.36,87.71 v1(49.5,87.86) ; U20.41 39.87,86.37 40.04,86.55 R103.1 40.06,87.11 40.61,87.11 40.64,87.14 v1(40.67,87.14) ; U23.AA6 81.34,81.1 80.07,82.37 79.5,82.37 78.66,83.21 78.29,83.58 75.06,83.58 74.68,83.2 71.08,83.2 v1(70.52,83.75)
  L08_SIG2 w0.091: v1(40.67,87.14) 41.95,88.42 48.95,88.42 v1(49.5,87.86) 49.88,87.86 49.95,87.93 50.65,87.93 51.13,87.45 51.13,86.94 52.35,85.72 61.47,85.72 63.12,84.07 70.2,84.07 v1(70.52,83.75)
PRG1_PRU1GPO18: length 85.9
  TOP w0.147: J2.E13 v1(59.31,132.35) ; v1(71.37,76.72) 71.37,75.67 73.38,73.66 75.82,73.66 76.63,74.47 79.53,74.47 80.16,75.1 83.46,75.1 U23.Y13
  L03_SIG1 w0.091: v1(71.37,76.72) 71.37,79.72 68.07,83.02 68.07,88.14 70.78,90.84 71.72,90.84 72.11,91.24 75.16,91.24 76.38,92.46 76.38,95.07 76.3,95.15 76.3,103.3 73.89,105.71 73.89,106.27 65.44,114.72 65.44,119.61 59.74,125.32 59.74,131.92 v1(59.31,132.35)
PRG1_PRU1GPO19: length 67.6
  TOP w0.147: U23.V12 v1(85.06,75.9) ; J2.C12 v1(60.58,129.81)
  L03_SIG1 w0.091: v1(60.58,129.81) 60.58,124.73 65.63,119.69 65.63,114.92 74.27,106.27 74.27,105.74 76.66,103.35 76.66,96.39 78.64,94.41 78.64,83.85 77.43,82.63 77.43,81.72 80.84,78.31 81.14,78.31 83.17,76.29 84.68,76.29 v1(85.06,75.9)
PRG1_RGMII1_ETH3_CLK: length 51.7
  TOP w0.147: U20.20 39.87,77.63 v1(40.26,77.24)
  L08_SIG2 w0.091: v1(59.94,112.79) 57.78,110.63 54.36,110.63 48.12,104.39 43.56,104.39 40.26,101.09 40.26,96.14 39.38,95.26 39.38,88.76 38.61,87.99 38.61,85.27 39.21,84.67 39.21,78.28 v1(40.26,77.24)
  BOTTOM w0.147: R237.2 v1(59.94,112.79)
PRG1_RGMII1_ETH3_CLK_OUT: length 4.9
  TOP w0.147: TP17.1 40.77,88.66 40.95,88.47 41.15,88.28 41.15,86.89 40.37,86.11 U20.40
PRG1_RGMII1_ETH3_RBIAS: length 1.3
  TOP w0.147: U20.12 R110.2
PRG1_RGMII1_RD0: length 52.1
  TOP w0.147: U23.Y7 83.46,80.7 81.22,80.7 80.52,81.41 79.5,81.41 78.75,82.16 78.75,82.45 77.94,83.26 75.86,83.26 75.37,83.26 74.53,82.42 70.63,82.42 69.13,83.92 68.46,83.92 66.76,85.62 62.46,85.62 62.33,85.49 62.33,85.35 62.2,85.22 62.02,85.22 61.89,85.35 61.89,85.49 61.76,85.62 61.57,85.62 61.45,85.49 61.45,85.35 61.32,85.22 61.13,85.22 61,85.35 61,85.49 60.87,85.62 60.69,85.62 60.56,85.49 60.56,85.35 60.43,85.22 60.25,85.22 60.12,85.35 60.12,85.49 59.99,85.62 59.81,85.62 59.68,85.49 59.68,85.35 59.55,85.22 59.36,85.22 59.24,85.35 59.24,85.49 59.11,85.62 58.92,85.62 58.79,85.49 58.79,85.35 58.66,85.22 58.48,85.22 58.35,85.35 58.35,85.49 58.22,85.62 58.04,85.62 57.91,85.49 57.91,85.35 57.78,85.22 57.6,85.22 57.47,85.35 57.47,85.49 57.34,85.62 57.16,85.62 57.03,85.49 57.03,85.35 56.9,85.22 56.71,85.22 56.58,85.35 56.58,85.49 56.45,85.62 56.27,85.62 56.14,85.49 56.14,85.35 56.01,85.22 55.83,85.22 55.7,85.35 55.7,85.49 55.57,85.62 55.39,85.62 55.26,85.49 55.26,85.35 55.13,85.22 54.95,85.22 54.82,85.35 54.82,85.49 54.69,85.62 54.5,85.62 54.37,85.49 54.37,85.35 54.24,85.22 54.06,85.22 53.93,85.35 53.93,85.49 53.8,85.62 50.55,85.62 47.58,82.65 45.85,82.65 45.74,82.76 R108.1 v1(45.09,83.45) 44.76,83.12 U20.33
  BOTTOM w0.147: R108.1 v1(45.09,83.45)
PRG1_RGMII1_RD1: length 50
  TOP w0.147: R107.1 v1(45.09,84.59) 44.11,83.62 U20.34 ; U23.U8 v1(85.86,79.9)
  L08_SIG2 w0.091: v1(85.86,79.9) 85.43,80.33 84.1,80.33 83.93,80.5 81.91,80.5 79.09,83.32 70.28,83.32 69.78,83.82 62.87,83.82 61.29,85.39 52.5,85.39 50.93,83.82 49.02,83.82 47.19,85.65 45.44,85.65 45.09,85.3 v1(45.09,84.59)
  BOTTOM w0.147: R107.1 v1(45.09,84.59)
PRG1_RGMII1_RD2: length 48.8
  TOP w0.147: U23.W8 v1(84.26,79.9) ; U20.35 43.21,84.12 v1(43.43,84.35)
  L08_SIG2 w0.091: v1(43.43,84.35) 43.82,83.96 44.05,83.96 44.14,84.05 44.14,84.79 44.23,84.88 44.4,84.88 44.49,84.79 44.49,84.05 44.58,83.96 45.59,83.96 45.68,84.05 45.68,84.65 45.77,84.74 45.93,84.74 46.02,84.65 46.02,84.05 46.11,83.96 46.28,83.96 46.37,84.05 46.37,84.65 46.46,84.74 46.62,84.74 46.71,84.65 46.71,84.05 46.8,83.96 47.64,83.96 48.72,82.89 69.68,82.89 69.98,82.59 78.3,82.59 78.98,81.92 78.98,81.3 79.97,80.3 83.35,80.3 83.75,79.9 v1(84.26,79.9)
PRG1_RGMII1_RD3: length 48.7
  TOP w0.147: v1(43.69,85.49) 43.36,85.16 42.75,85.16 42.62,85.02 U20.36 ; U23.V8 v1(85.06,79.9)
  L08_SIG2 w0.091: v1(85.06,79.9) 84.69,79.53 84.1,79.53 83.93,79.7 83.66,79.7 83.43,79.93 79.73,79.93 78.23,81.43 77.06,81.43 76.27,82.22 69.82,82.22 69.53,82.52 47.02,82.52 46.74,82.8 43.16,82.8 42.93,83.03 42.93,84.73 v1(43.69,85.49)
PRG1_RGMII1_RESETN: length 14.5
  TOP w0.147: v1(31.11,87.25) 31.11,87.88 R102.1 29.74,87.9 U19.4 ; U20.43 38.87,85.86 38.1,86.63 38.1,88.41 v1(38.48,88.79)
  L08_SIG2 w0.091: v1(31.11,87.25) 31.38,86.99 33.53,86.99 34.44,87.9 37.59,87.9 v1(38.48,88.79)
PRG1_RGMII1_RX_CTL: length 48.5
  TOP w0.147: v1(45.3,87.99) 44.77,87.99 R101.2 R100.1 43.43,87.36 42.33,86.25 41.77,86.25 41.37,85.85 U20.38 ; U23.Y8 83.46,79.9 81.53,79.9 81.43,79.8 80.6,79.8 78.46,81.94 78.46,82.32 78.11,82.67 75.62,82.67 74.99,82.04 70.17,82.04 68.83,83.39 68.14,83.39 66.69,84.84 v1(50.55,84.84)
  BOTTOM w0.147: v1(45.3,87.99) 46.58,87.99 49.73,84.84 v1(50.55,84.84)
PRG1_RGMII1_RXC: length 49.2
  TOP w0.147: U20.32 44.39,82.62 44.79,82.23 47.76,82.23 48.52,82.99 48.57,82.99 v1(48.9,83.31) ; U23.AA7 82.58,80.3 82.52,80.25 80.91,80.25 v1(80.26,80.9)
  L08_SIG2 w0.091: v1(80.26,80.9) 79.34,81.82 79.34,82.07 78.45,82.96 70.13,82.96 69.77,83.31 62.61,83.31 62.1,83.82 56.26,83.82 56.17,83.91 56.17,84.47 56.08,84.56 55.9,84.56 55.8,84.47 55.8,83.91 55.71,83.82 55.53,83.82 55.44,83.91 55.44,84.47 55.35,84.56 55.16,84.56 55.07,84.47 55.07,83.91 54.98,83.82 54.8,83.82 54.71,83.91 54.71,84.47 54.62,84.56 54.43,84.56 54.34,84.47 54.34,83.91 54.25,83.82 54.07,83.82 53.98,83.91 53.98,84.47 53.88,84.56 53.7,84.56 53.61,84.47 53.61,83.91 53.52,83.82 53.34,83.82 53.24,83.91 53.24,84.47 53.15,84.56 52.97,84.56 52.88,84.47 52.88,83.91 52.79,83.82 52.45,83.82 51.94,83.31 v1(48.9,83.31)
PRG1_RGMII1_TD0: length 58.7
  TOP w0.147: U20.28 43.2,80.62 43.37,80.46 43.87,80.46 43.98,80.36 43.98,80.22 44.07,80.13 44.07,78.74 44.45,78.36 46.35,78.36 46.74,78.74 46.74,80.99 46.94,81.19 47.94,81.19 50.47,83.73 51.35,83.73 51.48,83.86 51.48,84.27 51.61,84.4 51.8,84.4 51.93,84.27 51.93,83.86 52.06,83.73 52.24,83.73 52.37,83.86 52.37,84.27 52.5,84.4 52.68,84.4 52.81,84.27 52.81,83.86 52.94,83.73 53.12,83.73 53.25,83.86 53.25,84.27 53.38,84.4 53.56,84.4 53.69,84.27 53.69,83.86 53.82,83.73 54.01,83.73 54.14,83.86 54.14,84.27 54.27,84.4 54.45,84.4 54.58,84.27 54.58,83.86 54.71,83.73 54.89,83.73 55.02,83.86 55.02,84.27 55.15,84.4 55.33,84.4 55.46,84.27 55.46,83.86 55.59,83.73 55.77,83.73 55.9,83.86 55.9,84.27 56.03,84.4 56.22,84.4 56.35,84.27 56.35,83.86 56.47,83.73 56.66,83.73 56.79,83.86 56.79,84.27 56.92,84.4 57.1,84.4 57.23,84.27 57.23,83.86 57.36,83.73 57.54,83.73 57.67,83.86 57.67,84.27 57.8,84.4 57.98,84.4 58.11,84.27 58.11,83.86 58.24,83.73 58.43,83.73 58.56,83.86 58.56,84.27 58.68,84.4 58.87,84.4 59,84.27 59,83.86 59.13,83.73 59.31,83.73 59.44,83.86 59.44,84.27 59.57,84.4 59.75,84.4 59.88,84.27 59.88,83.86 60.01,83.73 67.38,83.73 68.02,83.09 68.71,83.09 70.35,81.45 74.81,81.45 75.59,82.23 76.9,82.23 77.72,81.41 78.54,81.41 80.44,79.5 U23.AA8
PRG1_RGMII1_TD1: length 55.6
  TOP w0.147: U20.27 43.45,80.12 v1(43.58,80) ; U23.U9 v1(85.86,79.1)
  BOTTOM w0.114: v1(85.86,79.1) 85.46,79.5 83.76,79.5 83.35,79.91
  BOTTOM w0.147: 83.35,79.91 78.93,84.33 73.69,84.33 72.72,85.29 71.41,85.29 68.51,82.4 52.54,82.4 52.31,82.17 52.31,81.43 52.19,81.31 52.03,81.31 51.91,81.43 51.91,82.28 51.79,82.4 51.63,82.4 51.51,82.28 51.51,81.91 51.39,81.79 51.22,81.79 51.11,81.91 51.11,82.28 50.99,82.4 50.82,82.4 50.7,82.28 50.7,81.43 50.59,81.31 50.42,81.31 50.3,81.43 50.3,82.28 50.19,82.4 50.02,82.4 49.9,82.28 49.9,81.43 49.78,81.31 49.62,81.31 49.5,81.43 49.5,82.21 49.32,82.4 45.17,82.4 44.32,81.55 44.32,80.74 v1(43.58,80)
PRG1_RGMII1_TD2: length 56
  TOP w0.147: v1(43.59,78.18) 43.59,79.36 43.41,79.54 43.39,79.54 43.31,79.62 U20.26 ; U23.W9 v1(84.26,79.1)
  L08_SIG2 w0.091: v1(84.26,79.1) 83.89,79.1 83.26,79.73 79.67,79.73 79.57,79.83 79.57,79.83 78.15,81.25 76.89,81.25 76.1,82.04 69.75,82.04 69.49,82.3 46.86,82.3 46.77,82.2 46.77,81.84 46.68,81.75 46.52,81.75 46.42,81.84 46.42,82.49 46.33,82.58 46.17,82.58 46.08,82.49 46.08,81.84 45.99,81.75 45.83,81.75 45.73,81.84 45.73,82.49 45.64,82.58 45.48,82.58 45.39,82.49 45.39,81.84 45.3,81.75 45.13,81.75 45.04,81.84 45.04,82.49 44.95,82.58 44.81,82.58 44.72,82.49 44.72,81.85 44.63,81.76 44.47,81.76 44.38,81.85 44.38,82.43 44.26,82.55 43.43,82.55 43.14,82.26 43.14,82.14 43.24,82.05 43.6,82.05 43.69,81.95 43.69,81.77 43.6,81.68 43.24,81.68 43.14,81.59 43.14,78.63 v1(43.59,78.18)
PRG1_RGMII1_TD3: length 58.7
  TOP w0.147: U23.AA9 81.48,78.7 81.37,78.81 80.22,78.81 78.21,80.82 77.48,80.82 77.14,81.16 75.35,81.16 75.06,80.86 70.11,80.86 69.93,81.03 68.67,82.3 67.69,82.3 66.85,83.14 53.86,83.14 51.89,81.17 51.89,80.99 52.52,80.36 52.52,80.18 52.39,80.05 52.21,80.05 51.58,80.68 51.4,80.68 51.27,80.55 51.27,80.37 51.9,79.74 51.9,79.56 51.77,79.43 51.58,79.43 50.96,80.05 50.77,80.05 50.64,79.92 50.64,79.74 51.27,79.11 51.27,78.93 51.14,78.8 50.96,78.8 50.33,79.43 50.15,79.43 50.02,79.3 50.02,79.12 50.65,78.49 50.65,78.31 50.52,78.18 50.33,78.18 49.71,78.8 49.52,78.8 49.39,78.67 49.39,78.49 50.02,77.86 50.02,77.68 49.89,77.55 49.71,77.55 49.08,78.18 48.9,78.18 48.77,78.05 48.77,77.87 49.4,77.24 49.4,77.06 49.27,76.93 49.08,76.93 48.46,77.55 48.27,77.55 47.32,76.6 44.27,76.6 42.62,78.25 U20.25
PRG1_RGMII1_TX_CTL: length 55.8
  TOP w0.147: v1(43.05,85.74) 42.93,85.74 42.64,85.45 42.63,85.45 42.55,85.37 U20.37 ; U23.Y9 83.46,79.1 80.41,79.1 78.4,81.11 77.6,81.11 77.26,81.45 75.23,81.45 74.93,81.16 70.23,81.16 68.71,82.68 67.82,82.68 67.06,83.43 53.73,83.43 48.14,77.84 45.31,77.84 v1(44.58,77.1)
  L08_SIG2 w0.091: v1(43.05,85.74) 42.9,85.74 42.29,85.14 42.29,78.75 43.94,77.1 v1(44.58,77.1)
PRG1_RGMII1_TXC: length 56.2
  TOP w0.147: U23.V9 v1(85.06,79.1) ; U20.29 43.31,81.12 43.52,80.91 v1(43.81,80.91)
  L08_SIG2 w0.091: v1(85.06,79.1) 84.66,78.71 83.6,78.71 82.94,79.37 79.52,79.37 79.42,79.47 79.42,79.47 78,80.88 76.74,80.88 75.94,81.68 69.6,81.68 69.36,81.92 53.2,81.92 53.11,81.82 53.11,80.79 53,80.67 52.87,80.67 52.75,80.79 52.75,81.84 52.66,81.93 52.47,81.93 52.38,81.84 52.38,80.79 52.29,80.7 52.11,80.7 52.02,80.79 52.02,81.84 51.92,81.93 51.74,81.93 51.65,81.84 51.65,80.79 51.56,80.7 51.38,80.7 51.28,80.79 51.28,81.84 51.19,81.93 51.01,81.93 50.92,81.84 50.92,80.79 50.83,80.7 50.64,80.7 50.55,80.79 50.55,81.84 50.46,81.93 50.28,81.93 50.19,81.84 50.19,80.81 50.1,80.72 49.91,80.72 49.82,80.81 49.82,81.84 49.73,81.93 48.56,81.93 47.96,81.33 44.6,81.33 44.19,80.91 v1(43.81,80.91)
PRG1_RGMII2_ETH2_CLK: length 57.8
  L08_SIG2 w0.091: v1(40.13,70.88) 40.13,72.02 38.99,73.17 38.99,84.58 38.32,85.24 38.32,88.02 39.16,88.85 39.16,95.42 40.01,96.27 40.01,101.35 43.31,104.65 47.97,104.65 54.24,110.92 57.67,110.92 58.67,111.92 v1(58.67,112.79)
  BOTTOM w0.147: R238.2 v1(58.67,112.79) ; v1(40.13,70.88) 39.74,70.49 U80.20
PRG1_RGMII2_ETH2_CLK_OUT: length 5.1
  BOTTOM w0.147: U80.40 40.24,62.01 40.64,61.61 40.89,61.61 41.09,61.42 41.09,58.76 TP78.1
PRG1_RGMII2_ETH2_RBIAS: length 1.3
  BOTTOM w0.147: U80.12 R349.2
PRG1_RGMII2_FET_ENN: length 1.8
  TOP w0.147: U27.9 53.98,87.71 53.99,87.7 R121.1
PRG1_RGMII2_FET_SEL: length 67.8
  TOP w0.147: U27.1 47.1,88.21 47.1,88.21 R120.1 46.51,88.77 v1(46.58,88.85)
  L03_SIG1 w0.091: v1(51.07,33.41) 50.7,33.41 50.04,34.08 50.04,40.89 43.59,47.35 41.81,47.35 40.45,48.7 40.45,56.93 43.76,60.25 43.76,63.07 43.84,63.14 43.84,74.09 46.3,76.56 46.3,88.57 v1(46.58,88.85)
  BOTTOM w0.147: U91.13 v1(51.07,33.41)
PRG1_RGMII2_MDC: length 40.4
  TOP w0.147: U27.6 v1(50.88,86.21)
  L08_SIG2 w0.091: v1(50.88,86.21) 50.25,86.84 49.83,86.84 49.38,87.3 43.43,87.3 41.71,85.57 41.71,74.02 40.61,72.92 40.61,70.28 40.51,70.18 40.46,70.18 39.52,69.24 39.52,64.34 39.19,64.01 v1(39.19,61.23)
  BOTTOM w0.147: U80.42 39.24,62.22 38.58,61.56 R369.2 39.09,61.01 39.19,61.11 v1(39.19,61.23)
PRG1_RGMII2_MDIO: length 38.8
  TOP w0.147: v1(49.68,86.44) 49.41,86.71 U27.4
  L08_SIG2 w0.091: v1(49.68,86.44) 49.1,87.02 43.56,87.02 41.99,85.45 41.99,76.61 42.85,75.74 42.85,74.32 41.58,73.05 41.58,70.89 39.83,69.14 39.83,61.94 v1(40.62,61.15)
  BOTTOM w0.147: U80.41 39.74,61.75 39.92,61.57 R370.1 39.92,61.01 40.48,61.01 40.62,61.15 v1(40.62,61.15)
PRG1_RGMII2_RD0: length 63.3
  TOP w0.147: v1(44.83,65.55) 44.37,65.55 44.09,65.26 R126.2 ; U23.W11 v1(84.26,77.5)
  L08_SIG2 w0.091: v1(84.26,77.5) 83.55,77.5 82.36,78.69 79.41,78.69 77.84,80.26 76.58,80.26 75.72,81.13 69.37,81.13 69.22,81.28 59.94,81.28 51.41,72.75 44.42,72.75 42.18,70.51 42.18,68.11 41.95,67.88 41.67,67.88 41.58,67.79 41.58,67.62 41.67,67.53 42.2,67.53 42.29,67.44 42.29,67.3 42.2,67.2 41.7,67.2 41.61,67.11 41.61,66.95 41.7,66.86 41.98,66.86 42.29,66.55 42.29,65.84 43.35,64.78 44.07,64.78 v1(44.83,65.55)
  BOTTOM w0.147: v1(44.83,65.55) 44.37,65.55 44.09,65.26 R126.2 43.53,64.67 43.2,65 U80.33
PRG1_RGMII2_RD1: length 62.7
  TOP w0.147: R128.2 44.09,62.99 v1(44.2,62.88) ; U23.V11 v1(85.06,77.5)
  L08_SIG2 w0.091: v1(44.2,62.88) 44.2,63.64 41.15,66.69 41.15,69.85 44.29,72.99 51.28,72.99 59.82,81.53 69.22,81.53 69.45,81.31 75.79,81.31 76.59,80.52 77.85,80.52 79.32,79.04 79.33,79.04 79.37,79 82.64,79 83.74,77.9 84.66,77.9 v1(85.06,77.5)
  BOTTOM w0.147: U80.34 43.22,64.5 43.61,64.1 43.62,64.1 43.89,63.83 43.89,63.82 44.09,63.62 R128.2 44.09,63.24 44.2,63.13 v1(44.2,62.88)
PRG1_RGMII2_RD2: length 61.9
  TOP w0.147: U23.AA12 v1(82.66,75.9)
  L08_SIG2 w0.091: v1(43.27,63.13) 43.27,63.52 43.18,63.61 42.44,63.61 41.69,62.86 41.69,62.64 41.78,62.55 42.13,62.55 42.22,62.46 42.22,62.3 42.13,62.21 41.78,62.21 41.69,62.11 41.69,60.75 41.81,60.62 42.77,60.62 42.86,60.53 42.86,59.97 42.95,59.88 43.12,59.88 43.21,59.97 43.21,60.53 43.3,60.62 43.46,60.62 43.55,60.53 43.55,59.97 43.64,59.88 43.81,59.88 43.9,59.97 43.9,60.53 43.99,60.62 44.15,60.62 44.24,60.53 44.24,59.97 44.34,59.88 44.5,59.88 44.59,59.97 44.59,60.53 44.68,60.62 44.84,60.62 44.93,60.53 44.93,60.06 45.03,59.97 45.19,59.97 45.28,60.06 45.28,60.53 45.37,60.62 45.66,60.62 46.32,61.28 46.32,61.88 46.98,62.54 46.98,63.1 61.41,77.53 75.15,77.53 76.73,75.95 81.18,75.95 81.53,75.59 82.35,75.59 v1(82.66,75.9)
  BOTTOM w0.147: v1(43.27,63.13) 43.27,63.81 43.08,64 U80.35
PRG1_RGMII2_RD3: length 61.6
  TOP w0.147: U23.Y12 v1(83.46,75.9)
  L08_SIG2 w0.091: v1(46.37,62.79) 46,62.79 45.9,62.69 45.16,62.69 44.9,62.94 44.9,63.79 44.99,63.89 45.3,63.89 45.39,63.98 45.39,64.16 45.3,64.25 44.99,64.25 44.9,64.34 44.9,64.64 45.67,65.4 46.18,65.4 46.27,65.31 46.27,63.93 46.36,63.83 46.52,63.83 46.62,63.93 46.62,65.31 46.81,65.51 47.03,65.51 47.12,65.42 47.12,64.28 47.24,64.16 47.39,64.16 47.49,64.25 47.49,65.42 47.58,65.51 48.87,65.51 49.5,66.14 49.5,66.27 49.31,66.45 49.31,66.58 49.44,66.71 49.57,66.71 49.76,66.52 49.89,66.52 50.09,66.73 50.09,68.35 50.9,69.16 52.27,69.16 61,77.89 75.3,77.89 75.41,77.78 76.86,76.33 80.89,76.33 81.15,76.58 82.86,76.58 83.28,76.16 83.28,76.09 v1(83.46,75.9)
  BOTTOM w0.147: U80.36 42.49,63.07 43.26,62.3 44.38,62.3 44.7,62.63 44.83,62.63 44.99,62.79 v1(46.37,62.79)
PRG1_RGMII2_RESETN: length 18.3
  TOP w0.147: U31.4 27.81,61.35 v1(28.3,61.85)
  L08_SIG2 w0.091: v1(38.35,59.32) 37.47,58.43 35.43,58.43 31.5,62.37 28.83,62.37 v1(28.3,61.85)
  BOTTOM w0.147: U80.43 38.74,62.26 37.97,61.49 37.97,59.7 v1(38.35,59.32) ; R367.1 v1(28.3,61.85)
PRG1_RGMII2_RX_CTL: length 63.2
  TOP w0.147: U23.W12 v1(84.26,75.9) ; R135.1 v1(43.05,61.61)
  L08_SIG2 w0.091: v1(43.05,61.61) 43.32,61.34 44.2,61.34 44.69,61.83 44.69,64.03 44.6,64.12 44.06,64.12 43.97,64.21 43.97,64.4 44.06,64.49 44.6,64.49 44.69,64.58 44.69,64.71 45.69,65.72 45.91,65.72 46,65.81 46,66.59 46.1,66.68 46.26,66.68 46.35,66.59 46.35,65.81 46.44,65.72 46.6,65.72 46.7,65.81 46.7,66.59 46.79,66.68 46.95,66.68 47.04,66.59 47.04,65.81 47.13,65.72 48.12,65.72 48.22,65.81 48.22,66.61 48.31,66.7 48.49,66.7 48.58,66.61 48.58,65.81 48.67,65.72 48.83,65.72 49.1,65.99 49.1,66.69 49.89,67.48 49.89,68.4 50.83,69.34 51.92,69.34 60.68,78.11 75.38,78.11 76.98,76.51 80.79,76.51 81.14,76.86 82.86,76.86 83.27,76.45 83.31,76.45 83.46,76.3 83.86,76.3 v1(84.26,75.9)
  BOTTOM w0.147: R135.1 v1(43.05,61.61) 42.6,61.61 42.34,61.86 41.66,61.86 41.24,62.28 U80.38
PRG1_RGMII2_RXC: length 61.9
  TOP w0.147: U23.U11 v1(85.86,77.5)
  L08_SIG2 w0.091: v1(85.86,77.5) 85.86,77.43 85.17,76.74 83.65,76.74 82.29,78.09 79.18,78.09 78.41,78.87 75.25,78.87 75.18,78.8 60.47,78.8 51.85,70.18 49.9,70.18 49.81,70.09 49.81,69.69 49.72,69.6 49.56,69.6 49.44,69.71 49.44,70.48 49.35,70.57 49.17,70.57 49.08,70.48 49.08,69.81 48.98,69.72 48.8,69.72 48.71,69.81 48.71,70.48 48.62,70.57 48.44,70.57 48.34,70.48 48.34,69.81 48.25,69.72 48.07,69.72 47.98,69.81 47.98,70.48 47.89,70.57 47.7,70.57 47.61,70.48 47.61,69.81 47.52,69.72 47.34,69.72 47.25,69.81 47.25,70.48 47.16,70.57 46.97,70.57 46.88,70.48 46.88,69.81 46.79,69.72 46.61,69.72 46.52,69.81 46.52,70.48 46.42,70.57 44.49,70.57 43.48,69.57 43.17,69.57 42.93,69.32 42.93,68.2 44.17,66.95 44.17,65.98 43.68,65.49 v1(43.31,65.49)
  BOTTOM w0.147: v1(43.31,65.49) 43.3,65.5 U80.32
PRG1_RGMII2_TD0: length 59.5
  TOP w0.147: v1(44.83,70.12) 45.83,70.12 46.05,70.34 47.3,70.34 49.4,72.44 53.29,72.44 55.34,74.5 55.34,76.52 55.2,76.67 54.25,76.67 54.1,76.82 54.1,77.11 54.25,77.26 55.2,77.26 55.34,77.41 55.34,77.7 55.2,77.85 54.25,77.85 54.1,78 54.1,78.29 54.25,78.44 55.2,78.44 55.34,78.58 55.34,78.88 55.2,79.03 54.25,79.03 54.1,79.17 54.1,79.47 54.25,79.62 55.2,79.62 55.34,79.76 55.34,80.49 57.4,82.55 66.89,82.55 67.53,81.91 68.22,81.91 69.86,80.27 72.64,80.27 73.03,79.88 77.88,79.88 80.04,77.72 82.4,77.72 82.58,77.9 U23.AA10
  BOTTOM w0.147: U80.28 43.35,67.5 44.2,68.34 44.2,69.48 v1(44.83,70.12)
PRG1_RGMII2_TD1: length 60
  TOP w0.147: U23.V10 v1(85.06,78.3)
  L08_SIG2 w0.091: v1(85.06,78.3) 85.46,77.91 85.46,77.34 85.08,76.96 83.74,76.96 82.24,78.46 79.38,78.46 78.02,79.83 75.69,79.83 75.03,79.17 60.32,79.17 52.2,71.04 50.98,71.04 50.89,71.14 50.89,71.77 50.8,71.86 50.61,71.86 50.52,71.77 50.52,71.1 50.43,71.01 49.3,71.01 49.21,71.1 49.21,71.77 49.12,71.86 48.94,71.86 48.85,71.77 48.85,71.1 48.76,71.01 48.57,71.01 48.48,71.1 48.48,71.77 48.39,71.86 48.21,71.86 48.12,71.77 48.12,71.1 48.02,71.01 47.81,71.01 47.72,71.1 47.72,71.36 47.63,71.45 47.45,71.45 47.36,71.36 47.36,71.1 47.26,71.01 47.08,71.01 46.99,71.1 46.99,71.41 46.9,71.5 46.71,71.5 46.62,71.41 46.62,71.1 46.53,71.01 46.35,71.01 46.26,71.1 46.26,71.41 46.17,71.5 45.98,71.5 45.89,71.41 45.89,71.1 45.8,71.01 45.62,71.01 45.53,71.1 45.53,71.41 45.43,71.5 45.25,71.5 45.16,71.41 45.16,71.1 45.07,71.01 44.32,71.01 v1(43.31,69.99)
  BOTTOM w0.147: U80.27 43.43,68 43.81,68.38 43.81,68.78 43.82,68.79 43.82,69.16 43.81,69.17 43.81,69.48 v1(43.31,69.99)
PRG1_RGMII2_TD2: length 60
  TOP w0.147: U23.U10 v1(85.86,78.3)
  L08_SIG2 w0.091: v1(43.36,68.98) 44.24,68.1 44.46,68.1 44.55,68.19 44.55,68.37 44.64,68.46 44.81,68.46 44.9,68.37 44.9,68.19 44.99,68.1 45.15,68.1 45.38,68.33 45.58,68.33 45.81,68.1 46.16,68.1 46.25,68.01 46.25,66.95 46.35,66.86 46.51,66.86 46.6,66.95 46.6,68.01 46.69,68.1 46.85,68.1 46.94,68.01 46.94,66.95 47.04,66.86 47.2,66.86 47.29,66.95 47.29,68.01 47.38,68.1 47.78,68.1 47.87,68.01 47.87,67.65 47.97,67.56 48.13,67.56 48.22,67.65 48.22,68.01 48.31,68.1 48.47,68.1 48.57,68.01 48.57,67.65 48.66,67.56 48.82,67.56 48.91,67.65 48.91,68.01 49,68.1 49.17,68.1 49.26,68.01 49.26,67.65 49.35,67.56 49.51,67.56 49.6,67.65 49.6,68.73 50.55,69.67 51.86,69.67 60.62,78.43 75.62,78.43 76.45,77.6 79.07,77.6 79.17,77.7 82.38,77.7 83.55,76.52 85.52,76.52 86.26,77.25 86.26,77.91 v1(85.86,78.3)
  BOTTOM w0.147: v1(43.36,68.98) 43.36,68.64 43.22,68.5 U80.26
PRG1_RGMII2_TD3: length 59.6
  TOP w0.147: U23.AA11 81.83,77.1 81.16,76.43 79.14,76.43 78.48,75.77 76.47,75.77 75.43,74.73 73.71,74.73 72.5,75.93 72.5,77.21 72.16,77.56 68.1,81.62 67.41,81.62 66.77,82.25 57.56,82.25 55.67,80.37 55.67,80.14 55.82,79.99 56.49,79.99 56.64,79.84 56.64,79.55 56.49,79.4 55.82,79.4 55.67,79.25 55.67,78.96 55.82,78.81 56.49,78.81 56.64,78.66 56.64,78.37 56.49,78.22 55.82,78.22 55.67,78.07 55.67,74.11 53.62,72.06 49.44,72.06 47.42,70.04 46.18,70.04 45.67,69.54 42.37,69.54 v1(41.65,68.82)
  BOTTOM w0.147: v1(41.65,68.82) 41.65,68.83 41.81,69 U80.25
PRG1_RGMII2_TX_CTL: length 59.7
  TOP w0.147: U23.Y11 83.46,76.7 81.78,76.7 81.57,76.49 81.57,76.43 81.28,76.13 79.26,76.13 78.47,75.34 76.45,75.34 75.56,74.44 73.49,74.44 72.21,75.72 72.21,77.09 72.04,77.26 67.98,81.32 67.29,81.32 66.65,81.96 62.6,81.96 56,75.35 56,70.93 51.79,66.73 49.6,66.73 45.55,62.68 45.14,62.68 44.82,62.36 42.67,62.36 41.85,63.18 41.85,63.32 v1(41.53,63.64)
  BOTTOM w0.147: U80.37 41.74,63.43 v1(41.53,63.64)
PRG1_RGMII2_TXC: length 60
  TOP w0.147: U23.Y10 83.46,78.3 80.09,78.3 78,80.39 v1(75.82,80.39)
  L08_SIG2 w0.091: v1(75.82,80.39) 69.85,80.39 68.99,79.53 63.44,79.53 63.34,79.62 63.34,80.66 63.25,80.75 63.07,80.75 62.98,80.66 62.98,79.62 62.89,79.53 62.61,79.53 62.52,79.62 62.52,80.68 62.43,80.77 62.24,80.77 62.15,80.68 62.15,79.62 62.06,79.53 61.88,79.53 61.79,79.62 61.79,80.68 61.69,80.77 61.51,80.77 61.42,80.68 61.42,79.62 61.33,79.53 61.15,79.53 61.05,79.62 61.05,80.68 60.96,80.77 60.78,80.77 60.69,80.68 60.69,79.62 60.6,79.53 59.8,79.53 52.53,72.26 46.48,72.26 46.1,71.88 44.09,71.88 42.55,70.33 42.55,67.77 v1(43.31,67)
  BOTTOM w0.147: U80.29 43.3,67 v1(43.31,67)
PRG1_RGMII_INTN: length 151.2
  TOP w0.147: v1(36.79,87.43) 36.8,87.43 37.13,87.1 R105.1 37.48,87.1 37.72,86.85 37.72,86.5 38.37,85.85 U20.44
  L03_SIG1 w0.091: v1(36.79,87.43) 36.79,85.4 36.8,85.39 36.8,70.91 36.66,70.77 v1(36.66,60.69)
  L08_SIG2 w0.091: v1(36.66,60.69) 37.62,60.69 39.37,58.94 45.31,58.94 46.78,60.42 46.78,62.08 47.17,62.46 47.17,63.02 61.48,77.34 75.07,77.34 76.67,75.75 80.32,75.75 81.02,75.75 82.06,74.71 86.91,74.71 87.07,74.87 87.07,76.59 87.87,77.38 87.87,79.27 88.09,79.49 91.72,79.49 91.85,79.36 91.85,77.38 92.1,77.13 94.12,77.13 94.25,77.26 94.25,77.79 94.39,77.92 94.81,77.92 95.08,77.66 95.08,74.86 95.23,74.7 95.7,74.7 95.88,74.52 95.88,72.53 95.89,72.53 96.14,72.28 98.09,72.28 98.3,72.07 98.3,70.71 101.7,67.31 101.7,64.83 101.37,64.5 v1(101.37,62.24)
  BOTTOM w0.147: R250.1 37.59,105.68 36.7,104.79 36.7,97.04 35.94,96.28 35.94,90.95 36.96,89.93 36.96,87.6 v1(36.79,87.43) ; U80.44 38.24,62.26 37.59,61.62 37.59,61.28 R368.1 37,61.02 36.67,60.69 v1(36.66,60.69) ; R597.1 99.46,63.64 100.86,62.24 v1(101.37,62.24)
PRG1_RGMII_INTN_RC: length 9.8
  TOP w0.147: v1(101.27,65.7) 100.82,65.7 99.06,67.46 99.06,68.47 98.66,68.87 98.66,70.07 98.42,70.3 97.86,70.3 U23.C19
  BOTTOM w0.147: R597.2 C491.1 100.73,65.15 v1(101.27,65.7)
PRG_EARTH: length 3.3
  BOTTOM w0.254: v1(2.18,85.84) 2.24,85.9 C295.1 2.24,86.86 v1(3.45,86.86)
  BOTTOM w0.381: R304.1 5.17,87.74 v1(5.5,88.06)
PRI_INN: length 7.2
  TOP w0.147: R55.1 v1(63.5,102.88) 62.66,103.72 62.66,105.12 v1(63.11,105.56)
  BOTTOM w0.147: U70.14 v1(63.11,105.56) ; C252.2 R55.1 v1(63.5,102.88)
RESETSTATZ: length 234.8
  TOP w0.147: TP68.1 106.96,41.7 v1(108.08,42.81) ; U54.2 v1(116.46,25.03) ; v1(40.19,37.78) 44.77,37.78 46.91,35.64 58.01,35.64 v1(59.95,33.7) ; U105.8 53.81,53.96 v1(54.31,53.47) ; U23.F16 v1(95.46,72.7)
  L03_SIG1 w0.091: v1(102.74,70.4) 103.01,70.66 103.62,70.66 103.98,70.3 103.98,66.33 106.68,63.64 106.68,55.77 109.25,53.2 117.31,53.2 120.02,50.49 120.02,50.31 120.85,49.48 121.96,49.48 122.75,48.69 122.75,47.76 122.76,47.75 122.76,32.73 116.46,26.43 ; 116.46,26.43 113.41,29.48 113.41,37.04 113.06,37.39 113.06,38.97 109.22,42.81 v1(108.08,42.81) ; 116.46,26.43 v1(116.46,25.03) ; v1(59.95,33.7) 59.95,39.75 54.31,45.39 v1(54.31,53.47)
  L08_SIG2 w0.091: v1(116.46,25.03) 116.46,24.02 110.94,18.5 102.28,18.5 99.46,21.32 93.51,21.32 91.03,18.84 82.01,18.84 77.34,23.51 64.39,23.51 60.96,26.94 60.96,32.77 60.3,33.43 60.22,33.43 v1(59.95,33.7)
  BOTTOM w0.114: 98.39,73.1 97.31,73.1 95.86,73.1 v1(95.46,72.7)
  BOTTOM w0.147: R344.2 104.06,70.73 103.07,70.73 v1(102.74,70.4) 102.17,70.97 101.31,70.97 99.17,73.1 98.39,73.1 ; 38.23,43.83 38.06,43.99 33.94,43.99 33.66,43.7 32.77,43.7 32.27,44.2 U86.3 ; U85.2 v1(108.08,42.81) 106.95,41.69 R435.2 ; U91.28 59.21,33.41 59.5,33.7 v1(59.95,33.7)
  BOTTOM w0.254: 38.23,43.83 U88.2 38.23,39.17 39.61,37.78 v1(40.19,37.78)
SEL_XDS: length 51.8
  TOP w0.147: v1(104.52,34.3) 104.52,33.67 104.76,33.43 U47.4 ; v1(121.46,50.9) 121.1,51.27 U56.4 ; v1(94.61,35.57) 94.75,35.57 94.88,35.44 U45.6
  L08_SIG2 w0.091: v1(121.46,50.9) 121.2,50.64 121.2,50.46 117.88,47.14 117.88,46.53 116.33,44.98 116.33,37.24 112.27,33.17 105.65,33.17 v1(104.52,34.3) 102.55,36.27 95.31,36.27 v1(94.61,35.57)
  BOTTOM w0.147: 125.32,53.93 125.32,53.18 123.72,51.59 122.15,51.59 v1(121.46,50.9) ; 125.32,53.93 125.46,53.79 125.68,53.79 125.82,53.93 U98.14 ; 125.32,53.93 U98.15
SEL_XDS110_INV: length 154.7
  TOP w0.147: v1(91.69,33.03) 91.69,33.31 91.28,33.73 U46.4 ; U47.2 108.97,32.78 109.2,32.54 R183.1 R184.1 112.2,32.54 v1(112.24,32.5) 113.16,31.59 113.16,19.34 111.44,17.63 110.59,17.63 109.52,16.56 109.52,13.93 109.02,13.43 U60.15 ; J25.8 71.88,39.89 71.63,39.64 71.63,39.26 72.01,38.88 72.48,38.88 73.27,38.09 v1(73.27,37.58) ; v1(71.72,26.42) 73.44,26.42 73.62,26.6 U52.1 74.32,27.55 75.45,26.42 v1(77.31,26.42) 79,26.42 79.21,26.63 U53.1 ; U37.15 88.19,46.58 v1(87.88,46.28) 87.88,46.3 87.69,46.5 U37.14 ; U55.6 138.55,26.01 138.27,25.73 136.7,25.73 136.25,26.19 134.32,26.19 v1(133.2,25.07)
  L03_SIG1 w0.091: v1(87.88,46.28) 89.79,44.38 89.79,40.53 91.69,38.62 v1(91.69,33.03)
  L08_SIG2 w0.091: v1(73.27,37.58) 73.27,37.21 73.28,37.2 73.28,30.45 v1(77.31,26.42) ; v1(112.24,32.5) 112.24,31.98 119.7,24.53 129.29,24.53 129.83,25.07 v1(133.2,25.07)
  BOTTOM w0.147: v1(77.31,26.42) 77.27,26.45 77.27,27.52 U93.1 ; v1(91.69,33.03) 92.33,33.03 94.72,30.65 103.1,30.65 104.95,32.5 v1(112.24,32.5) ; 75.86,38.52 75.86,38.77 76.72,39.63 J33.58 ; 75.86,38.52 75.86,38.38 76.27,37.97 81.77,37.97 87.88,44.08 v1(87.88,46.28) ; 75.86,38.52 75.71,38.37 74.05,38.37 v1(73.27,37.58) ; U94.1 v1(71.72,26.42)
SERDES0_ATB_0: length 4.7
  TOP w0.147: U23.W15 v1(84.26,73.5)
  BOTTOM w0.114: TP66.1 83.86,76.44 83.86,73.9 v1(84.26,73.5)
SERDES0_ATB_1: length 10.6
  TOP w0.147: U23.V16 v1(85.06,72.7)
  L08_SIG2 w0.091: v1(85.06,72.7) 84.66,73.1 84.09,73.1 83.87,72.88 83.87,72.81 83.86,72.79 83.86,72.5 83.51,72.15 82.8,72.15 82.04,71.39 82.04,70.58 81.33,69.87 81.33,69.59 80.04,68.3 v1(78.66,68.3)
  BOTTOM w0.147: TP73.1 78.56,68.2 v1(78.66,68.3)
SERDES0_REXT: length 22.2
  TOP w0.147: U23.T13 v1(86.66,75.1)
  L03_SIG1 w0.091: v1(74.4,76.1) 74.4,75.73 74.45,75.68 74.45,75.55 74.42,75.52 74.42,75.18 74.91,74.69 74.91,74.06 75.66,73.3 75.66,72.15 75.47,71.96 75.47,71.5 75.79,71.18 81.71,71.18 82.05,71.52 84.42,71.52 84.64,71.75 84.64,72.04 84.9,72.3 85.32,72.3 85.44,72.42 85.44,72.89 85.64,73.09 86.18,73.09 86.27,73.18 86.27,74.72 v1(86.66,75.1)
  BOTTOM w0.147: v1(74.4,76.1) 74.4,75.47 74.42,75.44 74.42,75.24 73.94,74.76 R338.1
SERDES_REFCLK0_N: length 81.4
  L08_SIG2 w0.081: v1(30.02,38.09) 30.29,38.36 arc(30.32,38.37) 30.35,38.38 30.43,38.38 arc(30.78,38.52) 30.92,38.87 30.92,43.6 arc(31.2,44.97) 31.97,46.13 arc(33.49,47.14) 35.28,47.5 40.14,47.5 arc(42.78,48.02) 45.01,49.51 50.08,54.58 arc(51.41,56.58) 51.88,58.93 51.88,62.6 arc(52.15,63.96) 52.92,65.11 61.22,73.41 arc(62,73.93) 62.93,74.12 73.31,74.12 arc(73.41,74.1) 73.49,74.05 73.54,73.99 arc(73.91,73.75) 74.34,73.66 76.91,73.66 arc(77.23,73.53) 77.37,73.2 77.37,73.16 arc(77.26,72.89) 77,72.78 76.68,72.78 arc(76.65,72.79) 76.62,72.81 v1(76.38,73.05)
  BOTTOM w0.108: v1(30.02,38.09) 29.71,38.39 29.3,38.39 28.41,37.51 27.44,37.51 27.02,37.93 27.02,38.44 26.86,38.6 26.46,38.6 26.35,38.49 R665.2 ; v1(76.38,73.05) 76.38,72.86 arc(76.44,72.71) 76.6,72.64 77.55,72.64 arc(77.67,72.69) 77.72,72.81 R680.1 77.72,74.34 R622.2 R624.2
SERDES_REFCLK0_N_C: length 8.1
  TOP w0.108: U23.W16 v1(84.26,72.7)
  BOTTOM w0.108: v1(84.26,72.7) 84.26,72.54 arc(84.23,72.47) 84.16,72.44 84.07,72.44 arc(83.87,72.4) 83.7,72.29 83.69,72.28 arc(83.59,72.21) 83.47,72.19 83.19,72.19 arc(83.02,72.22) 82.88,72.31 82.63,72.56 arc(82.33,72.76) 81.98,72.83 78.77,72.83 arc(78.73,72.88) 78.71,72.95 78.7,72.97 R680.2 ; R333.1 R661.2
SERDES_REFCLK0_P: length 81.3
  L08_SIG2 w0.081: v1(76.38,72.2) 76.62,72.44 arc(76.65,72.46) 76.68,72.47 77,72.47 arc(77.48,72.67) 77.69,73.16 77.69,73.2 arc(77.46,73.75) 76.91,73.98 74.34,73.98 arc(74.03,74.04) 73.77,74.21 73.71,74.27 arc(73.53,74.39) 73.31,74.43 62.93,74.43 arc(61.88,74.23) 60.99,73.63 52.7,65.34 arc(51.86,64.08) 51.56,62.6 51.56,58.93 arc(51.12,56.7) 49.86,54.81 44.79,49.74 arc(42.66,48.32) 40.14,47.82 35.28,47.82 arc(33.37,47.44) 31.75,46.35 arc(30.9,45.09) 30.61,43.6 30.61,38.87 arc(30.56,38.75) 30.43,38.7 30.35,38.7 arc(30.32,38.7) 30.29,38.72 v1(30.02,38.99)
  BOTTOM w0.108: v1(30.02,38.99) 29.71,38.68 29.18,38.68 28.29,37.8 27.56,37.8 27.3,38.05 27.3,38.56 26.98,38.89 26.46,38.89 26.35,39 R666.2 ; R625.2 R623.2 77.57,71.18 arc(77.68,71.34) 77.72,71.53 R679.1 77.51,72.28 arc(77.42,72.33) 77.32,72.35 76.75,72.35 arc(76.55,72.31) v1(76.38,72.2)
SERDES_REFCLK0_P_C: length 8.1
  TOP w0.108: U23.W17 v1(84.26,71.9)
  BOTTOM w0.108: R346.1 R662.2 R679.2 78.7,72.4 arc(78.71,72.46) 78.75,72.51 78.76,72.54 81.98,72.54 arc(82.22,72.49) 82.43,72.36 82.68,72.11 arc(82.91,71.95) 83.19,71.9 83.47,71.9 arc(83.7,71.94) 83.9,72.07 83.91,72.08 arc(83.98,72.13) 84.07,72.15 84.16,72.15 arc(84.23,72.12) 84.26,72.05 v1(84.26,71.9)
SERDES_RXN0: length 86.9
  TOP w0.14: U23.Y15 v1(83.46,73.5)
  L08_SIG2 w0.081: J27.A17 27.68,33.95 arc(27.41,34) 27.18,34.16 25.98,35.36 arc(25.83,35.59) 25.77,35.86 25.84,36.45 25.84,37.27 arc(25.97,37.57) 26.28,37.7 29.19,37.7 arc(29.42,37.66) 29.61,37.53 29.67,37.47 arc(29.84,37.35) 30.05,37.31 34.36,37.31 arc(35.57,37.55) 36.6,38.24 41.76,43.4 arc(43.34,44.46) 45.21,44.83 48.64,44.83 arc(49.99,45.1) 51.13,45.86 52.1,46.83 arc(52.8,47.88) 53.05,49.12 53.05,58.05 arc(53.95,62.58) 56.52,66.42 56.58,66.49 56.65,66.54 arc(56.65,66.54) 56.65,66.54 62.29,72.18 arc(63.32,72.87) 64.55,73.11 72.83,73.11 arc(73.28,73.02) 73.66,72.77 74.52,71.92 arc(75.55,71.22) 76.78,70.98 79.57,70.98 arc(80.52,71.17) 81.33,71.71 82.64,73.02 arc(82.85,73.16) 83.1,73.21 83.14,73.21 83.15,73.22 arc(83.19,73.24) 83.22,73.26 v1(83.46,73.5)
SERDES_RXP0: length 86.9
  TOP w0.14: U23.Y16 v1(83.46,72.7)
  L08_SIG2 w0.081: v1(83.46,72.7) 83.39,72.78 arc(83.26,72.86) 83.1,72.89 arc(82.97,72.87) 82.86,72.79 81.55,71.48 arc(80.64,70.88) 79.57,70.66 76.78,70.66 arc(75.43,70.93) 74.29,71.69 73.44,72.55 arc(73.16,72.73) 72.83,72.8 64.55,72.8 arc(63.45,72.58) 62.51,71.95 56.88,66.32 arc(56.86,66.3) 56.84,66.28 56.79,66.25 56.74,66.2 arc(54.24,62.46) 53.37,58.05 53.37,49.12 arc(53.09,47.76) 52.32,46.61 51.36,45.64 arc(50.11,44.81) 48.64,44.51 45.21,44.51 arc(43.46,44.17) 41.98,43.18 36.82,38.01 arc(35.69,37.26) 34.36,36.99 30.05,36.99 arc(29.72,37.06) 29.45,37.24 29.39,37.3 arc(29.3,37.36) 29.19,37.38 28.96,37.38 arc(28.84,37.33) 28.79,37.21 28.79,37.06 arc(28.62,36.9) 28.46,37.06 28.46,37.21 arc(28.29,37.38) 28.12,37.21 28.12,36.96 arc(27.95,36.79) 27.79,36.96 27.79,37.21 arc(27.62,37.38) 27.45,37.21 27.45,36.99 arc(27.28,36.82) 27.12,36.99 27.12,37.21 arc(26.95,37.38) 26.78,37.21 26.78,36.99 arc(26.61,36.82) 26.45,36.99 26.45,37.21 arc(26.4,37.33) 26.28,37.38 arc(26.2,37.35) 26.16,37.27 26.16,36.45 arc(26.18,36.35) 26.24,36.27 26.4,36.11 arc(26.57,35.99) J27.A16
SERDES_TXN0: length 90.4
  TOP w0.108: C100.1 74.3,71.09 arc(74.26,71.07) 74.22,71.06 73.81,71.06 arc(73.77,71.07) 73.75,71.09 v1(73.47,71.37)
  L08_SIG2 w0.081: J27.B15 25.78,29.06 arc(25.8,28.93) 25.87,28.81 arc(25.88,28.79) 25.9,28.77 27.4,27.27 arc(27.66,27.1) 27.97,27.03 28.57,27.03 arc(29.59,26.83) 30.45,26.26 31.47,25.24 arc(32.14,24.8) 32.93,24.64 47.44,24.64 arc(48.43,24.84) 49.28,25.4 arc(49.65,25.96) 49.78,26.62 49.78,36.71 arc(49.92,37.4) 50.31,37.99 54.08,41.76 arc(55.35,43.66) 55.8,45.91 55.8,55.32 arc(55.96,56.17) 56.45,56.89 61.15,61.6 arc(61.29,61.78) 61.38,61.99 arc(61.38,62) 61.38,62.01 61.38,67.62 arc(61.54,68.42) 62,69.11 64.08,71.19 arc(64.49,71.47) 64.98,71.56 68.98,71.56 arc(69.72,71.42) 70.36,70.99 70.36,70.99 arc(70.76,70.72) 71.24,70.63 72.1,70.63 arc(72.3,70.67) 72.47,70.78 72.62,70.94 arc(72.77,71.04) 72.95,71.07 73.14,71.07 arc(73.18,71.08) 73.2,71.1 v1(73.47,71.37)
SERDES_TXN0_C: length 8.8
  TOP w0.108: 75.13,71.36 75.22,71.27 arc(75.45,71.11) 75.72,71.06 77.8,71.06 arc(77.98,71.09) 78.13,71.2 79.27,72.34 arc(79.84,72.72) 80.51,72.85 82.49,72.85 arc(82.57,72.88) 82.6,72.96 82.6,73 arc(82.63,73.07) 82.71,73.1 U23.AA16
SERDES_TXP0: length 90.4
  TOP w0.108: v1(73.47,70.46) 73.75,70.74 arc(73.76,70.75) 73.78,70.76 73.83,70.77 74.22,70.77 arc(74.26,70.76) 74.3,70.74 C102.1
  L08_SIG2 w0.081: v1(73.47,70.46) 73.2,70.73 arc(73.18,70.75) 73.14,70.75 72.95,70.75 arc(72.89,70.74) 72.85,70.71 72.69,70.55 arc(72.42,70.37) 72.1,70.31 71.24,70.31 arc(70.64,70.43) 70.13,70.77 arc(69.6,71.12) 68.98,71.25 64.98,71.25 arc(64.61,71.17) 64.3,70.97 62.22,68.88 arc(61.83,68.3) 61.7,67.62 61.7,62.01 arc(61.69,61.96) 61.68,61.91 arc(61.57,61.62) 61.38,61.37 56.67,56.67 arc(56.26,56.05) 56.11,55.32 56.11,45.91 arc(55.64,43.54) 54.3,41.53 50.54,37.77 arc(50.21,37.28) 50.1,36.71 50.1,26.62 arc(49.94,25.84) 49.5,25.18 arc(48.55,24.54) 47.44,24.32 32.93,24.32 arc(32.02,24.5) 31.24,25.02 30.23,26.03 arc(29.47,26.54) 28.57,26.72 27.97,26.72 arc(27.54,26.8) 27.17,27.05 26.79,27.43 arc(26.67,27.48) 26.55,27.43 26.5,27.37 arc(26.26,27.37) 26.26,27.61 26.32,27.67 arc(26.32,27.9) 26.08,27.9 25.99,27.81 arc(25.75,27.81) 25.75,28.05 25.84,28.14 arc(25.89,28.26) 25.84,28.38 25.67,28.55 arc(25.64,28.58) 25.62,28.61 J27.B14
SERDES_TXP0_C: length 8.9
  TOP w0.108: U23.AA17 82.71,72.3 arc(82.63,72.34) 82.6,72.41 82.6,72.45 arc(82.57,72.53) 82.49,72.56 80.51,72.56 arc(79.95,72.45) 79.47,72.13 78.34,70.99 arc(78.09,70.83) 77.8,70.77 75.53,70.77 arc(75.43,70.75) 75.35,70.69 75.13,70.47
SOC_CLKIN: length 106.4
  TOP w0.147: R137.1 v1(98.21,61.95)
  L03_SIG1 w0.091: v1(62.61,87.9) 60.96,86.25 60.96,75.58 62.48,74.06 70.67,74.06 72.44,72.29 72.44,68.55 73.17,67.83 75.05,67.83 77.71,65.17 v1(78.74,65.17)
  L08_SIG2 w0.091: v1(78.74,65.17) 79.25,64.66 79.25,56.4 83.69,51.96 92.46,51.96 98.21,57.71 v1(98.21,61.95)
  BOTTOM w0.147: v1(62.61,87.9) 72.14,87.9 73.79,89.55 73.79,99.72 72.16,101.35 71.17,101.35 70.89,101.07 70.04,101.07 69.32,100.34 R272.2
SOC_DVDD1V8: length 4.3
  TOP w0.254: U23.E12 v1(96.26,75.9) ; U23.K14 v1(92.26,74.3) ; U23.K16 v1(92.26,72.7) ; U23.M14 v1(89.86,74.3) ; U23.J15 v1(93.06,73.5) ; U23.M15 v1(89.86,73.5)
  BOTTOM w0.254: C383.1 92.27,72.71 v1(92.26,72.7) ; v1(89.86,73.5) 89.74,73.62 C379.1 ; C359.1 96.41,75.9 v1(96.26,75.9)
  vias: v1(106.83,73.5) v1(108.23,73.47) v1(108.96,73.5) v1(126.62,111.01) v1(126.62,110) v1(126.62,108.98) v1(126.62,107.96) v1(127.64,111.01) v1(127.64,110) v1(127.64,108.98) v1(127.64,107.96) v1(128.65,111.01) v1(128.65,110) v1(128.65,108.98) v1(128.65,107.96)
SOC_DVDD3V3: length 15.7
  TOP w0.254: U23.F9 v1(95.46,79.1) ; U23.P15 v1(88.26,73.5) ; U23.R13 v1(87.46,75.1) ; U23.F14 v1(95.46,74.3) ; U23.G14 v1(94.66,74.3) ; U23.R8 v1(87.46,79.9) ; U23.R10 v1(87.46,78.3) ; U23.P14 v1(88.26,74.3) ; U23.N6 v1(89.06,81.5) ; U23.G8 v1(94.66,79.9) ; U23.G10 v1(94.66,78.3) ; U23.T9 v1(86.66,79.1) ; U23.G12 v1(94.66,75.9) ; U23.F13 v1(95.46,75.1) ; U23.P7 v1(88.26,80.7) ; U23.F11 v1(95.46,77.5) ; U23.M7 v1(89.86,80.7)
  L06_PWR2 w0.381: v1(88.26,73.5) v1(88.26,74.3)
  BOTTOM w0.254: v1(94.66,78.3) 94.65,78.31 C331.1 ; C374.1 95.58,74.18 v1(95.46,74.3) ; v1(87.46,79.9) 87.34,80.02 C319.1 ; C328.1 95.61,79.1 v1(95.46,79.1) ; v1(95.46,75.1) 95.45,75.11 C361.1 ; C337.1 95.58,77.62 v1(95.46,77.5) 95.58,77.38 C343.1 ; C360.1 87.34,75.22 v1(87.46,75.1) ; C378.1 v1(88.26,73.5) ; v1(94.66,74.3) 94.85,74.11 C376.1 ; v1(94.66,79.9) 94.78,79.78 C321.1 ; C309.1 89.98,80.82 v1(89.86,80.7) ; v1(86.66,79.1) 86.78,79.22 C326.1 ; v1(87.46,78.3) 87.58,78.42 C333.1 ; v1(88.26,80.7) 88.38,80.82 C312.1 ; C351.1 v1(94.66,75.9) ; v1(89.06,81.5) 88.94,81.62 C304.1
  vias: v1(103.35,73.5) v1(104.41,73.5) v1(133.35,92.6) v1(133.35,91.58) v1(133.35,90.57) v1(133.35,89.55) v1(134.37,92.6) v1(134.37,91.58) v1(134.37,90.57) v1(134.37,89.55) v1(135.38,92.6) v1(135.38,91.58) v1(135.38,90.57) v1(135.38,89.55)
SOC_EMU0: length 187.7
  TOP w0.147: U45.5 96.89,35.94 97.32,36.37 102.4,36.37 106.17,40.15 106.17,46.09 113.33,53.25 116.22,53.25 117.73,54.76 122.07,54.76 122.21,54.89 126.4,54.89 128.55,57.05 128.55,59.77 126.72,61.6 124.49,61.6 124.35,61.45 124.35,61.11 v1(124.08,60.85) ; U23.D10 v1(97.06,78.3) ; J39.1 R634.2 ; v1(135.59,25.4) 138.68,25.4 139.05,25.77 U55.5
  L03_SIG1 w0.091: v1(97.06,78.3) 97.46,78.71 101.5,78.71 101.78,78.43 102.92,78.43 103.59,77.77 111.4,77.77 116.1,73.07 116.1,67.29 116.74,66.65 120.02,66.65 124.36,62.32 124.36,61.13 v1(124.08,60.85)
  L08_SIG2 w0.091: v1(135.59,25.4) 135.59,27.13 134.75,27.97 134.75,32.46 128.04,39.16 128.04,40.56 128.01,40.59 128.01,55.61 124.41,59.22 124.41,60.52 v1(124.08,60.85)
  BOTTOM w0.147: J39.1 161.16,42.42 161.16,40.49 165.68,35.97 165.68,33.78 165.02,33.12 151.16,33.12 145.87,27.84 140.94,27.84 138.51,25.4 v1(135.59,25.4)
SOC_EMU1: length 187.3
  TOP w0.147: v1(134.98,23.62) 136.07,24.71 138.65,24.71 139.05,24.31 U55.4 ; v1(98.04,35.83) 98.08,35.83 98.2,35.94 U45.4 ; U23.E10 v1(96.26,78.3) ; J40.1 R635.2
  L03_SIG1 w0.091: v1(134.98,23.62) 134.64,23.95 128.71,23.95 125.6,27.07 125.6,50.17 124.51,51.26 124.51,53.06 123.23,54.34 110.23,54.34 107.9,56.66 107.9,57.17 107.61,57.46 v1(107.61,59.35)
  L08_SIG2 w0.091: v1(96.26,78.3) 96.26,78.13 96.66,77.73 96.66,77.09 97.16,76.6 98.04,76.6 100.33,74.31 103.33,74.31 103.86,73.78 103.86,72.98 108.16,68.68 108.16,68.61 108.2,68.57 108.2,65.35 110.29,63.26 110.29,59.58 109.8,59.09 107.88,59.09 v1(107.61,59.35) ; v1(134.98,23.62) 134.49,24.1 119.81,24.1 111.49,32.43 104.99,32.43 103.15,34.26 99.61,34.26 v1(98.04,35.83)
  BOTTOM w0.147: v1(134.98,23.62) 136.19,24.84 138.38,24.84 141.02,27.48 146,27.48 151.33,32.82 165.2,32.82 165.99,33.6 165.99,36.09 162.71,39.37 162.71,43.19 J40.1
SOC_I2C0_SCL: length 135.2
  TOP w0.147: v1(105.99,119.44) 105.9,119.53 U7.6 103.64,119.53 103.38,119.79 103.38,122.93 J5.3 106.02,125.57 107.87,125.57 108.58,124.86 108.58,123.54 109.29,122.83 113.41,122.83 115.88,120.36 115.88,116.14 112.18,112.44 112.18,90.05 113.37,88.86 113.37,83.02 116.28,80.11 116.28,69.64 112.69,66.05 109.27,66.05 109.17,66.16 v1(108.71,66.16) ; J2.E1 v1(74.55,132.35)
  L03_SIG1 w0.091: v1(74.55,132.35) 75.76,132.35 77.5,130.61 77.5,129.46 79.92,127.05 83.41,127.05 85.85,124.6 88.77,124.6 94.16,119.21 101.94,119.21 104.85,122.12 J5.3
  BOTTOM w0.147: R598.1 103.9,66.17 104.34,65.73 108.28,65.73 v1(108.71,66.16) 109.45,65.42 R358.2 ; v1(105.99,119.44) 105.9,119.53 U7.6
SOC_I2C0_SCL_RC: length 7.2
  TOP w0.147: v1(101.94,67.95) 100.85,69.04 100.85,69.52 100.36,70.01 100.36,70.98 99.84,71.5 U23.A18
  BOTTOM w0.147: R598.2 C492.1 v1(101.94,67.95)
SOC_I2C0_SDA: length 126.4
  TOP w0.147: J2.E2 v1(73.28,132.35) ; v1(109.47,66.69) 109.8,66.37 112.59,66.37 115.98,69.76 115.98,79.99 113.08,82.9 113.08,88.74 111.89,89.93 111.89,112.56 115.59,116.26 115.59,120.24 113.29,122.54 109.17,122.54 108.22,123.49 108.22,123.56 J5.2 104.77,121.77 U7.5 v1(105.96,120.18)
  L03_SIG1 w0.091: J5.2 101.98,118.99 94.07,118.99 88.68,124.38 85.76,124.38 83.31,126.83 79.83,126.83 77.28,129.37 77.28,130.5 75.95,131.84 73.79,131.84 v1(73.28,132.35)
  BOTTOM w0.147: R599.1 107.29,66.45 107.53,66.69 v1(109.47,66.69) R354.2 ; U7.5 v1(105.96,120.18)
SOC_I2C0_SDA_RC: length 11.3
  TOP w0.147: v1(101.87,68.74) 101.29,69.31 101.29,69.46 100.65,70.1 100.65,71.1 99.85,71.9 98.66,71.9 U23.B18
  BOTTOM w0.147: v1(101.87,68.74) 103.2,68.74 103.38,68.56 104.44,68.56 104.76,68.24 104.76,68.03 105.35,67.43 C493.1 R599.2
SOC_I2C1_SCL: length 493.1
  TOP w0.147: U28.1 139.56,70.1 139.06,69.61 137.79,69.61 137.54,69.86 v1(137.54,70.75) 137.56,70.77 U28.5 ; U16.5 135.85,102.42 v1(135.76,102.5) ; U29.1 123.38,66.75 123.19,66.56 120.8,66.56 120.43,66.93 114.26,66.93 113.03,65.7 104.87,65.7 103.76,66.82 102.36,66.82 100.57,68.61 100.57,69.4 100.08,69.89 100.08,70.86 99.82,71.12 99.47,71.12 99.46,71.1 97.86,71.1 U23.C18 ; U29.1 v1(124.08,67.58) ; U29.1 123.38,68.51 123.57,68.7 TP25.1 ; v1(71.5,100.81) 71.18,100.49 71.18,93.02 71.4,92.8 U18.1 ; v1(152.78,118.76) 152.25,118.76 152.17,118.85 U6.5 ; U34.15 43.05,41.93 43.68,41.3 45.85,41.3 46.63,42.09 v1(51.97,42.09) ; U51.7 v1(66.02,31.47) ; v1(144.53,109.23) 144.54,109.22 U11.5 147.46,109.22 147.83,108.85 147.83,107.98 147.57,107.72 U11.2 ; U1.5 v1(85.36,127.54) ; R659.1 55.63,57.87 55.39,58.12 54.75,58.12 v1(54.69,58.17) ; J27.B5 13.78,28.78 15.79,26.77 30,26.77 37.7,19.06 49.28,19.06 51.44,21.22 51.44,28.71 53.48,30.75 57.46,30.75 58.78,32.07 59.32,32.07 v1(59.9,32.65) ; U14.5 125.6,104.56 v1(125.6,103.52)
  TOP w0.254: R13.1 v1(129.29,119.14)
  TOP w0.305: U16.1 138.41,103.64 v1(138.4,103.65)
  L03_SIG1 w0.091: v1(66.02,31.47) 64.84,32.65 v1(59.9,32.65) 59.51,33.04 59.51,33.81 56.31,37 51.94,37 51.64,37.3 51.64,41.76 v1(51.97,42.09) 51.97,44.65 52.91,45.59 52.91,56.39 v1(54.69,58.17) 53.83,59.03 49.15,59.03 47.62,60.55 47.62,64.38 50.12,66.87 50.12,85.31 49.02,86.41 49.02,88.15 v1(50.16,89.3) ; v1(137.54,70.75) 134.21,67.42 126.71,67.42 126.4,67.1 124.56,67.1 v1(124.08,67.58) ; v1(85.36,127.54) 85.36,126.85 86.09,126.13 90.93,126.13 92.65,124.41 92.65,121.83 95.04,119.44 101.26,119.44 103.66,121.83 103.66,125.39 104.04,125.77 115.02,125.77 120.4,120.4 128.03,120.4 v1(129.29,119.14) 130.45,117.97 151.99,117.97 v1(152.78,118.76) 153.77,117.77 153.77,105.83 152.76,104.82 148.18,104.82 147.8,105.2 147.8,108.57 147.14,109.23 v1(144.53,109.23) 144.15,109.23 138.83,103.91 138.67,103.91 v1(138.4,103.65) ; J27.B5 13.78,30.49 13.71,30.42 13.71,29.88 13.74,29.85 13.74,23.16 10.41,19.83 10.17,19.83 v1(8.49,18.14)
  L08_SIG2 w0.091: v1(85.36,127.54) 83.08,125.26 81.69,125.26 80.9,124.47 75.24,124.47 71.12,120.35 71.12,106.06 70.66,105.6 70.66,101.65 v1(71.5,100.81) ; v1(125.6,103.52) 126.24,103.52 128.02,101.74 135,101.74 v1(135.76,102.5) 136.91,103.65 v1(138.4,103.65) 138.4,103.16 139.45,102.12 139.45,99.46 138.36,98.37 138.36,71.58 v1(137.54,70.75)
  BOTTOM w0.147: v1(124.08,67.58) 124.62,67.58 124.79,67.41 R353.2 ; v1(50.16,89.3) 50.74,88.72 58.85,88.72 60.55,90.42 70.23,90.42 73.3,93.5 73.3,99.67 72.16,100.81 v1(71.5,100.81) ; v1(8.49,18.14) 8.49,17.69 8.09,17.29 6.29,17.29 5.76,17.81 J36.5 ; R265.2 135.51,102.25 v1(135.76,102.5) ; v1(59.9,32.65) 59.57,32.97 59.5,32.97 59.44,33.03 58.67,33.03 58.55,32.91 U91.29
SOC_I2C1_SDA: length 485.2
  TOP w0.147: U23.B19 98.37,70.59 98.54,70.59 98.83,70.3 99.26,70.3 100.28,69.28 100.28,68.39 103.26,65.41 113.16,65.41 114.38,66.64 120.31,66.64 120.77,66.18 123.06,66.18 123.38,65.87 U29.6 v1(124.08,64.78) 124.43,64.78 124.44,64.78 TP27.1 ; U1.2 86.86,127.13 86.61,126.89 85.98,126.89 v1(85.85,127.01) 85.85,127.47 85.86,127.47 U1.4 ; U18.6 72.01,96.7 72.16,96.85 v1(72.16,100.15) ; U34.2 43.05,49.23 42.01,50.27 42.01,52.76 40.49,54.28 40.49,56.44 41.34,57.29 v1(45.61,57.29) 45.86,57.29 R660.1 ; U14.4 126.12,103.34 126.11,103.34 v1(126.11,102.88) ; U28.2 139.06,70.24 138.94,70.12 v1(138.05,70.12) 138.05,70.57 138.06,70.57 U28.4 ; J27.B6 17.05,27.18 31.62,27.18 39.1,19.7 48.77,19.7 51.05,21.99 51.05,29.99 53.59,32.53 v1(58.8,32.53) ; v1(66.02,32.48) 66.67,31.83 U51.6 ; U11.1 144.47,107.22 144.32,107.37 144.32,108.57 144.47,108.72 U11.4 v1(146.68,108.72) ; v1(152.78,119.65) 152.4,120.03 151.26,120.03 151.12,119.89 U6.4 ; v1(136.91,101.23) 136.91,101.24 U16.4
  TOP w0.254: R12.1 v1(131.7,119.27)
  L03_SIG1 w0.091: v1(136.91,101.23) 137.92,102.25 138.43,102.25 138.84,102.66 138.84,103.61 143.95,108.72 v1(146.68,108.72) 146.41,108.45 146.41,105.91 147.78,104.54 152.88,104.54 153.97,105.63 153.97,118.46 v1(152.78,119.65) 151.56,118.43 132.54,118.43 v1(131.7,119.27) 130.32,120.65 120.48,120.65 115.13,126 103.96,126 103.44,125.47 103.44,121.92 101.17,119.66 95.13,119.66 92.87,121.92 92.87,124.5 91.02,126.35 86.52,126.35 v1(85.85,127.01) ; J27.B6 14.78,23.41 v1(9.51,18.14) ; v1(124.08,64.78) 131.88,64.78 136.46,69.36 137.29,69.36 v1(138.05,70.12) ; v1(49.94,89.93) 48.79,88.78 48.79,86.21 49.94,85.06 49.94,66.95 47.4,64.41 47.4,59.09 v1(45.61,57.29) 47.92,54.98 47.92,47.25 51.16,44.02 51.16,37.01 52.53,35.64 56.42,35.64 58.8,33.26 v1(58.8,32.53) 59.69,31.64 65.23,31.64 65.84,31.03 66.2,31.03 66.46,31.28 66.46,32.04 v1(66.02,32.48)
  L08_SIG2 w0.091: v1(126.11,102.88) 128.65,100.34 135.49,100.34 136.38,101.23 v1(136.91,101.23) 136.91,100.86 138.14,99.63 138.14,87.74 136.02,85.61 136.02,82.44 136.91,81.56 136.91,70.75 137.54,70.12 v1(138.05,70.12) ; v1(85.85,127.01) 83.88,125.04 81.73,125.04 80.98,124.29 76.4,124.29 72.39,120.28 72.39,101.74 72.16,101.51 v1(72.16,100.15)
  BOTTOM w0.147: U91.30 58.69,32.41 v1(58.8,32.53) ; R270.2 136.2,100.98 136.46,101.23 v1(136.91,101.23) ; v1(72.16,100.15) 72.95,99.36 72.95,93.78 69.98,90.81 60.43,90.81 58.65,89.03 51.18,89.03 50.28,89.93 v1(49.94,89.93) ; v1(9.51,18.14) 8.33,16.97 6.19,16.97 5.84,17.31 J36.4 ; R357.2 124.79,64.95 124.62,64.78 v1(124.08,64.78)
SOC_I2C1_TA_SCL: length 19.5
  TOP w0.147: v1(65.91,15.13) 67.56,16.78 67.56,21.73 68.33,22.49 68.33,26.81 67.44,27.7 66.45,27.7 v1(65.68,26.94) 66.02,26.6 U51.2
  BOTTOM w0.147: R495.2 v1(65.68,26.94) ; J38.36 v1(65.91,15.13)
SOC_I2C1_TA_SDA: length 17.4
  TOP w0.147: U51.3 66.67,26.6 v1(67.01,26.94) 67.65,26.94 68.03,26.56 68.03,22.71 65.66,20.33 65.66,15.88 v1(64.91,15.13)
  BOTTOM w0.147: J38.38 v1(64.91,15.13) ; R494.2 v1(67.01,26.94)
SOC_MAIN_UART0_CTS_3V3: length 55.6
  TOP w0.147: U23.B16 98.66,73.5 100.22,73.5 101.29,72.43 102.23,72.43 v1(102.79,71.87)
  L03_SIG1 w0.091: v1(102.79,71.87) 103.22,72.3 103.61,72.3 104.66,71.25 104.66,67.7 107.52,64.83 107.52,60.04 108.84,58.73 108.84,56.54 110.82,54.56 123.6,54.56 124.94,53.21 127.98,53.21 128.63,53.86 131.9,53.86 132.78,52.97 v1(137.03,52.97)
  BOTTOM w0.147: v1(137.03,52.97) 137.03,52.85 136.74,52.56 U84.9
SOC_MAIN_UART0_RTS_3V3: length 52.9
  TOP w0.147: v1(101.78,71.85) 101.27,71.85 100.02,73.1 U23.A16
  L03_SIG1 w0.091: v1(135.64,53.96) 135.21,53.54 132.53,53.54 131.99,54.08 128.42,54.08 127.74,53.4 125.32,53.4 123.95,54.76 110.92,54.76 109.06,56.62 109.06,58.77 107.71,60.12 107.71,64.91 104.84,67.77 104.84,71.32 104.84,71.32 103.68,72.48 103.58,72.48 103.58,72.48 102.41,72.48 v1(101.78,71.85)
  BOTTOM w0.147: U84.7 135.58,53.91 v1(135.64,53.96)
SOC_MAIN_UART0_RX_3V3: length 62.3
  TOP w0.147: U23.D15 v1(97.06,73.5)
  L03_SIG1 w0.091: v1(97.06,73.5) 96.66,73.9 96.66,73.91 96.66,73.92 96.66,74.43 96.93,74.7 97.26,74.7 97.46,74.9 97.46,75.23 97.71,75.49 98.37,75.49 99.33,74.53 101.7,74.53 101.89,74.34 102.69,74.34 102.98,74.64 111.51,74.64 113.53,72.61 113.53,66.04 115.23,64.34 115.23,58.65 116.66,57.23 118.34,57.23 118.67,57.56 124.75,57.56 125.41,58.22 130.51,58.22 131.69,57.04 135.62,57.04 v1(137.02,55.64)
  BOTTOM w0.147: U84.8 136.53,53.16 137.02,53.65 v1(137.02,55.64)
SOC_MAIN_UART0_TX_3V3: length 53.1
  TOP w0.147: U23.C16 v1(97.86,72.7)
  L03_SIG1 w0.091: v1(97.86,72.7) 98.3,72.7 98.33,72.66 103.66,72.66 103.76,72.66 105.79,70.63 105.79,67.12 107.89,65.02 107.89,60.5 110.04,58.35 110.04,56.73 111.82,54.95 125.01,54.95 125.66,54.3 132.08,54.3 132.39,53.99 v1(134.87,53.99)
  BOTTOM w0.147: R608.2 135.47,54.58 v1(134.87,53.99) 135.18,53.68 U84.6
SOC_MAIN_UART1_RX_3V3: length 81.1
  TOP w0.147: U23.E15 v1(96.26,73.5)
  L03_SIG1 w0.091: v1(151,37.99) 148.9,37.99 138.59,48.3 138.59,50.22 137.89,50.92 137.89,53.13 134.72,56.3 131.28,56.3 129.91,57.67 125.64,57.67 124.06,56.09 122.1,56.09 121.32,55.31 113.83,55.31 112.72,56.42 112.72,57.5 109.85,60.37 109.52,60.37 v1(109.19,60.04)
  L08_SIG2 w0.091: v1(96.26,73.5) 96.66,73.91 98.07,73.91 100.84,71.13 104.93,71.13 107.54,68.53 107.54,62.15 109.19,60.49 v1(109.19,60.04)
  BOTTOM w0.147: v1(151,37.99) 151.5,37.99 151.8,38.29 U89.8
SOC_MAIN_UART1_TX_3V3: length 85
  TOP w0.147: U23.E14 v1(96.26,74.3)
  L03_SIG1 w0.091: v1(109.73,59.68) 109.99,59.42 109.99,59.41 112.49,56.91 112.49,56.26 113.63,55.13 121.39,55.13 122.17,55.91 125.17,55.91 126.75,57.48 129.84,57.48 131.2,56.12 134.52,56.12 137.67,52.97 137.67,50.82 137.93,50.57 138.37,50.12 138.37,48.21 149.35,37.23 v1(152.4,37.23)
  L08_SIG2 w0.091: v1(109.73,59.68) 109.73,60.52 107.76,62.49 107.76,68.57 104.99,71.34 100.92,71.34 98.76,73.5 98.76,74.11 98.16,74.7 96.66,74.7 v1(96.26,74.3)
  BOTTOM w0.147: U89.6 152.6,38.24 152.66,38.18 152.66,37.48 v1(152.4,37.23) 152.4,36.77 152.25,36.63 R609.2
