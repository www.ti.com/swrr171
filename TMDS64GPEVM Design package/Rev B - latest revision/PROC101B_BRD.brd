# Allegro board PROC101B_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MMC1_CLK_R: length 12.8
  TOP w0.147: U23.L20 91.46,69.5 91.46,68.47 91.67,68.26 91.67,66.37 92.72,65.32 92.72,64.12 93.21,63.64 v1(93.21,57.95)
MMC1_CMD: length 114.2
  TOP w0.147: v1(43.18,26.18) 43.85,26.85 46.65,26.85 47.88,28.08 v1(47.88,28.72) 47.88,29.17 47.88,29.18 U49.2 ; U23.J19 v1(93.06,70.3)
  BOTTOM w0.147: v1(93.06,70.3) 93.19,70.17 93.21,70.17 93.39,70 93.39,70 93.41,69.98 93.59,69.98 94.58,68.99 94.58,68.18 96.31,66.46 96.31,63.28 97.15,62.44 97.15,53.62 92.32,48.78 92.07,48.78 91.06,48.78 89.83,47.56 89.83,41.31 89.83,40.82 80.94,31.92 74.91,31.92 74.79,31.8 74.79,31.42 74.67,31.3 74.51,31.3 74.39,31.42 74.39,31.8 74.27,31.92 74.11,31.92 73.99,31.8 73.99,31.42 73.87,31.3 73.7,31.3 73.59,31.42 73.59,31.8 73.47,31.92 73.3,31.92 73.19,31.8 73.19,31.42 73.07,31.3 72.9,31.3 72.78,31.42 72.78,31.8 72.67,31.92 72.5,31.92 72.38,31.8 72.38,31.42 72.27,31.3 72.1,31.3 71.98,31.42 71.98,31.8 71.86,31.92 71.7,31.92 71.58,31.8 71.58,31.42 71.46,31.3 71.3,31.3 71.18,31.42 71.18,31.8 71.06,31.92 70.89,31.92 70.78,31.8 70.78,31.42 70.66,31.3 70.49,31.3 70.38,31.42 70.38,31.8 70.26,31.92 70.09,31.92 69.97,31.8 69.97,31.42 69.86,31.3 69.69,31.3 69.57,31.42 69.57,31.8 69.46,31.92 69.29,31.92 69.17,31.8 69.17,31.42 69.05,31.3 68.89,31.3 68.77,31.42 68.77,31.8 68.65,31.92 68.49,31.92 68.37,31.8 68.37,31.42 68.25,31.3 68.09,31.3 67.97,31.42 67.97,31.8 67.85,31.92 67.68,31.92 67.57,31.8 67.57,31.42 67.45,31.3 67.28,31.3 67.17,31.42 67.17,31.8 67.05,31.92 63.21,31.92 60.75,34.38 60.75,35.8 58.14,38.4 57.18,38.4 56.96,38.62 56.56,38.62 55.25,39.93 52.96,39.93 49.91,36.88 49.91,29.13 49.49,28.72 v1(47.88,28.72) ; J37.3 42.3,25.42 42.55,25.67 R485.2 43.07,26.07 v1(43.18,26.18)
MMC1_D0: length 113.4
  TOP w0.147: U23.K21 91.86,68.61 92.17,68.3 92.17,67.2 92.67,66.7 92.67,66.05 93.02,65.7 93.02,64.48 v1(93.34,64.15) ; U49.8 v1(47.88,31.83) 47.69,32.02 47.12,32.02 46.1,31 46.1,28.97 45.32,28.19 45.11,28.19 45.07,28.15 44.13,28.15 44.13,28.16 42.36,28.16 42.35,28.15 40.08,28.15 38.86,26.94 v1(38.86,26.21)
  BOTTOM w0.147: v1(47.88,31.83) 47.88,32.52 47.88,32.53 47.88,37.96 50.94,41.02 55.45,41.02 56.95,39.52 57.31,39.52 57.54,39.29 58.51,39.29 61.63,36.16 61.63,34.97 62.51,34.09 75.38,34.09 75.5,34.21 75.5,34.79 75.62,34.9 75.79,34.9 75.9,34.79 75.9,34.21 76.02,34.09 76.19,34.09 76.3,34.21 76.3,34.79 76.42,34.9 76.59,34.9 76.71,34.79 76.71,34.21 76.82,34.09 76.99,34.09 77.11,34.21 77.11,34.79 77.22,34.9 77.39,34.9 77.51,34.79 77.51,34.21 77.63,34.09 77.79,34.09 77.91,34.21 77.91,34.79 78.03,34.9 78.19,34.9 78.31,34.79 78.31,34.21 78.43,34.09 78.59,34.09 78.71,34.21 78.71,34.79 78.83,34.9 79,34.9 79.11,34.79 79.11,34.21 79.23,34.09 79.4,34.09 79.51,34.21 79.51,34.79 79.63,34.9 79.8,34.9 79.92,34.79 79.92,34.21 80.03,34.09 80.2,34.09 80.32,34.21 80.32,34.79 80.43,34.9 80.6,34.9 80.72,34.79 80.72,34.21 80.84,34.09 81.86,34.09 88.95,41.19 88.95,48.02 90.77,49.84 90.77,50.66 95.89,55.78 95.89,61.8 93.85,63.83 93.67,63.83 v1(93.34,64.15) ; v1(38.86,26.21) 38.84,26.19 R479.2 38.1,25.51 37.9,25.31 J37.7
MMC1_D1: length 114.3
  TOP w0.147: U49.7 48.38,32.15 48.13,32.4 v1(46.86,32.4) 45.72,31.26 45.72,29.22 44.94,28.45 44.25,28.45 44.25,28.45 42.23,28.45 42.23,28.45 39.86,28.45 38.73,27.32 37.21,27.32 v1(36.07,26.18) ; U23.L21 91.06,68.47 91.35,68.18 91.35,66.27 92.43,65.2 92.43,64 92.71,63.72 92.71,56.15 v1(91.82,55.26)
  BOTTOM w0.147: v1(91.82,55.26) 91.82,53.23 89.51,50.92 89.51,49.56 88.36,48.41 88.36,41.51 82.85,36 71.35,36 70.04,34.69 63.12,34.69 62.22,35.59 62.22,37.53 57.02,42.73 55.66,42.73 55.54,42.84 55.54,43.57 55.42,43.69 55.26,43.69 55.14,43.57 55.14,42.84 55.02,42.73 54.85,42.73 54.74,42.84 54.74,43.57 54.62,43.69 54.45,43.69 54.34,43.57 54.34,42.84 54.22,42.73 54.05,42.73 53.93,42.84 53.93,43.57 53.82,43.69 53.65,43.69 53.53,43.57 53.53,42.84 53.42,42.73 53.25,42.73 53.13,42.84 53.13,43.57 53.01,43.69 52.85,43.69 52.73,43.57 52.73,42.84 52.61,42.73 52.45,42.73 52.33,42.84 52.33,43.57 52.21,43.69 52.05,43.69 51.93,43.57 51.93,42.84 46.86,37.78 v1(46.86,32.4) ; v1(36.07,26.18) 36.09,26.19 R480.2 36.83,25.34 36.8,25.31 J37.8
MMC1_D2: length 113.7
  TOP w0.147: U23.K19 v1(92.26,70.3) ; v1(45.96,26.07) 46.41,26.07 46.56,26.22 47.41,26.22 50.04,28.84 50.04,31.46 49.48,32.02 v1(48.9,32.02) 48.88,32.01 U49.6
  BOTTOM w0.147: v1(45.96,26.07) R483.2 45.29,25.59 45.11,25.41 44.6,25.41 44.5,25.31 J37.1 ; v1(48.9,32.02) 48.9,36.7 52.55,40.35 52.72,40.52 55.49,40.52 56.81,39.21 57.2,39.21 57.42,38.99 58.38,38.99 61.34,36.04 61.34,34.85 62.39,33.8 73.2,33.8 73.32,33.68 73.32,32.8 73.43,32.68 73.6,32.68 73.72,32.8 73.72,33.68 73.84,33.8 74,33.8 74.12,33.68 74.12,32.8 74.24,32.68 74.4,32.68 74.52,32.8 74.52,33.68 74.64,33.8 74.8,33.8 74.92,33.68 74.92,32.8 75.04,32.68 75.21,32.68 75.32,32.8 75.32,33.68 75.44,33.8 75.61,33.8 75.72,33.68 75.72,32.8 75.84,32.68 76.01,32.68 76.13,32.8 76.13,33.68 76.24,33.8 76.41,33.8 76.53,33.68 76.53,32.8 76.64,32.68 76.81,32.68 76.93,32.8 76.93,33.68 77.05,33.8 77.21,33.8 77.33,33.68 77.33,32.8 77.45,32.68 77.61,32.68 77.73,32.8 77.73,33.68 77.85,33.8 81.98,33.8 89.25,41.06 89.25,47.89 90.72,49.37 92.07,49.37 96.56,53.86 96.56,62.16 95.72,63.01 95.72,65.97 94.99,66.7 94.99,66.71 94.01,67.69 94.01,68.49 93.13,69.37 92.51,69.37 92.26,69.62 v1(92.26,70.3)
MMC1_D3: length 113.7
  TOP w0.147: U23.K18 v1(92.26,71.1) ; v1(44.56,26.07) 45.05,26.56 47.11,26.56 48.38,27.82 v1(48.38,29.22) U49.3
  BOTTOM w0.114: v1(92.26,71.1) 92.66,70.7 92.66,70.12
  BOTTOM w0.147: J37.2 43.4,25 43.94,25.54 R484.2 v1(44.56,26.07) ; v1(48.38,29.22) 49.53,30.37 49.53,36.92 52.84,40.23 55.37,40.23 56.68,38.92 57.08,38.92 57.3,38.7 58.26,38.7 61.04,35.92 61.04,34.56 62.82,32.78 65.1,32.78 65.36,33.03 67.44,33.03 68.23,32.24 68.81,32.24 68.92,32.36 68.92,33.29 69.04,33.4 69.21,33.4 69.32,33.29 69.32,32.36 69.44,32.24 69.61,32.24 69.73,32.36 69.73,33.29 69.84,33.4 70.01,33.4 70.13,33.29 70.13,32.36 70.24,32.24 70.41,32.24 70.53,32.36 70.53,33.29 70.65,33.4 70.81,33.4 70.93,33.29 70.93,32.36 71.05,32.24 71.21,32.24 71.33,32.36 71.33,33.29 71.45,33.4 71.61,33.4 71.73,33.29 71.73,32.36 71.85,32.24 72.02,32.24 72.13,32.36 72.13,33.29 72.25,33.4 72.42,33.4 72.53,33.29 72.53,32.36 72.65,32.24 80.84,32.24 89.54,40.94 89.54,47.77 90.85,49.08 92.19,49.08 96.86,53.74 96.86,62.3 96.01,63.14 96.01,66.09 94.29,67.81 94.29,68.86 93.46,69.7 93.03,69.7 92.66,70.07 92.66,70.12
MMC1_SD_EN: length 33.4
  L03_SIG1 w0.091: v1(36.2,45.48) 36.2,43.83 41.04,38.99 43.24,38.99 49.94,32.3 49.94,31.36 52.43,28.86 v1(53.99,28.86)
  BOTTOM w0.147: U91.7 v1(53.99,28.86) ; U86.1 32.47,45.5 32.49,45.48 R416.1 33.04,45.52 33.62,46.1 35.57,46.1 v1(36.2,45.48)
MMC1_SD_LS_EN: length 165.7
  TOP w0.254: v1(115.24,65.21) 115.24,64.41 115.22,64.39 U39.3
  L03_SIG1 w0.091: v1(28.96,42.56) 30,42.56 35.64,36.92 43.54,36.92 46.58,33.87 46.58,32.72 46.44,32.58 46.44,32.12 47.52,31.03 48.35,31.03 52.25,27.14 55.42,27.14 64.23,18.33 64.23,16.46 65.08,15.61 78.38,15.61 79.25,14.74 90.38,14.74 94.72,10.4 97.91,10.4 98.55,11.05 103.11,11.05 108.28,16.22 112.98,16.22 118.55,21.78 118.55,27.95 124.16,33.56 124.16,41.05 v1(123.9,41.31)
  L08_SIG2 w0.091: v1(123.9,41.31) 123.9,44.73 121.54,47.09 121.54,49.05 122.25,49.76 122.25,55.88 121.34,56.79 121.34,59.51 120.65,60.2 120.65,61.75 117.18,65.21 v1(115.24,65.21)
  BOTTOM w0.147: v1(28.96,42.56) R426.2 29.66,42.6 28.9,43.36 U86.4
MMC1_SDCD: length 112.1
  TOP w0.147: U23.D19 v1(97.06,70.3)
  BOTTOM w0.147: J37.9 35.85,25.38 35.31,25.92 R481.2 34.69,26.19 34.42,26.47 34.42,27.7 35.05,28.34 45.97,28.34 46.23,28.08 49.28,28.08 50.29,29.1 50.29,36.83 53.1,39.64 55.13,39.64 56.44,38.33 56.84,38.33 57.11,38.05 58.06,38.05 60.45,35.66 60.45,34.26 63.71,31 80.44,31 91.11,41.68 91.11,46.29 94.6,49.79 94.6,49.97 97.74,53.1 97.74,62.7 96.9,63.54 96.9,66.3 97.39,66.79 97.39,68.06 97.06,68.39 v1(97.06,70.3)
Net_39: length 0.9
  TOP w0.147: 40.89,130.44 v1(41.53,131.08)
Net_40: length 0.9
  TOP w0.147: 40.89,129.17 v1(41.53,129.81)
OSC0: length 7.7
  TOP w0.147: Y2.1 167.02,25.43 166.91,25.54 164.14,25.54 163.78,25.17 C177.2 163.55,25.16 163.12,24.73 U59.88
OSC1: length 5.4
  TOP w0.147: U59.89 163.05,25.13 163.78,25.86 C172.2 164.65,25.87 Y2.3
OSPI0_CSN0: length 45.5
  TOP w0.147: U23.L19 v1(91.46,70.3)
  L03_SIG1 w0.091: v1(101.47,44.59) 103.43,42.63 105.84,42.63 106.1,42.89 106.1,46.31 101.77,50.64 101.77,55.87 95.74,61.91 95.74,62 95.25,62.48 93.11,62.48 92.58,63.01 92.58,64.86 92.1,65.35 91.98,65.35 91.78,65.54 91.78,66.55 91.46,66.87 v1(91.46,70.3)
  BOTTOM w0.147: v1(101.47,44.59) R422.2
OSPI0_LBCLK: length 23
  TOP w0.147: R600.2 97.63,50.7 96.77,51.56 94.87,51.56 v1(94.11,52.32)
  L03_SIG1 w0.091: v1(87.63,64.22) 88.01,63.84 88.01,62.61 88.65,61.98 88.65,60.07 89.66,59.05 92.2,59.05 92.71,58.55 92.71,57.66 94.11,56.26 v1(94.11,52.32)
  BOTTOM w0.147: v1(87.63,64.22) 87.52,64.33 R591.1
OSPI_CLK: length 45.1
  TOP w0.147: R167.1 R157.1 93.36,46.46 93.54,46.63 v1(95.11,46.63) ; U23.N20 89.86,69.5 89.86,68.45 90.19,68.12 90.19,66.15 v1(89.84,65.8)
  L03_SIG1 w0.091: v1(95.11,46.63) 96.09,47.6 96.09,50.1 96.17,50.18 96.65,50.18 96.73,50.26 96.73,50.38 96.65,50.46 96.17,50.46 96.09,50.54 96.09,50.65 96.17,50.73 96.65,50.73 96.73,50.81 96.73,50.93 96.65,51.01 96.17,51.01 96.09,51.09 96.09,51.2 96.17,51.28 96.65,51.28 96.73,51.36 96.73,51.47 96.65,51.56 96.17,51.56 96.09,51.64 96.09,51.75 96.17,51.83 96.65,51.83 96.73,51.91 96.73,52.02 96.65,52.1 96.17,52.1 96.09,52.18 96.09,52.3 96.17,52.38 96.65,52.38 96.73,52.46 96.73,52.57 96.65,52.65 96.17,52.65 96.09,52.73 96.09,52.85 96.17,52.93 96.65,52.93 96.73,53.01 96.73,53.12 96.65,53.2 96.17,53.2 96.09,53.28 96.09,53.4 96.17,53.48 96.65,53.48 96.73,53.56 96.73,53.67 96.65,53.75 96.17,53.75 96.09,53.83 96.09,53.94 96.17,54.02 96.65,54.02 96.73,54.1 96.73,54.22 96.65,54.3 96.17,54.3 96.09,54.38 96.09,54.49 96.17,54.57 96.65,54.57 96.73,54.65 96.73,54.77 96.65,54.85 96.17,54.85 96.09,54.93 96.09,55.04 96.17,55.12 96.65,55.12 96.73,55.2 96.73,55.32 96.65,55.4 96.17,55.4 96.09,55.48 96.09,55.59 96.17,55.67 96.65,55.67 96.73,55.75 96.73,55.86 96.65,55.94 96.17,55.94 96.09,56.02 96.09,56.14 96.17,56.22 96.65,56.22 96.73,56.3 96.73,56.41 96.65,56.49 96.17,56.49 96.09,56.57 96.09,58.63 96.05,58.67 96.05,58.69 93.65,61.09 91.63,61.09 89.66,63.06 89.66,65.25 89.84,65.43 v1(89.84,65.8)
OSPI_CS: length 4.7
  TOP w0.147: R168.1 v1(95.05,44.59) 95.57,44.08 97.31,44.08 U40.C2
  BOTTOM w0.147: R422.1 v1(95.05,44.59)
OSPI_DQ0: length 5.4
  TOP w0.147: R181.2 v1(100.35,39.38) 100.35,39.83 99.31,40.87 99.31,42.08 U40.D3
  BOTTOM w0.147: R181.2 v1(100.35,39.38)
OSPI_DQ1: length 4.9
  TOP w0.147: R176.2 v1(95.05,40.78) 96.35,42.08 97.31,42.08 U40.D2
  BOTTOM w0.147: R176.2 v1(95.05,40.78)
OSPI_DQ2: length 4.3
  TOP w0.147: U40.C4 100.31,44.08 101.91,44.08 v1(102.3,44.46) R169.2
  BOTTOM w0.147: R169.2 v1(102.3,44.46)
OSPI_DQ3: length 4.1
  TOP w0.147: U40.D4 100.31,43.08 102.3,43.08 v1(102.3,43.07) R172.2
  BOTTOM w0.147: R172.2 v1(102.3,43.07)
OSPI_DQ4: length 3.3
  TOP w0.147: U40.D5 101.71,41.67 v1(102.3,41.67) R173.2
  BOTTOM w0.147: R173.2 v1(102.3,41.67)
OSPI_DQ5: length 3.8
  TOP w0.147: R180.2 v1(99.08,39.32) 98.81,39.59 U40.E3
  BOTTOM w0.147: R180.2 v1(99.08,39.32)
OSPI_DQ6: length 3.7
  TOP w0.147: U40.E2 v1(97.81,39.32) R179.2
  BOTTOM w0.147: R179.2 v1(97.81,39.32)
OSPI_DQ7: length 3.8
  TOP w0.147: R178.2 v1(96.54,39.32) 96.54,41.31 U40.E1
  BOTTOM w0.147: R178.2 v1(96.54,39.32)
OSPI_DQS: length 7.8
  TOP w0.147: R155.2 97.41,49.65 97.79,49.28 97.79,48.9 97.94,48.74 R152.1 98.48,47.31 98.31,47.14 98.31,44.08 U40.C3
OSPI_DQS_SOC: length 27.3
  TOP w0.147: v1(99.44,50.62) 99.44,49.91 99.25,49.72 R152.2 ; U23.N19 v1(89.06,70.3)
  L03_SIG1 w0.091: v1(95.4,60.15) 96.64,58.91 96.64,57.06 97.43,56.28 97.43,52.63 v1(99.44,50.62)
  BOTTOM w0.147: v1(89.06,70.3) 89.06,67.79 90.6,66.25 91.62,66.25 92.71,65.16 92.71,63.76 93.26,63.2 93.95,63.2 95.4,61.75 v1(95.4,60.15)
OSPI_INTN: length 36.5
  TOP w0.147: v1(100.33,48.36) 103.49,48.36 103.99,47.85 R156.1 R158.2 ; U23.L17 v1(91.46,71.9)
  L03_SIG1 w0.091: v1(91.46,71.9) 90.56,71 90.56,66.42 90.68,66.3 90.68,65.68 91.27,65.08 91.27,62.92 91.69,62.51 92.06,62.51 92.71,61.86 95.01,61.86 101.04,55.83 101.04,49.07 v1(100.33,48.36)
OSPI_RSTN: length 14.2
  TOP w0.147: U40.A4 99.81,48.77 100.2,49.16 107.31,49.16 v1(107.82,48.66)
  BOTTOM w0.147: U85.4 R414.1 v1(107.82,48.66)
PCIE_CLKREQN: length 3
  BOTTOM w0.147: J27.B12 22.78,28.47 23.39,27.86 R482.1
PCIE_MCU_PORZ: length 115.6
  TOP w0.147: J34.3 53.08,40.15 54.48,41.55 58.09,41.55 59.23,40.41 59.23,36.56 61.35,34.44 61.35,31.23 60.65,30.52 59.48,30.52 58.96,30.01 58.96,29.42 59.53,28.85 68.09,28.85 71.51,32.27 85.29,32.27 86.57,31 91.21,31 93.17,32.96 102.31,32.96 108.87,39.52 108.87,44.22 112.98,48.33 122.05,48.33 123.51,46.87 126.91,46.87 127.4,47.35 U35.6
  BOTTOM w0.147: J34.3 47.5,42.16 47.88,42.55 R576.2
PCIE_PRSNT1#: length 28.6
  TOP w0.147: J35.3 26.17,42.67 20.45,42.67 19.02,41.25 13.12,41.25 8.87,37 8.87,34.86 J27.A1
  BOTTOM w0.147: R437.2 28.13,40.72 J35.3
PCIE_PRSNT2#_1: length 15.7
  TOP w0.147: J27.B17 26.41,32.82 23.42,32.82 21.62,34.62 21.62,38.25 J35.2
PCIE_PRSNT2N: length 3.1
  BOTTOM w0.147: J35.1 20.87,41.47 20.71,41.31 R431.2
PCIE_RESET_OUTN: length 3.3
  BOTTOM w0.147: J34.1 41.24,40.15 41.11,40.02 U88.4
PCIE_RESETN: length 30.7
  BOTTOM w0.147: J34.2 41.82,37.01 28.14,37.01 27.79,36.65 27.79,35.51 26.77,34.49 26.77,33.27 26.26,32.77 23.55,32.77 21.66,34.65 20.48,34.65 J27.A11
PCIE_SERDES_REFCLK0_N: length 9.7
  TOP w0.108: R667.2 25.37,38.48 arc(25.33,38.57) 25.25,38.6 24.79,38.6 arc(24.52,38.55) 24.29,38.39 24.18,38.29 arc(24.1,38.16) 24.07,38.02 24.07,37.73 arc(24.13,37.58) 24.28,37.51 24.55,37.51 arc(24.77,37.3) 24.55,37.08 24.23,37.08 arc(24.11,37.03) 24.07,36.92 24.07,36.75 arc(24.08,36.67) 24.13,36.6 J27.A14
  BOTTOM w0.108: J27.A14 24.07,36.66 24.07,38.29 24.38,38.6 24.86,38.6 R667.2
PCIE_SERDES_REFCLK0_P: length 13
  TOP w0.108: R668.2 25.37,39.07 arc(25.32,38.94) 25.19,38.89 24.79,38.89 arc(24.41,38.82) 24.08,38.6 23.97,38.49 arc(23.83,38.27) 23.78,38.02 J27.A13
  BOTTOM w0.108: J27.A13 23.78,38.41 24.26,38.89 24.86,38.89 R668.2
PCIE_TCK: length 5.5
  BOTTOM w0.147: TP85.1 14.02,38.58 14.02,37.53 13.78,37.29 J27.A5
PCIE_TDI: length 5.9
  BOTTOM w0.147: TP83.1 14.78,39.85 J27.A6
PCIE_TDO: length 10.4
  BOTTOM w0.147: J27.A7 15.78,32.96 15.47,32.65 15.11,32.65 14.77,32.31 14.77,31.04 13.79,30.06 13.79,29.04 14.1,28.73 14.1,27.07 TP95.1
PCIE_TMS: length 3.7
  BOTTOM w0.147: J27.A8 16.78,38.23 TP84.1
PCIE_TRSTN: length 7.3
  BOTTOM w0.147: TP94.1 17.77,28.45 17.77,29.86 17.78,29.87 J27.B9
PCIE_WAKEN: length 5.1
  BOTTOM w0.147: R486.1 20.21,30.03 19.78,30.47 J27.B11
PORZ: length 28.2
  TOP w0.147: R171.2 142.49,42 TP32.1 143.71,41.62 v1(143.76,41.67) ; v1(128.65,53.12) 128.65,54.12 R574.2 127.81,54.24 127.4,53.82 U35.1
  L03_SIG1 w0.091: v1(143.76,41.67) 142.88,42.56 142.88,43.39 138.37,47.89 130.68,47.89 129.41,49.16 129.41,52.36 v1(128.65,53.12)
PORZ_OUT: length 257.4
  TOP w0.147: U19.2 v1(25.4,89.11) ; U23.E17 v1(96.26,71.9) ; v1(109.96,39.78) 109.96,40.55 TP82.1 ; U31.2 29.69,59.96 29.08,59.36 v1(29.08,58.18)
  L03_SIG1 w0.091: v1(96.26,71.9) 96.44,71.72 96.68,71.72 96.89,71.51 101.27,71.51 102.01,70.77 v1(102.01,70.4) 102.62,71.01 103.81,71.01 104.29,70.53 104.29,66.33 106.9,63.72 106.9,57.15 107.19,56.86 v1(107.19,56.43) ; v1(25.4,89.11) 29.32,85.2 29.32,63.6 28.77,63.05 28.77,60.03 28.77,59.26 29.08,58.95 v1(29.08,58.18) 29.08,56.92 27.94,55.78 v1(27.94,45.61) 29.2,44.34 30.43,44.34 34.95,39.83 37.25,39.83 38.83,38.25 43.04,38.25 48.46,32.83 48.46,31.71 52.35,27.83 55.67,27.83 55.83,27.99 57.5,27.99 58.93,26.56 58.93,24.2 66.99,16.14 78.6,16.14 79.6,15.14 90.61,15.14 94.14,11.61 102.96,11.61 108.52,17.16 110.49,17.16 114.15,20.82 114.15,28.03 112.98,29.2 112.98,36.77 v1(109.96,39.78)
  L08_SIG2 w0.091: v1(107.19,56.43) 109.96,53.65 v1(109.96,39.78) ; v1(25.4,89.11) 26.23,89.11 35.81,98.69 35.81,103.01 38.1,105.3 44.58,105.3 45.85,106.57 v1(45.85,107.2)
  BOTTOM w0.147: v1(27.94,45.61) 28.05,45.5 U86.6 ; U69.2 v1(45.85,107.2) ; R348.2 103.17,69.23 v1(102.01,70.4) ; R434.2 v1(109.96,39.78)
PRG0_HSE_ETH1_CLK: length 21.1
  TOP w0.147: J2.A17 v1(54.23,127.27)
  L08_SIG2 w0.091: v1(54.23,127.27) 54.23,124.33 56.24,122.33 58.65,122.33 62.08,118.9 62.08,113.65 v1(61.21,112.79)
  BOTTOM w0.147: R236.2 v1(61.21,112.79)
PRG0_HSE_ETH2_CLK: length 22.9
  TOP w0.147: J2.B17 v1(54.23,128.54)
  L08_SIG2 w0.091: v1(54.23,128.54) 54.84,127.93 54.84,124.82 56.79,122.86 60.48,122.86 62.48,120.85 v1(62.48,112.79)
  BOTTOM w0.147: R235.2 v1(62.48,112.79)
PRG0_MDIO0_MDC: length 51.7
  TOP w0.147: J2.A5 68.83,125.87 v1(69.47,125.24) ; U23.P3 v1(88.26,83.9)
  L03_SIG1 w0.091: v1(69.47,125.24) 69.03,124.8 69.03,116.13 83.41,101.75 83.41,93.12 84.23,92.29 84.23,89.14 88.26,85.11 v1(88.26,83.9)
PRG0_MDIO0_MDIO: length 52.6
  TOP w0.147: U23.P2 88.26,84.7 88.26,85.27 88.17,85.36 88.17,87.1 84.2,91.07 84.2,91.94 80.76,95.39 80.76,105.11 70.52,115.34 70.52,117.91 72.73,120.12 R19.1 71.37,120.16 70.28,121.25 70.28,125.48 70.1,125.66 J2.A4
PRG0_PRU0_GPO9/CPSW_RGMII1_RX_C: length 41
  TOP w0.147: U23.W6 v1(84.26,81.5)
  L08_SIG2 w0.091: v1(56.16,97.03) 56.43,97.29 69.82,97.29 71.04,96.07 71.04,90.52 71.04,90.22 74.84,86.42 75.16,86.1 77.12,86.1 78.15,85.07 78.19,85.07 81.76,81.5 v1(84.26,81.5)
  BOTTOM w0.147: v1(56.16,97.03) 55.66,97.53 U75.6
PRG0_PRU0_GPO10/CPSW_RGMII1_RXC: length 39
  TOP w0.147: v1(76.71,85.6) 77.97,85.6 81.02,82.55 81.03,82.55 81.11,82.47 81.29,82.47 81.85,81.9 U23.AA5
  L08_SIG2 w0.091: v1(76.71,85.6) 75.15,85.6 75.01,85.74 70.68,90.07 70.68,90.12 70.6,90.19 70.6,95.97 69.7,96.87 69.4,96.87 57.24,96.87 56.77,96.39 55.61,96.39 v1(54.97,97.03)
  BOTTOM w0.147: U75.7 v1(54.97,97.03)
PRG0_PRU0GPO0: length 64.1
  TOP w0.147: U23.Y1 83.86,85.99 83.59,86.26 82.96,86.26 79.29,89.93 79.29,91.37 77,93.66 77,98.37 77.12,98.48 77.63,98.48 77.75,98.6 77.75,98.77 77.63,98.89 77.12,98.89 77,99 77,99.17 77.12,99.29 77.63,99.29 77.75,99.4 77.75,99.57 77.63,99.69 77.12,99.69 77,99.81 77,99.97 77.12,100.09 77.63,100.09 77.75,100.21 77.75,100.37 77.63,100.49 77.12,100.49 77,100.61 77,100.77 77.12,100.89 77.63,100.89 77.75,101.01 77.75,101.18 77.48,101.45 74.3,101.45 73.81,101.93 73.81,105.94 71.96,107.8 71.96,109.74 65.42,116.28 65.42,118.26 65.53,118.38 65.74,118.38 65.86,118.5 65.86,118.67 65.74,118.78 65.53,118.78 65.42,118.9 65.42,119.07 65.53,119.19 65.74,119.19 65.86,119.3 65.86,119.47 65.74,119.59 65.53,119.59 65.42,119.7 65.42,119.87 65.53,119.99 65.74,119.99 65.86,120.11 65.86,120.27 65.74,120.39 65.53,120.39 65.42,120.51 65.42,120.67 65.53,120.79 65.74,120.79 65.86,120.91 65.86,121.07 65.74,121.19 65.53,121.19 65.42,121.31 65.42,121.62 61.34,125.69 60.91,125.69 60.58,126.02 60.58,128.4 60.43,128.55 59.8,128.55 59.65,128.4 59.65,128.19 J2.B12
PRG0_PRU0GPO1: length 63.4
  TOP w0.147: U23.R4 v1(87.46,83.1) ; J2.E8 v1(65.66,132.35)
  L03_SIG1 w0.091: v1(87.46,83.1) 87.06,83.51 87.06,84.15 86.74,84.47 86.74,85.12 83.57,88.29 83.57,92.02 82.75,92.83 82.75,101.63 81.41,102.97 68.4,115.98 68.4,120.18 66.27,122.3 66.27,126.49 66.36,126.58 66.89,126.58 66.98,126.68 66.98,126.84 66.89,126.93 66.36,126.93 66.27,127.02 66.27,127.18 66.36,127.28 66.89,127.28 66.98,127.37 66.98,127.53 66.89,127.62 66.36,127.62 66.27,127.71 66.27,127.87 66.36,127.97 66.89,127.97 66.98,128.06 66.98,128.22 66.89,128.31 66.36,128.31 66.27,128.4 66.27,131.74 v1(65.66,132.35)
PRG0_PRU0GPO2: length 63.9
  TOP w0.147: J2.A8 67.41,124.25 67.41,123.14 67.53,123.02 68.08,123.02 68.2,122.9 68.2,122.74 68.08,122.62 67.53,122.62 67.41,122.5 67.41,122.34 67.53,122.22 68.08,122.22 68.2,122.1 68.2,121.93 68.08,121.82 67.53,121.82 67.41,121.7 67.41,121.53 67.53,121.42 68.08,121.42 68.2,121.3 68.2,121.13 68.08,121.01 67.53,121.01 67.41,120.9 67.41,120.73 67.53,120.61 68.08,120.61 68.2,120.49 68.2,120.33 68.08,120.21 67.53,120.21 67.41,120.09 67.41,119.93 67.53,119.81 68.08,119.81 68.2,119.69 68.2,119.53 68.08,119.41 67.53,119.41 67.41,119.29 67.41,119.12 67.53,119.01 68.08,119.01 68.2,118.89 68.2,118.72 68.08,118.61 67.53,118.61 67.41,118.49 67.41,118.32 67.53,118.2 68.08,118.2 68.2,118.09 68.2,117.92 68.08,117.8 67.53,117.8 67.41,117.69 67.41,117.52 67.53,117.4 68.08,117.4 68.2,117.28 68.2,117.12 68.08,117 67.53,117 67.41,116.88 67.41,116.37 79.28,104.5 79.28,94.55 80.76,93.08 80.76,90.54 81.81,89.48 83.44,89.48 83.7,89.22 83.7,89.02 83.54,88.86 83.54,88.65 83.75,88.44 83.96,88.44 84.12,88.6 84.32,88.6 84.53,88.39 84.53,88.18 84.37,88.02 84.37,87.81 84.58,87.61 84.79,87.61 84.95,87.77 85.16,87.77 85.86,87.06 85.86,84.7 U23.U2
PRG0_PRU0GPO3: length 64.1
  TOP w0.147: U23.V2 85.06,84.7 85.06,86.24 83.95,87.35 83.11,87.35 83.02,87.45 83.02,87.62 83.21,87.82 83.21,87.98 83.1,88.1 82.93,88.1 82.73,87.9 82.57,87.9 82.45,88.02 82.45,88.18 82.65,88.38 82.65,88.55 82.53,88.67 82.36,88.67 82.16,88.47 82,88.47 80.17,90.29 80.17,92.83 78.69,94.31 78.69,104.25 78.15,104.8 77.94,104.8 77.55,104.42 77.34,104.42 77.14,104.63 77.14,104.84 77.52,105.22 77.52,105.43 66.78,116.17 66.78,122.44 66.6,122.61 65.73,122.61 65.56,122.78 65.56,123.03 65.73,123.2 66.6,123.2 66.78,123.37 66.78,123.57 66.25,124.1 65.95,124.1 65.19,123.34 64.95,123.34 64.77,123.51 64.77,123.76 65.54,124.52 65.54,124.76 65.36,124.93 65.12,124.93 64.36,124.17 64.11,124.17 63.94,124.35 63.94,124.59 64.7,125.35 64.7,125.59 64.53,125.77 64.29,125.77 63.52,125.01 63.28,125.01 62.94,125.35 62.94,125.82 J2.A9
PRG0_PRU0GPO4: length 64
  TOP w0.147: U23.AA2 82.74,84.3 78.45,88.6 72.67,88.6 70.51,90.76 70.51,96.48 70.19,96.8 70.19,103.81 70.31,103.93 70.9,103.93 71.02,104.04 71.02,104.21 70.9,104.33 70.31,104.33 70.19,104.44 70.19,104.61 70.31,104.73 70.9,104.73 71.02,104.85 71.02,105.01 70.9,105.13 70.31,105.13 70.19,105.25 70.19,105.41 70.31,105.53 70.9,105.53 71.02,105.65 71.02,105.81 70.9,105.93 70.31,105.93 70.19,106.05 70.19,106.22 70.31,106.33 70.9,106.33 71.02,106.45 71.02,106.62 70.9,106.73 70.31,106.73 70.19,106.85 70.19,107.02 70.31,107.14 70.9,107.14 71.02,107.25 71.02,107.42 70.9,107.54 70.31,107.54 70.19,107.66 70.19,107.88 68.03,110.04 68.03,112.13 64.53,115.62 64.53,121.26 60.98,124.81 59.15,124.81 58.67,125.29 J2.A13
PRG0_PRU0GPO5: length 55.7
  TOP w0.147: J2.C6 v1(68.2,129.81) ; U23.R3 v1(87.46,83.9)
  L03_SIG1 w0.091: v1(68.2,129.81) 67.77,129.38 67.77,122 68.63,121.13 68.63,116.01 82.97,101.67 82.97,92.93 83.79,92.11 83.79,88.69 87,85.49 87,84.61 87.46,84.14 v1(87.46,83.9)
PRG0_PRU0GPO6: length 61.5
  TOP w0.147: J2.D8 v1(65.66,131.08) ; U23.T3 v1(86.66,83.9)
  L08_SIG2 w0.091: v1(86.66,83.9) 86.66,84.26 84.71,86.21 81.85,86.21 79.12,88.93 79.12,91.85 77.98,92.99 75.72,92.99 74.68,94.03 74.68,96.98 70.23,101.42 70.23,104.6 64.67,110.16 64.67,127.89 64.67,127.89 64.67,128.14 66.12,129.59 66.12,130.62 v1(65.66,131.08)
PRG0_PRU0GPO7: length 51.4
  TOP w0.147: J2.B7 66.88,127.32 66.88,126.49 69.09,124.28 69.09,115.94 80.17,104.86 80.17,95.14 83.61,91.7 83.61,90.83 87.06,87.38 U23.T1
PRG0_PRU0GPO8: length 50.9
  TOP w0.147: J2.A7 68.8,124.13 68.8,115.82 79.87,104.74 79.87,95.02 83.32,91.58 83.32,90.71 86.66,87.37 86.66,84.7 U23.T2
PRG0_PRU0GPO11: length 67.1
  TOP w0.147: J2.B14 57.99,127.32 57.99,125.01 58.48,124.52 60.85,124.52 64.24,121.13 64.24,115.46 67.73,111.96 67.73,109.87 69.9,107.7 69.9,96.67 70.04,96.52 70.05,96.52 70.22,96.36 70.22,90.63 73.47,87.38 73.95,87.38 74.06,87.49 74.06,88.05 74.18,88.16 74.35,88.16 74.47,88.05 74.47,87.49 74.58,87.38 74.75,87.38 74.87,87.49 74.87,88.05 74.98,88.16 75.15,88.16 75.27,88.05 75.27,87.49 75.39,87.38 75.55,87.38 75.67,87.49 75.67,88.05 75.79,88.16 75.95,88.16 76.07,88.05 76.07,87.49 76.19,87.38 76.35,87.38 76.47,87.49 76.47,88.05 76.59,88.16 76.76,88.16 76.87,88.05 76.87,87.49 76.99,87.38 77.16,87.38 77.27,87.49 77.27,88.05 77.39,88.16 77.56,88.16 77.68,88.05 77.68,87.49 77.79,87.38 79.07,87.38 81.23,85.22 81.43,85.22 82.74,83.9 83.22,83.9 83.62,83.5 U23.Y3
PRG0_PRU0GPO12: length 67
  TOP w0.147: J2.A14 57.4,124.83 58.01,124.22 60.73,124.22 63.94,121.01 63.94,115.34 64.64,114.63 64.64,114.47 64.12,113.95 64.12,113.78 64.24,113.66 64.41,113.66 64.93,114.18 65.09,114.18 65.21,114.07 65.21,113.9 64.69,113.38 64.69,113.21 64.81,113.09 64.97,113.09 65.49,113.62 65.66,113.62 65.78,113.5 65.78,113.33 65.26,112.81 65.26,112.64 65.37,112.53 65.54,112.53 66.06,113.05 66.23,113.05 66.35,112.93 66.35,112.77 65.82,112.24 65.82,112.08 65.94,111.96 66.11,111.96 66.63,112.48 66.8,112.48 67.44,111.84 67.44,109.74 69.6,107.58 69.6,98 67.96,96.36 67.96,92.38 73.55,86.79 79.18,86.79 81.14,84.84 81.4,84.84 82.73,83.5 U23.AA3
PRG0_PRU0GPO13: length 65.8
  TOP w0.147: U23.R6 v1(87.46,81.5) ; J2.C5 v1(69.47,129.81)
  L03_SIG1 w0.091: v1(87.46,81.5) 87.86,81.91 88.42,81.91 88.66,82.14 88.66,85.05 84.45,89.25 84.45,92.43 83.63,93.26 83.63,101.79 69.22,116.2 69.22,122.38 69.31,122.47 69.5,122.47 69.6,122.56 69.6,122.73 69.5,122.82 69.31,122.82 69.22,122.91 69.22,123.07 69.31,123.16 69.5,123.16 69.6,123.26 69.6,123.42 69.5,123.51 69.31,123.51 69.22,123.6 69.22,124.06 69.91,124.75 69.91,126.22 69.81,126.31 68.95,126.31 68.86,126.4 68.86,126.56 68.95,126.65 69.81,126.65 69.91,126.74 69.91,126.91 69.81,127 68.95,127 68.86,127.09 68.86,127.25 68.95,127.34 69.81,127.34 69.91,127.43 69.91,127.6 69.81,127.69 68.95,127.69 68.86,127.78 68.86,127.94 68.95,128.03 69.81,128.03 69.91,128.13 69.91,129.37 v1(69.47,129.81)
PRG0_PRU0GPO14: length 66
  TOP w0.147: U23.V4 v1(85.06,83.1) ; J2.C9 v1(64.39,129.81)
  L03_SIG1 w0.091: v1(85.06,83.1) 85.06,83.18 84.66,83.58 84.66,86.15 80.48,90.34 80.48,102.61 67.67,115.42 67.67,116.66 67.57,116.75 66.84,116.75 66.75,116.84 66.75,117 66.84,117.09 67.57,117.09 67.67,117.18 67.67,117.35 67.57,117.44 66.84,117.44 66.75,117.53 66.75,117.69 66.84,117.78 67.57,117.78 67.67,117.88 67.67,118.04 67.57,118.13 66.84,118.13 66.75,118.22 66.75,118.38 66.84,118.47 67.57,118.47 67.67,118.57 67.67,118.73 67.57,118.82 66.84,118.82 66.75,118.91 66.75,119.07 66.84,119.17 67.57,119.17 67.67,119.26 67.67,119.52 64.39,122.8 64.39,124.43 64.3,124.52 63.67,124.52 63.58,124.62 63.58,124.78 63.67,124.87 64.3,124.87 64.39,124.96 64.39,125.12 64.3,125.21 63.67,125.21 63.58,125.31 63.58,125.47 63.67,125.56 64.3,125.56 64.39,125.65 v1(64.39,129.81)
PRG0_PRU0GPO15: length 66.2
  TOP w0.147: U23.T5 v1(86.66,82.3) ; J2.D12 v1(60.58,131.08)
  L03_SIG1 w0.091: v1(60.58,131.08) 61.11,130.55 61.11,124.68 65.81,119.98 65.81,115.99 79.37,102.43 79.37,87.9 83.25,84.02 83.25,81.47 83.86,80.87 83.86,80.54 84.09,80.31 86.02,80.31 86.26,80.54 86.26,81.9 v1(86.66,82.3)
PRG0_PRU0GPO16: length 63.8
  TOP w0.147: J2.E9 v1(64.39,132.35) ; U23.U4 v1(85.86,83.1)
  L08_SIG2 w0.091: v1(64.39,132.35) 63.97,132.35 63.75,132.13 63.75,109.8 69.5,104.06 69.5,101.12 73.94,96.67 73.94,89.74 75.6,88.09 78.18,88.09 81.92,84.35 85.27,84.35 85.47,84.15 85.47,83.72 85.86,83.33 v1(85.86,83.1)
PRG0_PRU0GPO17: length 52.6
  TOP w0.147: U23.U1 86.26,87.17 83.57,89.87 81.85,89.87 81.06,90.66 81.06,93.2 79.58,94.68 79.58,104.62 68.5,115.7 68.5,123.57 65.61,126.47 65.61,127.32 J2.B8
PRG0_PRU0GPO18: length 52.3
  TOP w0.147: U23.V1 85.46,86.26 82.64,89.08 81.8,89.08 80.47,90.41 80.47,92.95 78.99,94.43 78.99,104.38 67.11,116.26 67.11,123.7 64.34,126.47 64.34,127.32 J2.B9
PRG0_PRU0GPO19: length 53
  TOP w0.147: J2.B11 61.93,127.19 61.93,125.94 66.47,121.4 66.47,116.06 76.84,105.69 76.84,103.95 78.4,102.39 78.4,94.19 79.88,92.71 79.88,90.17 83.04,87.01 83.82,87.01 84.66,86.17 U23.W1
PRG0_PRU1_GPO7/CPSW_RGMII1_RD0: length 42.1
  TOP w0.147: U23.W5 v1(84.26,82.3)
  L08_SIG2 w0.091: v1(84.26,82.3) 81.54,82.3 77.38,86.47 75.31,86.47 75.2,86.58 71.41,90.37 71.41,96.22 69.79,97.84 57.78,97.84 57.66,97.96 57.66,98.11 57.55,98.22 57.42,98.22 57.25,98.04 57.12,98.04 57,98.16 57,98.29 57.18,98.46 57.18,98.59 57.06,98.71 56.93,98.71 56.76,98.53 56.63,98.53 56.47,98.69 56.47,98.72 v1(56.16,99.03)
  BOTTOM w0.147: v1(56.16,99.03) 55.84,99.35 55.35,99.35 55.17,99.53 U75.2
PRG0_PRU1_GPO9/CPSW_RGMII1_RD1: length 42.6
  TOP w0.147: U23.Y5 83.46,82.3 81.87,82.3 81.2,82.97 81.19,82.97 78.05,86.11 72.99,86.11 67.73,91.37 65.39,91.37 65.27,91.25 65.27,91.04 65.16,90.92 64.99,90.92 64.87,91.04 64.87,91.25 64.75,91.37 64.59,91.37 64.47,91.25 64.47,91.04 64.35,90.92 64.19,90.92 64.07,91.04 64.07,91.25 63.95,91.37 63.78,91.37 63.67,91.25 63.67,91.04 63.55,90.92 63.38,90.92 63.27,91.04 63.27,91.25 63.15,91.37 62.98,91.37 62.86,91.25 62.86,91.04 62.75,90.92 62.58,90.92 62.46,91.04 62.46,91.25 62.35,91.37 62.18,91.37 62.06,91.25 62.06,91.04 61.94,90.92 61.78,90.92 61.66,91.04 61.66,91.25 61.54,91.37 61.38,91.37 61.26,91.25 61.26,91.04 61.14,90.92 60.98,90.92 60.86,91.04 60.86,91.25 60.74,91.37 59.18,91.37 55.58,94.97 55.58,98.42 v1(54.97,99.03)
  BOTTOM w0.147: U75.3 v1(54.97,99.03)
PRG0_PRU1_GPO10/CPSW_RGMII1_RD2: length 42.2
  TOP w0.147: U23.V6 v1(85.06,81.5)
  L08_SIG2 w0.091: v1(56.16,98.08) 56.16,97.71 56.34,97.54 69.83,97.54 71.22,96.14 71.22,90.3 75.02,86.5 75.24,86.29 77.27,86.29 81.65,81.9 84.66,81.9 v1(85.06,81.5)
  BOTTOM w0.147: v1(56.16,98.08) 55.72,98.53 U75.4
PRG0_PRU1_GPO17/CPSW_RGMII1_RD3: length 42.9
  TOP w0.147: U23.V5 v1(85.06,82.3)
  L08_SIG2 w0.091: v1(85.06,82.3) 84.91,82.45 84.68,82.45 84.43,82.7 81.43,82.7 77.48,86.65 75.39,86.65 71.59,90.45 71.59,96.29 69.86,98.02 58.08,98.02 56.55,99.55 56.03,99.55 55.62,99.14 55.62,98.67 v1(54.97,98.03)
  BOTTOM w0.147: U75.5 v1(54.97,98.03)
PRG0_PRU1GPO0: length 71.1
  TOP w0.147: J2.A12 59.59,126.28 59.59,125.63 59.82,125.4 61.22,125.4 65.12,121.5 65.12,116.16 71.66,109.62 71.66,107.68 73.45,105.89 73.45,99.64 73.6,99.49 74.27,99.49 74.42,99.64 74.42,100.81 74.65,101.04 76.56,101.04 76.71,100.89 76.71,100.67 76.59,100.56 75.38,100.56 75.26,100.44 75.26,100.27 75.38,100.15 76.59,100.15 76.71,100.04 76.71,99.87 76.59,99.75 75.38,99.75 75.26,99.64 75.26,99.47 75.38,99.35 76.59,99.35 76.71,99.23 76.71,99.07 76.59,98.95 75.38,98.95 75.26,98.83 75.26,98.67 75.38,98.55 76.59,98.55 76.71,98.43 76.71,98.27 76.59,98.15 75.38,98.15 75.26,98.03 75.26,97.86 75.38,97.75 76.59,97.75 76.71,97.63 76.71,93.5 78.99,91.21 78.99,89.8 79.69,89.11 79.69,88.95 79.57,88.82 79.57,88.66 79.68,88.54 79.85,88.54 79.97,88.66 80.14,88.66 80.25,88.54 80.25,88.38 80.13,88.26 80.13,88.09 80.25,87.97 80.42,87.97 80.54,88.09 80.7,88.09 80.82,87.98 80.82,87.81 80.7,87.69 80.7,87.52 80.82,87.41 80.98,87.41 81.11,87.53 81.27,87.53 81.39,87.41 81.39,87.24 81.27,87.12 81.27,86.96 81.39,86.84 81.55,86.84 81.67,86.96 81.84,86.96 81.96,86.84 81.96,86.68 81.84,86.55 81.84,86.39 81.95,86.27 82.12,86.27 82.24,86.39 82.41,86.39 83.46,85.34 83.46,84.88 83.86,84.48 U23.Y2
PRG0_PRU1GPO1: length 71.8
  TOP w0.147: U23.W2 84.26,84.7 84.26,86.01 83.54,86.72 82.91,86.72 79.58,90.05 79.58,92.59 78.11,94.07 78.11,94.75 77.96,94.9 77.57,94.9 77.42,95.05 77.42,95.34 77.57,95.49 77.96,95.49 78.11,95.64 78.11,101.55 77.72,101.93 76.81,101.93 76.48,102.26 76.48,104.47 76.33,104.61 76.04,104.61 75.89,104.47 75.89,102.43 75.74,102.29 75.45,102.29 75.3,102.43 75.3,104.47 75.15,104.61 74.86,104.61 74.71,104.47 74.71,102.43 74.56,102.29 74.27,102.29 74.12,102.43 74.12,105.06 74.27,105.2 76.33,105.2 76.48,105.35 76.48,105.64 75.84,106.27 74.21,106.27 74.06,106.42 74.06,106.63 74.67,107.24 74.67,107.45 74.46,107.66 74.25,107.66 73.51,106.91 73.3,106.91 73.09,107.12 73.09,107.33 73.84,108.07 73.84,108.28 66.17,115.95 66.17,116.06 66.02,116.21 65.93,116.21 65.79,116.36 65.79,116.65 65.93,116.8 66.02,116.8 66.17,116.94 66.17,117.24 66.02,117.39 65.93,117.39 65.79,117.53 65.79,117.83 65.93,117.98 66.02,117.98 66.17,118.12 66.17,121.29 61.21,126.24 J2.A11
PRG0_PRU1GPO2: length 71.3
  TOP w0.147: U23.V3 v1(85.06,83.9) ; J2.D9 v1(64.39,131.08)
  L03_SIG1 w0.091: v1(64.39,131.08) 64.82,130.65 64.82,122.63 67.94,119.5 67.94,115.4 80.7,102.65 80.7,101.94 80.79,101.84 81.21,101.84 81.31,101.75 81.31,101.59 81.21,101.5 80.79,101.5 80.7,101.41 80.7,101.24 80.79,101.15 81.21,101.15 81.31,101.06 81.31,100.9 81.21,100.81 80.79,100.81 80.7,100.72 80.7,100.55 80.79,100.46 81.21,100.46 81.31,100.37 81.31,100.21 81.21,100.12 80.79,100.12 80.7,100.03 80.7,99.86 80.79,99.77 81.21,99.77 81.31,99.68 81.31,99.52 81.21,99.43 80.79,99.43 80.7,99.33 80.7,99.17 80.79,99.08 81.21,99.08 81.31,98.99 81.31,98.83 81.21,98.73 80.79,98.73 80.7,98.64 80.7,98.48 80.79,98.39 81.21,98.39 81.31,98.3 81.31,98.14 81.21,98.04 80.79,98.04 80.7,97.95 80.7,97.79 80.79,97.7 81.21,97.7 81.31,97.61 81.31,97.44 81.21,97.35 80.79,97.35 80.7,97.26 80.7,97.1 80.79,97.01 81.21,97.01 81.31,96.92 81.31,96.75 81.21,96.66 80.79,96.66 80.7,96.57 80.7,96.41 80.79,96.32 81.21,96.32 81.31,96.23 81.31,96.06 81.21,95.97 80.79,95.97 80.7,95.88 80.7,95.72 80.79,95.63 81.21,95.63 81.31,95.53 81.31,95.37 81.21,95.28 80.79,95.28 80.7,95.19 80.7,95.03 80.79,94.93 81.21,94.93 81.31,94.84 81.31,94.68 81.21,94.59 80.79,94.59 80.7,94.5 80.7,94.34 80.79,94.24 81.21,94.24 81.31,94.15 81.31,93.99 81.21,93.9 80.79,93.9 80.7,93.81 80.7,93.64 80.79,93.55 81.21,93.55 81.31,93.46 81.31,93.3 81.21,93.21 80.79,93.21 80.7,93.12 80.7,92.99 80.79,92.9 81.21,92.9 81.31,92.81 81.31,92.65 81.21,92.56 80.79,92.56 80.7,92.46 80.7,90.42 85.06,86.06 v1(85.06,83.9)
PRG0_PRU1GPO3: length 70.6
  TOP w0.147: J2.C8 v1(65.66,129.81) ; U23.T4 v1(86.66,83.1)
  L03_SIG1 w0.091: v1(86.66,83.1) 86.26,83.51 86.26,85.22 83.31,88.16 83.31,91.74 81.71,93.34 81.71,99.75 81.8,99.84 82.43,99.84 82.52,99.93 82.52,100.09 82.43,100.19 81.8,100.19 81.71,100.28 81.71,100.44 81.8,100.53 82.43,100.53 82.52,100.62 82.52,100.79 82.43,100.88 81.8,100.88 81.71,100.97 81.71,101.13 81.8,101.22 82.43,101.22 82.52,101.31 82.52,101.48 82.43,101.57 81.8,101.57 81.71,101.66 81.71,102.15 68.2,115.67 68.2,119.86 65.66,122.4 65.66,123.28 65.57,123.38 65.12,123.38 65.02,123.47 65.02,123.63 65.12,123.72 65.57,123.72 65.66,123.81 65.66,123.98 65.57,124.07 65.12,124.07 65.02,124.16 65.02,124.32 65.12,124.41 65.57,124.41 65.66,124.5 65.66,124.67 65.57,124.76 65.12,124.76 65.02,124.85 65.02,125.01 65.12,125.1 65.57,125.1 65.66,125.19 65.66,125.36 65.57,125.45 65.12,125.45 65.02,125.54 65.02,125.7 65.12,125.79 65.57,125.79 65.66,125.89 65.66,126.05 65.57,126.14 65.12,126.14 65.02,126.23 65.02,126.39 65.12,126.48 65.57,126.48 65.66,126.58 65.66,126.74 65.57,126.83 65.12,126.83 65.02,126.92 65.02,127.08 65.12,127.18 65.57,127.18 65.66,127.27 65.66,127.43 65.57,127.52 65.12,127.52 65.02,127.61 65.02,127.78 65.12,127.87 65.57,127.87 65.66,127.96 65.66,128.12 65.57,128.21 65.12,128.21 65.02,128.3 65.02,128.47 65.12,128.56 65.57,128.56 65.66,128.65 65.66,128.81 65.57,128.9 65.12,128.9 65.02,128.99 65.02,129.14 65.12,129.24 65.55,129.24 65.66,129.34 v1(65.66,129.81)
PRG0_PRU1GPO4: length 71.4
  TOP w0.147: J2.B13 58.67,128.33 58.82,128.47 59.11,128.47 59.26,128.33 59.26,127.32 59.26,127.32 59.26,125.47 59.62,125.1 61.1,125.1 64.83,121.38 64.83,115.74 70.48,110.08 70.49,110.08 71.35,109.22 71.35,106.04 71.47,105.92 72.93,105.92 73.05,105.8 73.05,105.63 72.93,105.52 71.47,105.52 71.35,105.4 71.35,105.23 71.47,105.12 72.93,105.12 73.05,105 73.05,104.83 72.93,104.71 71.47,104.71 71.35,104.6 71.35,104.43 71.47,104.31 72.93,104.31 73.05,104.2 73.05,104.03 72.93,103.91 71.47,103.91 71.35,103.79 71.35,103.61 70.48,102.74 70.48,96.92 70.81,96.6 70.81,90.88 72.71,88.98 78.56,88.98 82.83,84.7 83.22,84.7 83.46,84.47 83.46,84.14 83.69,83.9 84.26,83.9 U23.W3
PRG0_PRU1GPO5: length 57.7
  TOP w0.147: U23.P4 v1(88.26,83.1) ; J2.D6 v1(68.2,131.08)
  L03_SIG1 w0.091: v1(68.2,131.08) 68.63,130.65 68.63,121.75 68.81,121.56 68.81,116.09 83.19,101.71 83.19,93.02 84.01,92.2 84.01,88.85 87.86,85 87.86,83.5 v1(88.26,83.1)
PRG0_PRU1GPO6: length 69
  TOP w0.147: J2.E11 v1(61.85,132.35) ; U23.R5 v1(87.46,82.3)
  L08_SIG2 w0.091: v1(87.46,82.3) 87.06,82.7 86.51,82.7 86.26,82.96 86.26,84.3 85.75,84.81 82.27,84.81 78.39,88.69 75.52,88.69 74.31,89.89 74.31,96.83 69.87,101.27 69.87,104.33 64.29,109.91 64.29,128.78 64.87,129.36 64.87,132.54 64.52,132.89 62.39,132.89 v1(61.85,132.35)
PRG0_PRU1GPO8: length 51
  TOP w0.147: J2.B4 69.51,127.31 69.51,125.84 69.92,125.43 69.92,121.27 69.51,120.86 69.51,115.94 80.46,104.99 80.46,95.27 83.91,91.82 83.91,90.95 87.64,87.22 87.65,87.22 87.86,87.01 U23.R1
PRG0_PRU1GPO11: length 64.5
  TOP w0.147: J2.D11 v1(61.85,131.08) ; U23.W4 v1(84.26,83.1)
  L03_SIG1 w0.091: v1(84.26,83.1) 83.91,83.45 83.91,85.78 83.73,85.97 83.73,86.1 83.97,86.34 83.97,86.47 83.85,86.58 83.72,86.58 83.48,86.34 83.35,86.34 83.24,86.46 83.24,86.59 83.48,86.83 83.48,86.96 83.36,87.07 83.23,87.07 83,86.83 82.87,86.83 82.75,86.95 82.75,87.08 82.99,87.31 82.99,87.44 82.87,87.56 82.75,87.56 82.51,87.32 82.38,87.32 82.26,87.44 82.26,87.56 82.5,87.8 82.5,87.93 82.39,88.05 82.26,88.05 82.02,87.81 81.89,87.81 81.77,87.92 81.77,88.05 82.01,88.29 82.01,88.42 81.9,88.54 81.77,88.54 81.53,88.3 81.4,88.3 81.29,88.41 81.29,88.54 81.52,88.78 81.52,88.91 81.41,89.02 81.28,89.02 81.04,88.79 80.91,88.79 80.8,88.9 80.8,89.03 81.04,89.27 81.04,89.4 80.92,89.51 80.79,89.51 80.55,89.27 80.42,89.27 80.03,89.66 80.03,102.54 66.4,116.17 66.4,120.17 62.56,124.01 62.56,130.37 v1(61.85,131.08)
PRG0_PRU1GPO12: length 64.8
  TOP w0.147: U23.Y4 83.46,83.1 82.36,83.1 81.9,83.56 81.9,83.94 81.66,84.19 81.65,84.19 81.32,84.51 80.34,84.51 78.41,86.44 73.15,86.44 67.67,91.92 67.67,96.48 69.31,98.12 69.31,106.32 63.65,111.98 63.65,120.89 60.61,123.93 56.92,123.93 56.74,124.1 56.74,127.76 56.6,127.9 J2.B15
PRG0_PRU1GPO13: length 64.6
  TOP w0.147: U23.T6 v1(86.66,81.5) ; J2.D5 v1(69.47,131.08)
  L03_SIG1 w0.091: v1(69.47,131.08) 70.13,130.42 70.13,124.66 69.8,124.34 69.8,119.28 69.89,119.18 70.27,119.18 70.36,119.09 70.36,118.93 70.27,118.84 69.89,118.84 69.8,118.75 69.8,118.58 69.89,118.49 70.27,118.49 70.36,118.4 70.36,118.24 70.27,118.15 69.89,118.15 69.8,118.06 69.8,115.88 83.85,101.82 83.85,93.35 84.68,92.52 84.68,90.48 89.46,85.7 89.46,81.34 89.22,81.11 87.06,81.11 v1(86.66,81.5)
PRG0_PRU1GPO14: length 64.4
  TOP w0.147: J2.E12 v1(60.58,132.35) ; U23.U6 v1(85.86,81.5)
  L03_SIG1 w0.091: v1(85.86,81.5) 85.46,81.11 84.01,81.11 83.47,81.64 83.47,84.11 79.59,88 79.59,102.46 65.99,116.06 65.99,120.06 61.3,124.75 61.3,131.63 v1(60.58,132.35)
PRG0_PRU1GPO15: length 64.3
  TOP w0.147: U23.U5 v1(85.86,82.3) ; J2.C11 v1(61.85,129.81)
  L03_SIG1 w0.091: v1(61.85,129.81) 61.85,129.14 61.94,129.05 62.24,129.05 62.33,128.96 62.33,128.79 62.24,128.7 61.94,128.7 61.85,128.61 61.85,128.45 61.94,128.36 62.24,128.36 62.33,128.27 62.33,128.1 62.24,128.01 61.94,128.01 61.85,127.92 61.85,127.76 61.94,127.67 62.24,127.67 62.33,127.57 62.33,127.41 62.24,127.32 61.94,127.32 61.85,127.23 61.85,127.07 61.94,126.98 62.24,126.98 62.33,126.88 62.33,126.72 62.24,126.63 61.94,126.63 61.85,126.54 61.85,126.38 61.94,126.28 62.24,126.28 62.33,126.19 62.33,126.03 62.24,125.94 61.94,125.94 61.85,125.85 61.85,124.46 66.18,120.13 66.18,116.14 79.81,102.5 79.81,88.99 83.69,85.1 83.69,82.18 83.97,81.91 85.46,81.91 v1(85.86,82.3)
PRG0_PRU1GPO16: length 62.4
  TOP w0.147: U23.AA4 82.09,82.7 81.48,83.31 v1(81.48,83.77) ; J2.A15 v1(55.5,126)
  L08_SIG2 w0.091: v1(81.48,83.77) 77.77,87.48 77.76,87.48 77.74,87.5 75.66,87.5 73.58,89.59 73.58,96.52 69.13,100.97 69.13,103.38 63.37,109.14 63.37,123.55 60.92,126 57.61,126 57.5,126.11 57.5,126.49 57.39,126.59 57.24,126.59 57.13,126.49 57.13,126.11 57.03,126 56.87,126 56.77,126.11 56.77,126.49 56.66,126.59 56.51,126.59 56.4,126.49 56.4,126.11 56.29,126 v1(55.5,126)
PRG1_ETH2_D0M: length 29
  BOTTOM w0.108: J21.B2 13.04,68.98 16.72,65.3 19.79,65.3 21.2,63.89 34.86,63.89 34.96,64 U80.2
PRG1_ETH2_D0P: length 29
  BOTTOM w0.108: J21.B1 12.45,72.09 12.75,71.79 12.75,68.86 16.6,65.01 19.67,65.01 21.08,63.6 34.77,63.6 34.88,63.5 U80.1
PRG1_ETH2_D1M: length 28.8
  BOTTOM w0.108: J21.B4 15.48,73.26 15.48,72.14 15.77,71.84 15.77,70.61 16.48,69.9 18.49,69.9 23.53,64.86 24.91,64.86 25.02,64.97 25.02,65.69 25.29,65.96 25.75,65.96 26.03,65.69 26.03,64.97 26.13,64.86 26.35,64.86 26.46,64.97 26.46,65.69 26.74,65.96 27.19,65.96 27.47,65.69 27.47,64.97 27.58,64.86 31.48,64.86 32.01,65.39 34.95,65.39 35.06,65.5 U80.5
PRG1_ETH2_D1P: length 28.8
  BOTTOM w0.108: J21.B3 15.11,72.09 15.49,71.72 15.49,70.49 16.36,69.61 18.37,69.61 23.41,64.57 25.03,64.57 25.31,64.85 25.31,65.57 25.41,65.67 25.63,65.67 25.74,65.57 25.74,64.85 26.01,64.57 26.47,64.57 26.75,64.85 26.75,65.57 26.86,65.67 27.07,65.67 27.18,65.57 27.18,64.85 27.46,64.57 31.6,64.57 32.13,65.1 34.95,65.1 35.05,65 U80.4
PRG1_ETH2_D2M: length 28.9
  BOTTOM w0.108: U80.8 34.82,67 34.72,66.89 29.83,66.89 29.72,67 29.72,67.82 29.45,68.1 28.99,68.1 28.71,67.82 28.71,67 28.6,66.89 28.39,66.89 28.28,67 28.28,67.82 28,68.1 27.55,68.1 27.27,67.82 27.27,67 27.16,66.89 26.95,66.89 26.84,67 26.84,67.82 26.56,68.1 26.1,68.1 25.83,67.82 25.83,67 25.72,66.89 25.5,66.89 25.39,67 25.39,67.82 25.12,68.1 24.66,68.1 24.38,67.82 24.38,67 24.28,66.89 22.84,66.89 18.28,71.46 18.28,71.74 18.12,71.9 J21.B6
PRG1_ETH2_D2P: length 28.9
  BOTTOM w0.108: J21.B5 17.52,72.09 17.99,71.62 17.99,71.34 22.72,66.61 24.4,66.61 24.67,66.88 24.67,67.7 24.78,67.81 25,67.81 25.11,67.7 25.11,66.88 25.38,66.61 25.84,66.61 26.12,66.88 26.12,67.7 26.22,67.81 26.44,67.81 26.55,67.7 26.55,66.88 26.83,66.61 27.28,66.61 27.56,66.88 27.56,67.7 27.67,67.81 27.88,67.81 27.99,67.7 27.99,66.88 28.27,66.61 28.72,66.61 29,66.88 29,67.7 29.11,67.81 29.33,67.81 29.43,67.7 29.43,66.88 29.71,66.61 34.71,66.61 34.82,66.5 U80.7
PRG1_ETH2_D3M: length 28.9
  BOTTOM w0.108: J21.B8 20.61,73.31 20.61,71.42 22.95,69.08 24.01,69.08 24.12,69.19 24.12,70.11 24.4,70.38 24.85,70.38 25.13,70.11 25.13,69.19 25.24,69.08 25.45,69.08 25.56,69.19 25.56,70.11 25.84,70.38 26.29,70.38 26.57,70.11 26.57,69.19 26.68,69.08 26.9,69.08 27,69.19 27,70.11 27.28,70.38 27.74,70.38 28.01,70.11 28.01,69.19 28.12,69.08 28.34,69.08 28.45,69.19 28.45,70.11 28.72,70.38 29.18,70.38 29.46,70.11 29.46,69.19 29.57,69.08 29.78,69.08 29.89,69.19 29.89,70.11 30.17,70.38 30.62,70.38 30.9,70.11 30.9,69.19 31.01,69.08 31.83,69.08 32.52,68.39 34.65,68.39 34.75,68.5 U80.11
PRG1_ETH2_D3P: length 28.9
  BOTTOM w0.108: J21.B7 20.12,72.09 20.32,71.89 20.32,71.3 22.83,68.79 24.13,68.79 24.41,69.07 24.41,69.99 24.52,70.09 24.73,70.09 24.84,69.99 24.84,69.07 25.12,68.79 25.57,68.79 25.85,69.07 25.85,69.99 25.96,70.09 26.17,70.09 26.28,69.99 26.28,69.07 26.56,68.79 27.02,68.79 27.29,69.07 27.29,69.99 27.4,70.09 27.62,70.09 27.73,69.99 27.73,69.07 28,68.79 28.46,68.79 28.74,69.07 28.74,69.99 28.84,70.09 29.06,70.09 29.17,69.99 29.17,69.07 29.45,68.79 29.9,68.79 30.18,69.07 30.18,69.99 30.29,70.09 30.5,70.09 30.61,69.99 30.61,69.07 30.89,68.79 31.71,68.79 32.4,68.1 34.74,68.1 34.85,68 U80.10
PRG1_ETH2_GPIO_1: length 42.8
  BOTTOM w0.147: U80.22 40.74,70.61 R341.1 R340.2 42.55,71.02 43.18,71.65 43.18,73.05 42.7,73.53 42.7,75.82 41.48,77.04 41.48,84.09 41.03,84.53 36.37,84.53 35,85.9 25.83,85.9 25.17,86.56 18.87,86.56 18.26,87.17 R617.2
PRG1_ETH2_LED1: length 3.2
  BOTTOM w0.147: J21.B11 11.22,71.05 Q14.3
PRG1_ETH2_LED2: length 7.6
  BOTTOM w0.147: Q21.3 14.33,83.01 14.45,82.89 R616.1 13.73,82.25 J21.B14
PRG1_ETH2_LED3: length 9.4
  BOTTOM w0.147: J21.B13 8.91,77.43 7.13,77.43 6.44,78.12 Q16.3 3.74,78.7 3.74,78.7 R615.1
PRG1_ETH2_LED_1000/RX_ER: length 118.2
  TOP w0.147: v1(35.31,59.64) 36.07,58.87 41.72,58.87 43.44,60.59 45.61,60.59 46.86,61.85 46.86,63.47 49.71,66.32 51.84,66.32 56.29,70.77 56.29,75.23 62.73,81.66 66.53,81.66 67.16,81.03 67.85,81.03 71.92,76.97 71.92,75.58 73.51,73.99 75.54,73.99 76.5,74.96 79.2,74.96 79.75,75.5 82.47,75.5 82.49,75.49 82.83,75.49 82.85,75.5 U23.AA13
  L08_SIG2 w0.091: v1(35.31,59.64) 34.55,59.64 30.61,63.57 20.75,63.57 19.05,61.86 13.59,61.86 12.63,62.82 9.17,62.82 4.62,67.36 4.62,68.55 3.1,70.08 3.1,75.83 v1(2.48,76.45)
  BOTTOM w0.147: U80.46 37.24,62.2 36.87,61.83 36.71,61.83 36.57,61.7 36.54,61.7 36.47,61.64 35.84,61.64 35.31,61.1 v1(35.31,59.64) R388.2 36.25,58.61 R386.1 ; R343.2 v1(2.48,76.45)
PRG1_ETH2_LED_ACT: length 39.1
  L08_SIG2 w0.091: v1(10.27,66.35) 13.34,69.42 19.68,69.42 25.35,63.75 30.69,63.75 30.7,63.74 30.75,63.74 34.41,60.09 35.74,60.09 v1(36.34,59.48)
  BOTTOM w0.147: R324.1 v1(10.27,66.35) ; U80.45 37.74,62.41 37.67,62.34 37.67,62.21 37.53,62.08 37,61.54 36.87,61.54 36.48,61.14 36.47,61.14 36.21,60.88 36.21,60.88 36.02,60.69 36.02,59.8 v1(36.34,59.48) 36.59,59.23 36.75,59.23 37.31,58.68 R385.1 37.41,58.61 R387.2
PRG1_ETH2_LED_LINK: length 75.8
  TOP w0.147: U23.U12 v1(85.86,75.9)
  L08_SIG2 w0.091: v1(34.67,61.17) 35.37,61.86 37.41,61.86 38.72,60.55 41.02,60.55 41.4,60.93 41.4,62.89 42.58,64.08 43.45,64.08 43.7,63.82 43.7,62.64 43.11,62.05 42.87,62.05 42.62,61.79 42.62,61.43 43.2,60.85 45.57,60.85 46.1,61.37 46.1,61.91 46.8,62.61 46.8,63.18 61.33,77.71 75.22,77.71 76.8,76.13 81.01,76.13 81.26,76.38 82.75,76.38 83.06,76.07 83.06,75.74 83.29,75.51 85.46,75.51 v1(85.86,75.9)
  BOTTOM w0.147: R562.2 R563.1 34.04,60.53 v1(34.67,61.17) 35.5,61.99 36.45,61.99 36.74,62.28 U80.47
PRG1_ETH3_D0M: length 27.3
  TOP w0.108: U20.2 35.07,84.12 34.96,84.24 33.23,84.24 32.07,85.39 19.43,85.39 13.04,79.01 J21.A2
PRG1_ETH3_D0P: length 27.3
  TOP w0.108: U20.1 35.02,84.62 34.92,84.52 33.35,84.52 32.19,85.68 19.31,85.68 12.75,79.13 12.75,78.98 12.47,78.69 J21.A1
PRG1_ETH3_D1M: length 27
  TOP w0.108: U20.5 35.07,82.62 34.96,82.74 28.54,82.74 28.26,83.01 28.26,83.7 28.15,83.81 27.94,83.81 27.83,83.7 27.83,83.01 27.55,82.74 27.09,82.74 26.82,83.01 26.82,83.7 26.71,83.81 26.49,83.81 26.39,83.7 26.39,83.01 26.11,82.74 25.61,82.74 24.77,81.89 17.8,81.89 15.79,79.88 15.79,79.06 15.58,78.84 J21.A4
PRG1_ETH3_D1P: length 27
  TOP w0.108: J21.A3 15.02,78.69 15.51,79.18 15.51,80 17.68,82.18 24.65,82.18 25.49,83.02 25.99,83.02 26.1,83.13 26.1,83.82 26.37,84.1 26.83,84.1 27.11,83.82 27.11,83.13 27.21,83.02 27.43,83.02 27.54,83.13 27.54,83.82 27.82,84.1 28.27,84.1 28.55,83.82 28.55,83.13 28.66,83.02 34.92,83.02 35.02,83.12 U20.4
PRG1_ETH3_D2M: length 26.7
  TOP w0.108: U20.8 34.88,81.12 34.76,81.24 30.3,81.24 29.85,80.79 29.06,80.79 28.95,80.68 28.95,79.83 28.67,79.55 28.22,79.55 27.94,79.83 27.94,80.68 27.83,80.79 27.62,80.79 27.51,80.68 27.51,79.83 27.23,79.55 26.77,79.55 26.5,79.83 26.5,80.68 26.39,80.79 26.17,80.79 26.06,80.68 26.06,79.83 25.79,79.55 25.33,79.55 25.05,79.83 25.05,80.68 24.95,80.79 18.81,80.79 18.12,80.1 J21.A6
PRG1_ETH3_D2P: length 26.8
  TOP w0.108: U20.7 34.84,81.62 34.75,81.53 30.18,81.53 29.73,81.08 28.94,81.08 28.66,80.8 28.66,79.95 28.55,79.84 28.34,79.84 28.23,79.95 28.23,80.8 27.95,81.08 27.5,81.08 27.22,80.8 27.22,79.95 27.11,79.84 26.89,79.84 26.79,79.95 26.79,80.8 26.51,81.08 26.05,81.08 25.78,80.8 25.78,79.95 25.67,79.84 25.45,79.84 25.34,79.95 25.34,80.8 25.07,81.08 18.69,81.08 17.83,80.22 17.83,78.98 17.55,78.69 J21.A5
PRG1_ETH3_D3M: length 27
  TOP w0.108: J21.A8 20.66,79.23 21.37,79.94 22.91,79.94 24.2,78.64 27.71,78.64 27.81,78.55 27.81,77.21 28.07,76.94 28.45,76.94 28.72,77.21 28.72,78.55 28.81,78.64 28.95,78.64 29.04,78.55 29.04,77.21 29.31,76.94 29.69,76.94 29.95,77.21 29.95,78.55 30.05,78.64 30.19,78.64 30.28,78.55 30.28,77.21 30.55,76.94 30.92,76.94 31.19,77.21 31.19,78.55 31.29,78.64 31.52,78.64 32.61,79.74 34.96,79.74 35.07,79.62 U20.11
PRG1_ETH3_D3P: length 27
  TOP w0.108: J21.A7 20.1,78.69 20.37,78.96 20.37,79.35 21.25,80.22 23.03,80.22 24.32,78.93 27.83,78.93 28.1,78.66 28.1,77.33 28.19,77.23 28.33,77.23 28.43,77.33 28.43,78.66 28.69,78.93 29.07,78.93 29.33,78.66 29.33,77.33 29.43,77.23 29.57,77.23 29.66,77.33 29.66,78.66 29.93,78.93 30.31,78.93 30.57,78.66 30.57,77.33 30.67,77.23 30.8,77.23 30.9,77.33 30.9,78.66 31.17,78.93 31.4,78.93 32.49,80.02 34.92,80.02 35.02,80.12 U20.10
PRG1_ETH3_GPIO_1: length 39.6
  TOP w0.147: v1(43.23,76.99) 43.05,77.17 R115.1 R114.2 40.87,77.58 U20.22 ; R614.2 v1(17.47,90.6)
  BOTTOM w0.147: v1(17.47,90.6) 18.74,90.6 18.84,90.7 22.8,90.7 26.71,86.79 35.46,86.79 36.84,85.42 41.4,85.42 41.42,85.39 41.49,85.39 42.36,84.52 42.36,77.86 v1(43.23,76.99)
PRG1_ETH3_LED1: length 3.7
  BOTTOM w0.147: Q15.3 6.88,72.24 7,72.35 J21.A11
PRG1_ETH3_LED2: length 12.4
  TOP w0.147: J21.A14 12.95,83.32 R613.1 13.55,86.25 13.55,86.25 Q20.3
PRG1_ETH3_LED3: length 14.7
  TOP w0.147: Q4.3 8.56,86.23 8.55,86.23 R612.1 6.52,86.23 4.6,84.3 4.6,79.89 J21.A13
PRG1_ETH3_LED_1000/RX_ER: length 97.9
  TOP w0.147: U20.46 37.37,85.97 37.05,86.28 36.97,86.28 36.77,86.49 35.96,86.49 35.43,87.01 v1(35.43,88.48) R94.2 36.38,89.51 R96.1 ; v1(14.94,90.35) 13.69,90.35 13.01,89.67 R99.2 ; U23.V13 v1(85.06,75.1)
  L03_SIG1 w0.091: v1(85.06,75.1) 84.64,75.52 83.22,75.52 83.04,75.71 83.04,76.06 82.7,76.4 81.59,76.4 80.37,77.62 80.37,78.35 75.92,82.79 75.92,84.88 73.15,87.64 v1(73.15,90.18)
  BOTTOM w0.147: v1(73.15,90.18) 73.15,90.95 72.9,91.2 72.14,91.2 70.99,90.06 60.71,90.06 59.01,88.37 50.11,88.37 48.84,89.64 45.88,89.64 42.54,86.29 37.17,86.29 35.79,87.67 35.79,88.13 v1(35.43,88.48) 34.25,88.48 32.79,89.94 29.95,89.94 28.65,91.24 16.28,91.24 15.39,90.35 v1(14.94,90.35)
PRG1_ETH3_LED_ACT: length 56.4
  TOP w0.147: U20.45 37.87,85.94 37.22,86.58 37.1,86.58 36.79,86.88 36.45,86.88 36.15,87.18 36.15,88.32 v1(36.47,88.63) 36.55,88.63 36.8,88.88 36.88,88.88 37.44,89.44 R97.1 37.53,89.51 R95.2
  L08_SIG2 w0.091: v1(1.51,70.61) 2.31,71.42 2.31,74.42 1.85,74.88 1.85,79.73 7.98,85.85 27.8,85.85 31.75,89.8 35.3,89.8 v1(36.47,88.63)
  BOTTOM w0.147: R334.1 v1(1.51,70.61)
PRG1_ETH3_LED_LINK: length 71.8
  TOP w0.147: R564.2 R565.1 34.16,87.68 v1(34.5,87.35) 34.82,87.03 34.82,86.93 35.63,86.12 36.7,86.12 36.87,85.96 U20.47 ; U23.W13 v1(84.26,75.1)
  L03_SIG1 w0.091: v1(84.26,75.1) 84.14,75.22 82.56,75.22 82.19,75.59 80.95,75.59 79.63,76.91 79.63,78.72 75.65,82.7 75.65,84.76 72.64,87.77 v1(72.64,90.69)
  BOTTOM w0.147: v1(72.64,90.69) 71.71,89.76 60.83,89.76 59.1,88.04 49.97,88.04 48.7,89.31 45.98,89.31 44.88,88.21 44.88,88.21 42.66,85.99 36.96,85.99 35.6,87.35 v1(34.5,87.35)
PRG1_IEP0_EDC_LATCH_IN0: length 30.1
  TOP w0.147: U23.V7 v1(85.06,80.7)
  L08_SIG2 w0.091: J17.1 67.02,96.5 69.55,96.5 70.23,95.82 70.23,90.35 70.23,90.35 70.23,90.04 70.31,89.96 70.31,89.92 74.11,86.12 75.26,84.96 77.93,84.96 78,84.89 78.09,84.89 81.88,81.1 84.66,81.1 v1(85.06,80.7)
