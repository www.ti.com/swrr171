# Allegro board PROC101B_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_UDQS_N: length 44.2
  TOP w0.153: U23.M1 v1(89.86,85.5) ; U13.A7 v1(92,110.55)
  L08_SIG2 w0.107: v1(89.86,85.5) 89.6,85.5 89.44,85.67 89.44,86.05 88.68,86.81 87.83,86.81 84.64,90 84.64,92.46 81.62,95.48 81.62,100.71 81.71,100.81 81.88,100.81 82.1,101.03 82.1,101.35 81.88,101.57 81.71,101.57 81.62,101.66 81.62,101.8 81.71,101.9 81.88,101.9 82.1,102.12 82.1,102.43 81.88,102.66 81.71,102.66 81.62,102.75 81.62,102.89 81.71,102.98 81.88,102.98 82.1,103.21 82.1,103.52 81.88,103.74 81.71,103.74 81.62,103.84 81.62,103.97 81.71,104.07 81.88,104.07 82.1,104.29 82.1,104.61 81.88,104.83 81.71,104.83 81.62,104.93 81.62,105.06 81.71,105.16 81.88,105.16 82.1,105.38 82.1,105.69 81.88,105.92 81.71,105.92 81.62,106.01 81.62,106.23 86.69,111.3 88.36,111.3 88.9,110.76 91.19,110.76 91.48,111.06 92.23,111.06 92.58,110.7 92.58,110.43 92.36,110.21 91.79,110.21 91.68,110.32 91.68,110.48 91.75,110.55 v1(92,110.55)
DDR_UDQS_P: length 44.3
  TOP w0.153: U23.N1 v1(89.06,85.5) ; U13.B7 v1(92,109.75)
  L08_SIG2 w0.107: v1(92,109.75) 92.24,109.99 92.45,109.99 92.8,110.34 92.8,110.79 92.32,111.27 91.39,111.27 91.1,110.97 88.99,110.97 88.45,111.51 86.6,111.51 81.4,106.32 81.4,105.92 81.62,105.7 81.79,105.7 81.88,105.6 81.88,105.47 81.79,105.37 81.62,105.37 81.4,105.15 81.4,104.84 81.62,104.61 81.79,104.61 81.88,104.52 81.88,104.38 81.79,104.29 81.62,104.29 81.4,104.06 81.4,103.75 81.62,103.53 81.79,103.53 81.88,103.43 81.88,103.29 81.79,103.2 81.62,103.2 81.4,102.98 81.4,102.66 81.62,102.44 81.79,102.44 81.88,102.34 81.88,102.21 81.79,102.11 81.62,102.11 81.4,101.89 81.4,101.57 81.62,101.35 81.79,101.35 81.88,101.26 81.88,101.12 81.79,101.02 81.62,101.02 81.4,100.8 81.4,95.39 84.42,92.37 84.42,89.91 87.74,86.59 88.59,86.59 89.22,85.96 89.22,85.66 v1(89.06,85.5)
DDR_VPP: length 27.9
  TOP w0.381: U13.B1 v1(87.21,109.75) ; U13.R9 v1(94.4,98.55)
  L06_PWR2 w0.381: v1(94.4,98.55) 94.63,98.33 94.97,98.33 95.18,98.12 95.18,97.01 94.8,96.62 87.31,96.62 86.4,97.53 86.4,108.9 86.8,109.3 86.8,109.35 v1(87.21,109.75)
  BOTTOM w0.254: v1(87.21,109.75) 86.6,109.75 C227.2 ; C270.2 94.68,96.92 95.08,97.32 95.08,97.88 v1(94.4,98.55)
DDR_VREFCA: length 19.7
  TOP w0.254: C42.2 85.98,100.85 86.09,100.95 87.21,100.95 U13.M1
  TOP w0.381: v1(79.12,113.17) 80.14,113.17 83.06,110.25 83.06,108.98 85.98,106.06 85.98,102.31 85.09,101.42 C42.2
  BOTTOM w0.203: 78.36,114.31 78.14,114.53 U68.6
DDR_VTT_EN: length 92.5
  TOP w0.147: U23.L18 v1(91.46,71.1) ; U10.5 v1(126.73,116.61)
  L08_SIG2 w0.091: v1(91.46,71.1) 91.83,70.73 91.83,69.46 93.2,68.09 95.69,68.09 99.78,64 99.78,62.74 102.68,59.83 106.17,59.83 107.31,58.69 109.86,58.69 112.9,61.74 112.9,65.29 115.87,68.26 117.79,68.26 120.74,71.21 120.74,105.73 123.94,108.93 123.94,112.59 123.95,112.6 123.95,112.9 126.73,115.68 v1(126.73,116.61)
DDR_VTT_EN_3V3: length 63.3
  TOP w0.147: U10.8 v1(125.23,116.61)
  TOP w0.203: v1(77.47,114.19) 77.95,114.19 78.34,113.8 R29.1 78.34,112.55 77.98,112.19 TP7.1
  L03_SIG1 w0.091: v1(125.23,116.61) 123.57,114.95 123.57,110.49 121.39,108.31 120.89,108.31 115.58,113.61 78.05,113.61 v1(77.47,114.19)
  BOTTOM w0.203: U68.7 77.74,114.46 v1(77.47,114.19) 77.22,114.19 76.94,114.46 U68.9
DEBOUNCE_GPIO_SOC/MCU: length 35.6
  TOP w0.147: U50.3 127.97,28.08 128.12,27.92 130.84,27.92 131.49,27.27 131.49,25.66 v1(130.36,24.53) ; SW5.1 122.03,10.59 122.45,11.01 122.45,17.39 122.03,17.81 SW5.2 122.03,19.08 v1(121.97,19.14)
  BOTTOM w0.147: v1(130.36,24.53) Q17.2 131.34,23.49 131.57,23.26 131.57,20.97 130.53,19.93 128.07,19.93 126.68,18.54 R534.1 C465.2 122.79,18.54 122.56,18.3 122.54,18.3 122.5,18.26 D8.2 121.92,19.09 v1(121.97,19.14)
DEBOUNCE_MCU_RESETZ: length 26.3
  TOP w0.147: U50.1 127.54,27.08 127.68,27.22 Q8.2 128.26,25.41 128.15,25.31 128.15,25.3 127.13,24.27 127.13,21.3 v1(129.31,19.12) 129.33,19.1 SW6.2 129.33,17.26 129.74,16.84 129.74,11.01 129.33,10.59 SW6.1
  BOTTOM w0.147: C466.2 R536.1 130.31,18.39 130.03,18.12 D9.2 129.29,18.64 129.31,18.66 v1(129.31,19.12)
DEBOUNCE_WARM_RST: length 29.7
  TOP w0.147: v1(114.68,19.17) 114.68,17.97 SW4.2 114.74,16.84 115.14,16.44 115.14,10.99 114.74,10.59 SW4.1 ; U50.6 123.3,28.08 124.27,27.11 Q10.2 v1(124.27,22.37)
  BOTTOM w0.147: v1(114.68,19.17) 114.68,18.71 114.63,18.66 D11.2 115.12,17.95 115.52,18.35 C467.2 R537.1 120.26,18.35 v1(124.27,22.37)
DEMB: length 4.3
  TOP w0.147: R693.2 160.68,54.55 U30.33
DIR: length 21.6
  L08_SIG2 w0.091: v1(77.29,52.85) 77.72,53.28 77.72,55.89 73.66,59.96 73.66,65.84 v1(72.52,66.98)
  BOTTOM w0.147: U81.2 77.18,52.96 v1(77.29,52.85) ; v1(72.52,66.98) 72.32,67.18 R355.1 R356.2 70.36,67.45 69.81,68 U79.2
DISPLAY_VDDB3V3_ON: length 3.3
  BOTTOM w0.147: U99.4 27.66,18.12 27.73,18.19 R538.2
EEPROM_A1: length 3.7
  TOP w0.147: U7.2 112.39,118.88 R26.2 R27.2
EEPROM_A2: length 3.4
  TOP w0.147: R18.2 R17.2 112.26,119.73 112.05,119.53 U7.3
EEPROM_WP: length 2.3
  TOP w0.147: U7.7 103.52,118.88 103.34,119.06 R25.2
EMMC_RSTN: length 13.3
  TOP w0.147: U44.K5 117.37,35.85 117.11,36.11 v1(117.11,36.14) ; v1(117.37,29.59) R193.2 117.37,28.13 117.41,28.08 U54.4
  BOTTOM w0.147: v1(117.11,36.14) 115.39,36.14 114.43,35.18 114.43,32.53 v1(117.37,29.59)
EXP_BRD_DET_INTN: length 2.1
  BOTTOM w0.147: U66.13 103.64,118.88 103.55,118.79 R226.1
FSI_FET_ENN: length 1.6
  TOP w0.147: U8.17 60.69,118.87 R21.1
FSI_FET_SEL: length 126.6
  TOP w0.147: U8.21 v1(58.03,121.04) ; U8.11 58.53,115.09 v1(59.69,113.93) 59.18,113.43 56.9,113.43 55.5,112.03 51.18,112.03 50.8,112.41 v1(44.2,112.41)
  L03_SIG1 w0.091: v1(58.03,121.04) 58.34,120.74 58.34,115.29 v1(59.69,113.93) ; v1(53.47,29.73) 53.47,30.96 52.37,32.05 52.37,34.09 52.04,34.42 51.69,34.42 51.33,34.77 51.33,35.18 50.34,36.17 50.34,43.08 47.24,46.18 45.11,46.18 40.92,50.37 40.92,56.16 46.81,62.05 46.81,64.63 49.39,67.21 49.39,70.66 46.56,73.49 46.56,85.45 47.7,86.59 47.7,89.63 46.55,90.78 46.55,92.29 43.41,95.42 43.41,96.52 42.8,97.13 42.8,101.6 44.2,103 v1(44.2,112.41)
  BOTTOM w0.147: v1(53.47,29.73) 53.49,29.76 U91.8 ; v1(58.03,121.04) U8.21
FSI_RX0_CLK: length 61.6
  TOP w0.147: v1(56.54,114.31) 57.04,114.81 U8.8
  L08_SIG2 w0.091: v1(56.54,114.31) 55.9,114.95 55.9,120.01 55.12,120.79 7.71,120.79 6.5,122 4.89,122 J7.1
FSI_RX0_D0: length 63.7
  TOP w0.147: v1(58.67,113.93) 58.03,114.57 U8.10
  L08_SIG2 w0.091: v1(58.67,113.93) 57.52,113.93 55.84,112.25 46.19,112.25 43.75,114.7 32.51,114.7 31.88,115.33 29.27,115.33 26.09,112.16 11.51,112.16 8.61,115.05 8.61,115.74 7.25,117.09 4.71,117.09 J7.5
FSI_RX0_D1: length 62.7
  TOP w0.147: v1(59.69,114.95) 59.03,115.6 U8.12
  L08_SIG2 w0.091: J7.7 4.87,114.4 6.86,114.4 9.36,111.9 26.18,111.9 28.67,114.39 43.74,114.39 46.1,112.03 55.93,112.03 57.4,113.5 58.85,113.5 59.11,113.75 59.11,114.37 v1(59.69,114.95)
FSI_TX0_CLK: length 59.2
  TOP w0.147: U8.13 v1(59.83,116.35)
  L08_SIG2 w0.091: J7.2 7.98,123.33 10.29,121.01 55.28,121.01 56.13,120.16 56.13,116.73 56.52,116.35 v1(59.83,116.35)
FSI_TX0_D0: length 72.6
  TOP w0.147: U8.14 60.57,117.37 v1(60.83,117.11)
  L08_SIG2 w0.091: J7.6 4.69,119.66 2.87,119.66 2.18,120.35 2.18,123.67 3.49,124.98 7.09,124.98 10.84,121.23 55.68,121.23 57.14,119.78 59.05,119.78 59.36,119.46 59.36,117.94 60.2,117.11 v1(60.83,117.11)
FSI_TX0_D1: length 75.4
  TOP w0.147: U8.15 v1(60.58,117.87)
  L08_SIG2 w0.091: J7.8 4.97,116.84 3.25,116.84 1.52,118.57 1.52,124.32 2.84,125.64 8.74,125.64 12.93,121.45 55.77,121.45 57.27,119.96 59.13,119.96 59.69,119.39 59.69,118.76 v1(60.58,117.87)
FT4232_DO: length 3.7
  TOP w0.147: v1(132.85,28.2) 133.45,28.2 133.62,28.38 R192.2 R191.1
  BOTTOM w0.147: U92.4 133.03,28.38 v1(132.85,28.2)
FT4232_EECLK: length 10.4
  TOP w0.147: v1(135.38,29.99) 135.13,30.24 R186.1
  BOTTOM w0.147: U87.62 137.97,34.48 136.02,32.53 136.02,30.62 v1(135.38,29.99) 135.38,29.82 135.24,29.68 U92.2
FT4232_EECS: length 8.6
  BOTTOM w0.147: U87.63 137.47,34.61 135,32.15 R463.1 134.09,31.56 134.13,31.52 U92.1
FT4232_EEDATA: length 12
  TOP w0.147: R192.1 v1(135.76,28.97)
  BOTTOM w0.147: U87.61 138.47,34.47 136.4,32.4 136.4,29.61 v1(135.76,28.97) 135.31,28.97 135.26,29.03 U92.3
FT4232_MCU_UART0_CTS_3V3: length 6.2
  TOP w0.147: v1(142.47,49.52) 143.48,49.52 144.02,50.05 v1(144.02,52.47)
  BOTTOM w0.147: U82.12 143.86,52.63 v1(144.02,52.47) ; U87.28 v1(142.47,49.52)
FT4232_MCU_UART0_RTS_3V3: length 3.8
  BOTTOM w0.147: U87.29 142.97,49.73 142.57,50.13 142.57,52.03
FT4232_MCU_UART0_RX_3V3: length 4.8
  TOP w0.147: v1(143.13,51.2) 142.75,50.81 141.99,50.81 141.47,50.29 v1(141.47,49.52)
  BOTTOM w0.147: U82.13 142.97,51.36 v1(143.13,51.2) ; U87.26 v1(141.47,49.52)
FT4232_MCU_UART0_TX_3V3: length 3.7
  BOTTOM w0.147: U82.15 142.17,49.98 141.97,49.78 U87.27
FT4232_REF: length 2.8
  TOP w0.147: R175.2 v1(136.38,41.65)
  BOTTOM w0.147: v1(136.38,41.65) 136.16,41.44 U87.6
FT4232_RESET: length 8.4
  BOTTOM w0.254: R417.1 129.54,46.75 130.18,47.39 132.93,47.39 133.08,47.24 C416.2 133.48,46.5 133.73,46.24 133.73,45.61 133.9,45.44 U87.14
FT4232_UART0_CTS_3V3: length 3.9
  TOP w0.147: v1(137.03,51.2) 137.47,50.76 v1(137.47,49.52)
  BOTTOM w0.147: U84.12 136.87,51.36 v1(137.03,51.2) ; U87.18 v1(137.47,49.52)
FT4232_UART0_RTS_3V3: length 4.5
  BOTTOM w0.147: U84.14 135.58,50.2 135.73,50.05 137.67,50.05 137.97,49.75 U87.19
FT4232_UART0_RX_3V3: length 5.4
  TOP w0.147: v1(136.53,50.58) 135,49.06 v1(135,47.26)
  BOTTOM w0.147: v1(135,47.26) 135,46.45 U87.16 ; v1(136.53,50.58) 136.29,50.81 136.04,50.81 U84.13
FT4232_UART0_TX_3V3: length 3.7
  BOTTOM w0.147: U84.15 135.18,50.13 135.64,49.67 136.7,49.67 136.97,49.41 U87.17
FT4232_UART1_RX_3V3: length 6.8
  BOTTOM w0.147: U89.13 151.8,41.42 151.5,41.72 151.5,41.93 149.5,43.94 148.52,43.94 148.51,43.93 147.65,43.93 147.64,43.94 U87.38
FT4232_UART1_TX_3V3: length 7.9
  TOP w0.147: v1(147.56,43.44) 151.78,43.44 v1(152.53,42.69)
  BOTTOM w0.147: U89.15 152.6,42.18 152.53,42.26 v1(152.53,42.69) ; U87.39 v1(147.56,43.44)
FT4232_UART3_RX_3V3: length 5.9
  BOTTOM w0.147: U87.48 148.52,38.94 150.21,40.62 U89.12
FT4232_UART3_TX_3V3: length 12.9
  TOP w0.147: v1(152.02,42.18) 151.56,42.18 150.17,40.78 147.7,40.78 145.49,38.57 v1(143.38,38.57)
  BOTTOM w0.147: U89.14 152.2,42 v1(152.02,42.18) ; U87.52 142.97,38.16 v1(143.38,38.57)
FT4232_USB_DM: length 52.6
  TOP w0.107: J26.2 173.05,41.43 172.83,41.21 172.55,41.21 v1(172.25,41.52) 171.89,41.16 171.7,41.16 171.39,40.85 171.39,40.59 171.22,40.42 171.06,40.42 170.95,40.53 U42.5
  L03_SIG1 w0.094: v1(137.43,41.78) 137.22,41.99 136.89,41.99 136.49,42.39 136.49,43.32 136.76,43.59 137.84,43.59 138.64,42.79 138.64,39.42 140.11,37.95 147.57,37.95 149.61,35.91 151.21,35.91 151.76,35.36 154.86,35.36 158.11,38.6 168.51,38.6 171.23,41.32 172.05,41.32 v1(172.25,41.52)
  BOTTOM w0.107: v1(137.43,41.78) 137.11,42.09 136.15,42.09 135.99,41.94 U87.7
FT4232_USB_DP: length 52.5
  TOP w0.107: J26.3 173.04,40.78 172.83,40.99 172.54,40.99 v1(172.25,40.7) 172,40.94 171.79,40.94 171.61,40.76 171.61,40.5 171.31,40.2 171.06,40.2 170.89,40.03 U42.4
  L03_SIG1 w0.094: v1(137.43,42.6) 137.43,42.34 137.32,42.23 137,42.23 136.74,42.49 136.74,43.22 136.86,43.34 137.74,43.34 138.39,42.68 138.39,39.32 140.01,37.7 147.47,37.7 149.51,35.67 151.11,35.67 151.66,35.11 154.97,35.11 158.21,38.35 168.61,38.35 171.33,41.08 172.37,41.08 172.47,40.98 172.47,40.8 172.37,40.7 v1(172.25,40.7)
  BOTTOM w0.107: U87.8 135.99,42.44 136.12,42.31 137.14,42.31 v1(137.43,42.6)
FT4232_USB_VBUS: length 4.5
  TOP w0.254: v1(170.63,41.54) 170.5,41.42 U42.6 ; C154.2 172.15,42.43 172.5,42.08 J26.1 ; U43.4 v1(166.38,39.37) ; U43.6 v1(165.09,39.37)
  vias: v1(171.51,45.99) v1(172.02,44.97)
FT_PWREN#: length 6.6
  BOTTOM w0.147: R464.1 138.2,31.87 138.97,32.64 U87.60
GPIO1_43_INTN: length 70.4
  TOP w0.147: U23.C13 v1(97.86,75.1)
  L03_SIG1 w0.091: v1(120.78,57.11) 120,56.34 115.87,56.34 114.27,57.94 114.27,65.04 112.84,66.47 112.84,69.84 110.63,72.05 110.63,73.85 110.07,74.4 103.06,74.4 102.78,74.12 101.8,74.12 101.61,74.31 99.09,74.31 98.3,75.1 v1(97.86,75.1)
  L08_SIG2 w0.091: v1(124.08,28.84) 120.78,32.15 120.78,46.79 121.08,47.09 121.08,49.12 122,50.04 122,55.7 121.04,56.66 121.04,56.85 v1(120.78,57.11)
  BOTTOM w0.147: R471.2 123.96,28.73 v1(124.08,28.84)
GPIO_CPSW1_RST: length 102.8
  L03_SIG1 w0.091: v1(44.83,106.57) 44.83,103.25 43.11,101.53 43.11,97.17 43.63,96.65 43.63,95.52 46.77,92.38 46.77,91.34 48.08,90.03 48.08,86.56 46.79,85.27 46.79,73.6 49.57,70.82 49.57,67.13 47,64.56 47,61.98 46.99,61.97 46.99,61.57 41.96,56.54 41.96,50.12 45.68,46.41 47.27,46.41 50.65,43.03 50.65,36.75 52.63,34.77 52.63,33.4 56,30.03 v1(56,28.86)
  BOTTOM w0.147: U91.3 v1(56,28.86) ; v1(44.83,106.57) 46.45,106.57 47.52,107.65 49.63,107.65 49.78,107.8 R241.1 R242.1 47.88,108.36 47.86,108.34 U69.1
GPIO_EMMC_RSTN: length 70.8
  TOP w0.147: v1(115.46,21.24) R196.1 115.46,22.7 115.51,22.75 U54.1
  L08_SIG2 w0.091: v1(57,28.86) 58.4,28.86 65.98,21.28 78.87,21.28 81.75,18.4 91.64,18.4 94.05,20.8 99.34,20.8 102.08,18.06 111.64,18.06 113.28,19.7 113.92,19.7 v1(115.46,21.24)
  BOTTOM w0.147: U91.1 v1(57,28.86)
GPIO_OLED_RESETN: length 62.2
  L08_SIG2 w0.091: v1(50.95,34.41) 51.39,33.97 51.39,33.7 51.5,33.59 51.5,33.23 51.39,33.12 51.39,32.7 51.5,32.59 51.5,32.23 51.39,32.12 51.39,31.7 51.5,31.59 51.5,28.19 51.31,28 51.31,24 48.64,21.34 10.27,21.34 v1(8.64,19.7)
  BOTTOM w0.147: U91.15 v1(50.95,34.41) ; v1(8.64,19.7) R531.2 8.04,18.34 8.04,18.34 8.04,18.33 8.04,18.08 7.93,17.98 7.93,17.95 7.66,17.69 6.31,17.69 6.04,17.95 6.04,17.97 5.96,18.05 5.96,18.06 5.7,18.31 J36.6
GPIO_OSPI_RSTN: length 43.5
  TOP w0.147: U23.K17 v1(92.26,71.9)
  L08_SIG2 w0.091: v1(92.26,71.9) 91.89,72.28 91.3,72.28 91.09,72.06 91.09,69.82 93.2,67.71 95.2,67.71 99.48,63.43 99.48,51.66 107.64,43.5 107.64,42.13 v1(107.99,41.79)
  BOTTOM w0.147: U85.1 R429.1 108.26,42.05 v1(107.99,41.79)
GPIO_PCIE_RST_OUT: length 30.3
  L03_SIG1 w0.091: v1(54.47,29.73) 54.47,28.7 54.1,28.34 52.5,28.34 49.7,31.13 49.7,32.22 43.19,38.73 41.03,38.73 39.02,40.74 36.55,40.74 v1(36.14,41.15)
  BOTTOM w0.147: U88.1 36.6,42.82 36.23,43.19 R424.2 R430.1 36.14,41.45 v1(36.14,41.15) ; U91.6 54.49,29.76 v1(54.47,29.73)
GPIO_RGMII1_RST: length 91.7
  TOP w0.147: U19.1 v1(25.4,90.06)
  L03_SIG1 w0.091: v1(25.4,90.06) 24.97,89.63 24.97,88.9 29.12,84.75 29.12,64.42 27.76,63.05 27.76,58.36 27.51,58.11 27.51,45.16 28.65,44.02 29.84,44.02 30.54,43.32 30.54,42.91 35.23,38.23 38.34,38.23 39.24,37.32 43.7,37.32 47.62,33.39 47.62,32.17 47.46,32 47.46,31.65 47.71,31.4 48.52,31.4 52.37,27.55 v1(56.01,27.55)
  BOTTOM w0.147: v1(56.01,27.55) 55.5,28.06 U91.4 ; R301.1 26.48,89.48 26.5,89.51 R300.1 25.44,90.1 v1(25.4,90.06)
GPIO_RGMII2_RST: length 50.4
  TOP w0.147: U31.1 30.61,58.56 v1(30.97,58.2)
  L03_SIG1 w0.091: v1(54.99,28.86) 54.21,28.08 52.44,28.08 49.48,31.04 49.48,32.12 43.1,38.51 39.08,38.51 37.07,40.51 35.81,40.51 35,41.33 33.91,41.33 30.86,44.37 30.86,50.26 30.98,50.38 30.98,50.74 30.97,50.75 v1(30.97,58.2)
  BOTTOM w0.147: R371.1 R380.1 v1(30.97,58.2) ; U91.5 v1(54.99,28.86)
GPIO_SOC/MCU: length 3.4
  TOP w0.147: U50.5 121.68,28.58 v1(121.41,28.84)
  BOTTOM w0.147: R470.1 122.4,29.35 122.41,29.34 R471.1 121.53,28.73 v1(121.41,28.84)
GPMC0_AD0: length 93.6
  TOP w0.147: v1(67.82,80.15) 67.8,80.15 67.79,80.14 RA1.9 ; J2.E14 v1(58.04,132.35)
  L03_SIG1 w0.091: v1(58.04,132.35) 58.53,132.35 58.85,132.03 58.85,128.94 58.96,128.83 59.33,128.83 59.44,128.73 59.44,128.58 59.33,128.47 58.96,128.47 58.85,128.36 58.85,128.21 58.96,128.1 59.33,128.1 59.44,128 59.44,127.84 59.33,127.74 58.96,127.74 58.85,127.63 58.85,127.48 58.96,127.37 59.33,127.37 59.44,127.26 59.44,127.11 59.33,127.01 58.96,127.01 58.85,126.9 58.85,125.75 65.22,119.38 65.22,114.66 67.89,111.98 67.89,110.62 75.39,103.12 75.39,102.62 75.28,102.51 74.02,102.51 73.91,102.4 73.91,102.25 74.02,102.14 75.28,102.14 75.39,102.04 75.39,101.89 75.28,101.78 74.02,101.78 73.91,101.67 73.91,101.52 74.02,101.41 75.28,101.41 75.39,101.31 75.39,101.15 75.28,101.05 74.02,101.05 73.91,100.94 73.91,100.79 74.02,100.68 75.28,100.68 75.39,100.57 75.39,100.42 75.28,100.32 74.02,100.32 73.91,100.21 73.91,100.06 74.02,99.95 75.36,99.95 75.56,99.75 75.56,96.93 75.41,96.77 74,96.77 73.89,96.67 73.89,96.51 74,96.41 75.28,96.41 75.39,96.3 75.39,96.15 75.28,96.04 74,96.04 73.89,95.93 73.89,95.78 74,95.68 75.28,95.68 75.39,95.57 75.39,95.42 75.28,95.31 74,95.31 73.89,95.2 73.89,95.05 74,94.94 75.28,94.94 75.39,94.84 75.39,94.69 75.28,94.58 74,94.58 73.89,94.47 73.89,94.32 74,94.21 75.28,94.21 75.39,94.11 75.39,93.95 75.28,93.85 74,93.85 73.89,93.74 73.89,93.59 74,93.48 75.28,93.48 75.39,93.37 75.39,93.17 75.12,92.9 72.43,92.9 67.82,88.29 v1(67.82,80.15)
GPMC0_AD1: length 93.9
  TOP w0.147: RA1.10 v1(67.2,80) ; J2.D14 v1(58.04,131.08)
  L03_SIG1 w0.091: v1(67.2,80) 67.2,88.1 73.51,94.41 73.51,97.52 73.61,97.62 74.26,97.62 74.37,97.73 74.37,97.88 74.26,97.99 73.61,97.99 73.51,98.1 73.51,98.25 73.61,98.36 74.26,98.36 74.37,98.46 74.37,98.61 74.26,98.72 73.61,98.72 73.51,98.83 73.51,98.98 73.61,99.09 74.26,99.09 74.37,99.19 74.37,99.35 74.26,99.45 73.61,99.45 73.51,99.56 73.51,104.39 73.31,104.59 73.16,104.59 72.22,103.65 72.06,103.65 71.96,103.76 71.96,103.91 72.9,104.85 72.9,105 72.79,105.11 72.64,105.11 71.7,104.17 71.55,104.17 71.44,104.28 71.44,104.43 72.38,105.37 72.38,105.52 72.27,105.63 72.12,105.63 71.18,104.69 71.03,104.69 70.92,104.79 70.92,104.95 71.86,105.89 71.86,106.04 71.76,106.14 71.61,106.14 70.66,105.2 70.51,105.2 70.41,105.31 70.41,105.46 71.35,106.4 71.35,106.56 71.24,106.66 71.09,106.66 70.15,105.72 70,105.72 69.89,105.83 69.89,105.98 70.83,106.92 70.83,107.07 70.72,107.18 70.57,107.18 69.63,106.24 69.48,106.24 69.37,106.35 69.37,106.5 70.31,107.44 70.31,107.59 70.2,107.7 70.05,107.7 69.11,106.76 68.96,106.76 68.86,106.86 68.86,106.99 69.79,107.92 69.79,108.11 69.27,108.63 68.94,108.63 68.08,107.77 67.92,107.77 67.82,107.88 67.82,108.03 68.68,108.89 68.68,109.04 68.57,109.15 68.42,109.15 67.56,108.29 67.41,108.29 67.3,108.39 67.3,108.54 68.16,109.41 68.16,109.56 68.06,109.67 67.91,109.67 67.04,108.8 66.89,108.8 66.78,108.91 66.78,109.06 67.65,109.93 67.65,110.08 67.49,110.24 67.49,111.84 65,114.33 65,119.35 58.47,125.87 58.47,130.65 v1(58.04,131.08)
GPMC0_AD2: length 94
  TOP w0.147: v1(66.67,80.79) 66.67,80.16 66.7,80.14 RA1.11 ; J2.C14 v1(58.04,129.81)
  L03_SIG1 w0.091: v1(66.67,80.79) 66.67,87.91 73.28,94.51 73.28,95.21 73.17,95.32 72.73,95.32 72.62,95.42 72.62,95.58 72.73,95.68 73.17,95.68 73.28,95.79 73.28,95.94 73.17,96.05 72.73,96.05 72.62,96.16 72.62,96.31 72.73,96.41 73.17,96.41 73.28,96.52 73.28,96.67 73.17,96.78 72.73,96.78 72.62,96.89 72.62,97.04 72.73,97.15 73.17,97.15 73.28,97.25 73.28,97.4 73.17,97.51 72.73,97.51 72.62,97.62 72.62,97.77 72.73,97.88 73.17,97.88 73.28,97.98 73.28,98.14 73.17,98.24 72.73,98.24 72.62,98.35 72.62,98.5 72.73,98.61 73.17,98.61 73.28,98.72 73.28,98.87 73.17,98.97 72.73,98.97 72.62,99.08 72.62,99.23 72.73,99.34 73.17,99.34 73.28,99.45 73.28,99.6 73.17,99.71 72.73,99.71 72.62,99.81 72.62,99.96 72.73,100.07 73.17,100.07 73.28,100.18 73.28,100.33 73.17,100.44 72.73,100.44 72.62,100.54 72.62,100.7 72.73,100.8 73.17,100.8 73.28,100.91 73.28,101.06 73.17,101.17 72.73,101.17 72.62,101.28 72.62,101.43 72.73,101.53 73.17,101.53 73.28,101.64 73.28,101.96 71.41,103.82 71.26,103.82 70.56,103.12 70.41,103.12 70.3,103.23 70.3,103.38 71,104.08 71,104.23 70.9,104.34 70.75,104.34 70.05,103.64 69.89,103.64 69.79,103.75 69.79,103.9 70.49,104.6 70.49,104.75 70.38,104.85 70.23,104.85 69.53,104.16 69.38,104.16 69.27,104.26 69.27,104.41 69.97,105.11 69.97,105.27 69.86,105.37 69.71,105.37 69.01,104.67 68.86,104.67 68.75,104.78 68.75,104.93 69.45,105.63 69.45,105.78 69.35,105.89 69.19,105.89 68.49,105.19 68.34,105.19 68.24,105.3 68.24,105.45 68.93,106.15 68.93,106.3 68.83,106.41 68.68,106.41 67.98,105.71 67.83,105.71 67.72,105.81 67.72,105.97 68.42,106.67 68.42,106.82 68.31,106.92 68.16,106.92 67.46,106.22 67.31,106.22 67.2,106.33 67.2,106.48 67.9,107.18 67.9,107.33 67.79,107.44 67.64,107.44 66.94,106.74 66.79,106.74 66.68,106.85 66.68,107 67.38,107.7 67.38,107.85 67.28,107.96 67.12,107.96 66.43,107.26 66.27,107.26 66.17,107.37 66.17,107.52 66.87,108.22 66.87,108.37 66.76,108.48 66.61,108.48 65.91,107.78 65.76,107.78 65.65,107.88 65.65,108.04 66.35,108.73 66.35,108.89 66.24,108.99 66.09,108.99 65.39,108.29 65.26,108.29 65.17,108.39 65.17,108.51 66.27,109.61 66.27,112.71 64.78,114.2 64.78,119.26 58.04,126 v1(58.04,129.81)
GPMC0_AD3: length 93.7
  TOP w0.147: J2.E15 v1(56.77,132.35) ; RA1.12 v1(66.2,80)
  L03_SIG1 w0.091: v1(66.2,80) 66.2,80.6 66.21,80.61 66.21,80.97 66.2,80.97 66.2,87.73 72.37,93.89 72.37,94.19 72.28,94.28 70.54,94.28 70.43,94.39 70.43,94.54 70.54,94.65 72.11,94.65 72.21,94.76 72.21,94.91 72.11,95.02 70.54,95.02 70.43,95.12 70.43,95.27 70.54,95.38 72.11,95.38 72.21,95.49 72.21,95.64 72.11,95.75 70.54,95.75 70.43,95.85 70.43,96.01 70.54,96.11 72.11,96.11 72.21,96.22 72.21,96.37 72.11,96.48 70.54,96.48 70.43,96.59 70.43,96.74 70.54,96.84 72.11,96.84 72.21,96.95 72.21,97.1 72.11,97.21 70.54,97.21 70.43,97.32 70.43,97.47 70.54,97.58 72.11,97.58 72.21,97.68 72.21,97.83 72.11,97.94 70.54,97.94 70.43,98.05 70.43,98.2 70.54,98.31 72.11,98.31 72.21,98.41 72.21,98.57 72.11,98.67 70.54,98.67 70.43,98.78 70.43,98.93 70.54,99.04 72.11,99.04 72.21,99.15 72.21,99.34 70.59,100.97 70.59,102.49 67.69,105.38 67.67,105.38 64.56,108.49 64.56,109.24 64.66,109.35 65.55,109.35 65.68,109.48 65.68,109.62 65.59,109.71 64.66,109.71 64.56,109.82 64.56,109.97 64.66,110.08 65.55,110.08 65.68,110.21 65.68,110.35 65.59,110.45 64.66,110.45 64.56,110.55 64.56,111.56 64.66,111.67 65.12,111.67 65.23,111.78 65.23,111.93 65.12,112.03 64.66,112.03 64.56,112.14 64.56,112.29 64.66,112.4 65.12,112.4 65.23,112.51 65.23,112.66 65.12,112.77 64.66,112.77 64.56,112.87 64.56,113.02 64.66,113.13 65.12,113.13 65.23,113.24 65.23,113.39 65.12,113.5 64.66,113.5 64.56,113.6 64.56,119.13 57.61,126.08 57.61,132.03 57.29,132.35 v1(56.77,132.35)
GPMC0_AD4: length 93.7
  TOP w0.147: v1(65.77,80.79) 65.77,80.21 65.7,80.14 RA1.13 ; J2.D15 v1(56.77,131.08)
  L03_SIG1 w0.091: v1(65.77,80.79) 65.77,87.61 70.21,92.04 70.21,96.98 70.1,97.09 68.26,97.09 68.15,97.2 68.15,97.35 68.26,97.46 70.1,97.46 70.21,97.56 70.21,97.72 70.1,97.82 68.26,97.82 68.15,97.93 68.15,98.08 68.26,98.19 70.1,98.19 70.21,98.3 70.21,98.45 70.1,98.56 68.26,98.56 68.15,98.66 68.15,98.81 68.26,98.92 70.1,98.92 70.21,99.03 70.21,99.23 70.1,99.34 69.3,99.34 69.19,99.45 69.19,99.6 69.3,99.71 70.1,99.71 70.21,99.81 70.21,99.96 70.1,100.07 69.3,100.07 69.19,100.18 69.19,100.33 69.3,100.44 70.1,100.44 70.21,100.54 70.21,100.7 70.1,100.8 69.3,100.8 69.19,100.91 69.19,101.06 69.3,101.17 70.1,101.17 70.21,101.28 70.21,102.44 69.92,102.73 69.77,102.73 68.37,101.33 68.22,101.33 68.11,101.44 68.11,101.59 69.51,102.98 69.51,103.14 69.4,103.24 69.25,103.24 67.85,101.85 67.7,101.85 67.59,101.95 67.59,102.1 68.99,103.5 68.99,103.65 68.88,103.76 68.73,103.76 67.33,102.36 67.18,102.36 67.08,102.47 67.08,102.62 68.47,104.02 68.47,104.17 68.37,104.28 68.21,104.28 66.84,102.91 66.71,102.91 66.59,103.04 66.59,103.17 67.96,104.54 67.96,104.69 64.33,108.31 64.33,119.04 57.38,126 57.38,130.96 57.26,131.08 v1(56.77,131.08)
GPMC0_AD5: length 95.7
  TOP w0.147: J2.C15 v1(56.77,129.81) ; RA1.14 v1(65.2,80)
  L03_SIG1 w0.091: v1(56.77,129.81) 56.34,130.24 56.34,131.51 56.25,131.6 56.02,131.6 55.93,131.51 55.93,128.75 56.04,128.64 57.07,128.64 57.18,128.54 57.18,128.38 57.07,128.28 56.04,128.28 55.93,128.17 55.93,128.02 56.04,127.91 57.07,127.91 57.18,127.8 57.18,127.65 57.07,127.55 56.04,127.55 55.93,127.44 55.93,127.29 56.04,127.18 57.07,127.18 57.18,127.07 57.18,126.92 57.07,126.81 56.04,126.81 55.93,126.71 55.93,126.56 56.04,126.45 57.07,126.45 57.18,126.34 57.18,126.19 57.07,126.08 56.04,126.08 55.93,125.98 55.93,125.82 56.04,125.72 57.07,125.72 57.18,125.61 57.18,125.46 57.07,125.35 56.04,125.35 55.93,125.24 55.93,125.09 56.04,124.98 58.09,124.98 64.11,118.96 64.11,107.53 65.41,106.24 65.41,101.15 65.54,101.02 68.32,101.02 68.43,100.91 68.43,100.76 68.32,100.65 65.5,100.65 65.41,100.56 65.41,100.42 65.54,100.28 68.32,100.28 68.43,100.18 68.43,100.03 68.32,99.92 65.5,99.92 65.41,99.83 65.41,99.68 65.51,99.58 67.76,99.58 67.87,99.47 67.87,99.32 67.76,99.21 65.51,99.21 65.41,99.1 65.41,98.95 65.51,98.85 67.76,98.85 67.87,98.74 67.87,98.59 67.76,98.48 65.65,98.48 65.56,98.39 65.56,98.09 65.65,98 67.54,98 67.94,97.59 67.94,90.1 65.21,87.36 65.21,80.61 65.2,80.6 v1(65.2,80)
GPMC0_AD6: length 93.6
  TOP w0.147: v1(64.77,80.79) 64.77,80.21 64.7,80.14 RA1.15 ; J2.E17 v1(54.23,132.35)
  L03_SIG1 w0.091: v1(64.77,80.79) 64.77,87.23 67.03,89.49 67.03,95.81 67.14,95.92 67.29,95.92 67.4,95.81 67.4,90.18 67.5,90.07 67.65,90.07 67.76,90.18 67.76,96.18 67.65,96.29 67.14,96.29 67.03,96.39 67.03,97.43 66.82,97.65 65.67,97.65 65.17,98.15 65.17,106.16 63.98,107.35 63.98,107.4 63.93,107.45 63.93,118.85 63.48,119.3 63.33,119.3 62.71,118.67 62.56,118.67 62.45,118.78 62.45,118.93 63.07,119.55 63.07,119.71 62.96,119.81 62.81,119.81 62.19,119.19 62.04,119.19 61.93,119.3 61.93,119.45 62.55,120.07 62.55,120.22 62.45,120.33 62.3,120.33 61.67,119.71 61.52,119.71 61.41,119.81 61.41,119.97 62.04,120.59 62.04,120.74 61.93,120.85 61.78,120.85 61.16,120.22 61,120.22 60.9,120.33 60.9,120.48 61.52,121.11 61.52,121.26 58.85,123.93 57.19,123.93 57.09,124.03 57.09,124.66 56.98,124.76 56.83,124.76 56.72,124.66 56.72,124.03 56.61,123.93 56.46,123.93 56.35,124.03 56.35,124.66 56.25,124.76 56.1,124.76 55.99,124.66 55.99,124.03 55.88,123.93 55.73,123.93 55.62,124.03 55.62,124.66 55.52,124.76 55.36,124.76 55.26,124.66 55.26,124.03 55.15,123.93 54.58,123.93 54.46,124.05 54.46,125.04 54.63,125.22 54.96,125.22 55.07,125.32 55.07,125.48 54.96,125.58 54.77,125.58 54.66,125.69 54.66,125.84 54.77,125.95 54.96,125.95 55.07,126.06 55.07,126.21 54.96,126.32 54.77,126.32 54.66,126.42 54.66,126.57 54.77,126.68 54.96,126.68 55.07,126.79 55.07,126.94 54.96,127.05 54.77,127.05 54.66,127.15 54.66,127.31 54.77,127.41 54.96,127.41 55.07,127.52 55.07,127.67 54.96,127.78 54.77,127.78 54.66,127.89 54.66,128.04 54.77,128.14 54.96,128.14 55.07,128.25 55.07,128.4 54.96,128.51 54.77,128.51 54.66,128.62 54.66,128.77 54.77,128.88 54.96,128.88 55.07,128.98 55.07,129.13 54.96,129.24 54.77,129.24 54.66,129.35 54.66,129.5 54.77,129.61 54.96,129.61 55.07,129.71 55.07,129.87 54.96,129.97 54.77,129.97 54.66,130.08 54.66,130.23 54.77,130.34 54.96,130.34 55.07,130.45 55.07,130.6 54.96,130.7 54.77,130.7 54.66,130.81 54.66,130.96 54.77,131.07 54.96,131.07 55.07,131.18 55.07,131.33 54.96,131.44 54.77,131.44 54.66,131.54 54.66,132.26 54.57,132.35 v1(54.23,132.35)
GPMC0_AD7: length 93.9
  TOP w0.147: RA1.16 v1(64.11,80) ; J2.D17 v1(54.23,131.08)
  L03_SIG1 w0.091: v1(54.23,131.08) 53.67,130.52 53.67,123.92 55.06,122.53 55.31,122.53 55.42,122.64 55.42,123.49 55.53,123.6 55.68,123.6 55.79,123.49 55.79,122.64 55.89,122.53 56.05,122.53 56.15,122.64 56.15,123.49 56.26,123.6 56.41,123.6 56.52,123.49 56.52,122.64 56.63,122.53 56.78,122.53 56.88,122.64 56.88,123.49 56.99,123.6 57.14,123.6 57.25,123.49 57.25,122.64 57.36,122.53 57.51,122.53 57.62,122.64 57.62,123.49 57.72,123.6 57.87,123.6 57.98,123.49 57.98,122.64 58.09,122.53 58.39,122.53 58.53,122.39 58.69,122.39 59.32,123.02 59.47,123.02 59.58,122.92 59.58,122.77 58.94,122.13 58.94,121.98 59.05,121.87 59.2,121.87 59.84,122.51 59.99,122.51 60.1,122.4 60.1,122.25 59.46,121.61 59.46,121.46 59.57,121.35 59.72,121.35 60.36,121.99 60.51,121.99 60.62,121.88 60.62,121.73 59.98,121.1 59.98,120.94 63.67,117.25 63.67,107.34 64.8,106.22 64.8,91.75 64.9,91.64 66.14,91.64 66.24,91.53 66.24,91.38 66.14,91.27 64.9,91.27 64.8,91.16 64.8,91.01 64.9,90.91 66.14,90.91 66.24,90.8 66.24,90.65 66.14,90.54 64.9,90.54 64.8,90.43 64.8,90.28 64.9,90.17 66.14,90.17 66.24,90.07 66.24,89.92 66.14,89.81 64.9,89.81 64.8,89.7 64.8,87.57 64.11,86.89 64.11,85.65 64.01,85.54 63.18,85.54 63.07,85.44 63.07,85.28 63.18,85.18 64.01,85.18 64.11,85.07 64.11,84.92 64.01,84.81 63.18,84.81 63.07,84.7 63.07,84.55 63.18,84.45 64.01,84.45 64.11,84.34 64.11,84.19 64.01,84.08 63.18,84.08 63.07,83.97 63.07,83.82 63.18,83.71 64.01,83.71 64.11,83.61 64.11,83.45 64.01,83.35 63.18,83.35 63.07,83.24 63.07,83.09 63.18,82.98 64.01,82.98 64.11,82.87 64.11,82.72 64.01,82.62 63.18,82.62 63.07,82.51 63.07,82.36 63.18,82.25 64.01,82.25 64.11,82.14 64.11,81.99 64.01,81.88 63.18,81.88 63.07,81.78 63.07,81.63 63.18,81.52 64.01,81.52 64.11,81.41 64.11,81.26 64.01,81.15 63.18,81.15 63.07,81.05 63.07,80.89 63.18,80.79 64.01,80.79 64.11,80.68 v1(64.11,80)
GPMC0_AD8: length 14
  TOP w0.147: J2.A22 47.24,124.6 50.57,121.27 56.57,121.27 57.04,120.81 U8.23
GPMC0_AD8/FSI_RX0_CLK: length 93.8
  TOP w0.147: v1(75.17,64.53) 75.15,64.52 RA3.9 ; U8.1 v1(54.99,119.37)
  L03_SIG1 w0.091: v1(54.99,119.37) 53.18,119.37 52.83,119.02 52.83,114.72 55.21,112.34 55.21,102.95 55.32,102.84 55.95,102.84 56.06,102.73 56.06,102.58 55.95,102.47 55.32,102.47 55.21,102.37 55.21,102.21 55.32,102.11 55.95,102.11 56.06,102 56.06,101.85 55.95,101.74 55.32,101.74 55.21,101.63 55.21,100.44 55.72,99.93 55.72,96.44 54.98,95.7 54.98,95.48 55.09,95.37 56.41,95.37 56.52,95.26 56.52,95.11 56.41,95 55.09,95 54.98,94.9 54.98,94.75 55.09,94.64 56.41,94.64 56.52,94.53 56.52,94.38 56.41,94.27 55.09,94.27 54.98,94.17 54.98,94.01 55.09,93.91 56.41,93.91 56.52,93.8 56.52,93.65 56.41,93.54 55.09,93.54 54.98,93.43 54.98,93.28 55.09,93.18 56.41,93.18 56.52,93.07 56.52,92.92 56.41,92.81 55.09,92.81 54.98,92.7 54.98,92.55 55.09,92.44 56.41,92.44 56.52,92.34 56.52,92.19 56.41,92.08 55.09,92.08 54.98,91.97 54.98,77.8 61.19,71.59 66.48,71.59 67.13,70.94 67.13,70.3 69.41,68.02 69.41,65.97 69.18,65.74 69.18,64.31 70.71,62.78 73.87,62.78 75.17,64.08 v1(75.17,64.53)
GPMC0_AD9: length 13.3
  TOP w0.147: U8.22 57.54,121.14 57.11,121.57 51.77,121.57 48.51,124.82 J2.A21
GPMC0_AD9/FSI_RX0_D0: length 93.9
  TOP w0.147: RA3.10 74.57,64.29 74.62,64.34 74.62,65 v1(75.17,65.55) ; U8.3 v1(55,118.37)
  L03_SIG1 w0.091: v1(75.17,65.55) 74.6,64.98 74.6,63.95 73.65,63 70.8,63 69.4,64.4 69.4,65.65 69.63,65.87 69.63,68.69 68.14,70.17 68.14,71.44 67.78,71.81 61.32,71.81 56.74,76.38 56.74,78 55.47,79.27 55.47,80.11 55.57,80.2 56.5,80.2 56.59,80.3 56.59,80.48 56.5,80.57 55.57,80.57 55.47,80.66 55.47,80.84 55.57,80.94 56.5,80.94 56.59,81.03 56.59,81.21 56.5,81.3 55.57,81.3 55.47,81.39 55.47,81.58 55.57,81.67 56.5,81.67 56.59,81.76 56.59,81.94 56.5,82.03 55.57,82.03 55.47,82.13 55.47,82.31 55.57,82.4 56.5,82.4 56.59,82.49 56.59,82.67 56.5,82.77 55.57,82.77 55.47,82.86 55.47,83.04 55.57,83.13 56.5,83.13 56.59,83.22 56.59,83.41 56.5,83.5 55.57,83.5 55.47,83.59 55.47,83.77 55.57,83.86 56.5,83.86 56.59,83.95 56.59,84.14 56.5,84.23 55.57,84.23 55.47,84.32 55.47,84.5 55.57,84.59 56.5,84.59 56.59,84.69 56.59,84.87 56.5,84.96 55.57,84.96 55.47,85.05 55.47,85.37 56.03,85.93 56.03,89.97 57.3,91.24 57.3,91.94 56.85,92.39 56.85,99.62 56.21,100.25 56.21,101.58 56.55,101.92 56.55,107.16 55.63,108.09 55.63,112.23 53.05,114.81 53.05,118.58 53.29,118.82 54.55,118.82 v1(55,118.37)
GPMC0_AD10: length 15.2
  TOP w0.147: U8.20 58.53,121.24 57.91,121.86 52.22,121.86 49.12,124.96 49.12,127.29 J2.B21
GPMC0_AD10/FSI_RX0_D1: length 95.1
  TOP w0.147: v1(74.17,64.53) 74.07,64.43 RA3.11 ; v1(53.98,118.38) 54.48,117.87 U8.4
  L03_SIG1 w0.091: v1(53.98,118.38) 53.98,116.53 53.7,116.26 53.7,114.47 56.77,111.4 56.77,111.11 56.67,111 56.01,111 55.91,110.9 55.91,110.75 56.01,110.64 56.67,110.64 56.77,110.53 56.77,110.38 56.67,110.27 56.01,110.27 55.91,110.17 55.91,110.01 56.01,109.91 56.67,109.91 56.77,109.8 56.77,109.65 56.67,109.54 56.01,109.54 55.91,109.43 55.91,109.28 56.01,109.18 56.67,109.18 56.77,109.07 56.77,102.01 58.01,100.77 58.01,100.49 57.9,100.38 57.36,100.38 57.25,100.28 57.25,100.12 57.36,100.02 57.9,100.02 58.01,99.91 58.01,99.76 57.9,99.65 57.36,99.65 57.25,99.54 57.25,99.39 57.36,99.29 57.9,99.29 58.01,99.18 58.01,99.03 57.9,98.92 57.36,98.92 57.25,98.81 57.25,98.66 57.36,98.55 57.9,98.55 58.01,98.45 58.01,98.3 57.9,98.19 57.36,98.19 57.25,98.08 57.25,97.93 57.36,97.82 57.9,97.82 58.01,97.72 58.01,97.56 57.9,97.46 57.36,97.46 57.25,97.35 57.25,97.2 57.36,97.09 57.9,97.09 58.01,96.98 58.01,91.51 56.96,90.47 56.96,90.2 57.07,90.09 57.98,90.09 58.09,89.98 58.09,89.83 57.98,89.72 57.07,89.72 56.96,89.62 56.96,89.47 57.07,89.36 57.98,89.36 58.09,89.25 58.09,89.1 57.98,88.99 57.07,88.99 56.96,88.89 56.96,88.73 57.07,88.63 57.98,88.63 58.09,88.52 58.09,88.37 57.98,88.26 57.07,88.26 56.96,88.15 56.96,88 57.07,87.89 57.98,87.89 58.09,87.79 58.09,87.64 57.98,87.53 57.07,87.53 56.96,87.42 56.96,87.27 57.07,87.16 57.98,87.16 58.09,87.06 58.09,86.9 57.98,86.8 57.07,86.8 56.96,86.69 56.96,76.47 61.41,72.03 68.48,72.03 69.09,71.42 69.09,70.37 69.85,69.61 69.85,65.78 69.62,65.56 69.62,64.76 71.16,63.22 73.3,63.22 74.17,64.09 v1(74.17,64.53)
GPMC0_AD11: length 94.5
  TOP w0.147: RA3.12 73.57,64.3 73.61,64.34 73.61,64.99 v1(74.17,65.55) ; J2.E21 v1(49.15,132.35)
  L03_SIG1 w0.091: v1(49.15,132.35) 48.34,131.54 48.34,124.68 52.31,120.7 52.31,114.92 54.99,112.24 54.99,100.53 54.99,100.35 55.5,99.84 55.5,96.53 54.76,95.8 54.76,77.71 61.1,71.37 65.51,71.37 65.97,70.91 65.97,70.44 68.33,68.09 68.33,66.44 68.96,65.8 68.96,64.13 70.08,63.01 70.08,62.99 70.51,62.56 73.97,62.56 75.6,64.19 75.6,65.73 75.35,65.98 74.6,65.98 v1(74.17,65.55)
GPMC0_AD12: length 93.7
  TOP w0.147: J2.C21 v1(49.15,129.81) ; v1(73.15,64.53) 73.07,64.44 RA3.13
  L03_SIG1 w0.091: v1(73.15,64.53) 73.15,64.09 72.72,63.66 71.66,63.66 70.96,64.36 70.96,66.04 70.31,66.69 70.31,70.83 68.66,72.49 61.72,72.49 57.45,76.76 57.45,84.63 60.96,88.14 60.96,96.98 58.71,99.24 58.71,100.7 57.22,102.19 57.22,111.58 54.81,113.99 54.81,116.53 55.7,117.42 55.7,119.91 51.51,124.1 50.11,124.1 49.15,125.07 49.15,126.52 49.26,126.63 49.91,126.63 50.01,126.73 50.01,126.89 49.91,126.99 49.26,126.99 49.15,127.1 49.15,127.25 49.26,127.36 49.91,127.36 50.01,127.47 50.01,127.62 49.91,127.72 49.26,127.72 49.15,127.83 49.15,127.98 49.26,128.09 49.91,128.09 50.01,128.2 50.01,128.35 49.91,128.46 49.26,128.46 49.15,128.56 49.15,128.71 49.26,128.82 49.91,128.82 50.01,128.93 50.01,129.08 49.91,129.19 49.26,129.19 49.15,129.29 v1(49.15,129.81)
GPMC0_AD13: length 94.2
  TOP w0.147: v1(73.15,65.55) 72.58,64.97 72.58,64.3 72.57,64.29 RA3.14 ; J2.D21 v1(49.15,131.08)
  L03_SIG1 w0.091: v1(49.15,131.08) 48.52,130.45 48.52,124.83 52.07,121.27 54.08,121.27 55.5,119.85 55.5,117.74 53.92,116.16 53.92,114.57 57,111.49 57,102.1 58.49,100.61 58.49,99.15 60.74,96.89 60.74,88.58 57.19,85.02 57.19,76.56 61.5,72.25 68.59,72.25 70.07,70.77 70.07,66.56 70.69,65.94 70.69,64.07 71.32,63.44 73.2,63.44 73.59,63.83 73.59,65.11 v1(73.15,65.55)
GPMC0_AD14: length 15.8
  TOP w0.147: J2.B20 50.47,127.22 50.47,125.12 53.14,122.45 58.44,122.45 59.83,121.05 U8.18
GPMC0_AD14/FSI_TX0_D0: length 93.6
  TOP w0.147: RA3.15 72.07,64.33 72.12,64.39 v1(72.12,64.41) ; U8.6 55.74,116.46 v1(55.24,115.97)
  L03_SIG1 w0.091: v1(72.12,64.41) 72.43,64.72 72.43,66.25 70.69,67.99 70.69,71.07 68.34,73.42 62.48,73.42 59.77,76.14 59.77,76.74 59.87,76.84 60.37,76.84 60.48,76.95 60.48,77.1 60.37,77.21 59.87,77.21 59.77,77.32 59.77,77.47 59.87,77.57 60.37,77.57 60.48,77.68 60.48,77.83 60.37,77.94 59.87,77.94 59.77,78.05 59.77,78.2 59.87,78.31 60.37,78.31 60.48,78.41 60.48,78.56 60.37,78.67 59.87,78.67 59.77,78.78 59.77,78.93 59.87,79.04 60.37,79.04 60.48,79.14 60.48,79.3 60.37,79.4 59.87,79.4 59.77,79.51 59.77,79.66 59.87,79.77 60.37,79.77 60.48,79.88 60.48,80.03 60.37,80.13 59.87,80.13 59.77,80.24 59.77,80.39 59.87,80.5 60.37,80.5 60.48,80.61 60.48,80.76 60.37,80.87 59.87,80.87 59.77,80.97 59.77,81.12 59.87,81.23 60.37,81.23 60.48,81.34 60.48,81.49 60.37,81.6 59.87,81.6 59.77,81.7 59.77,81.86 59.87,81.96 60.37,81.96 60.48,82.07 60.48,82.22 60.37,82.33 59.87,82.33 59.77,82.44 59.77,82.59 59.87,82.69 60.37,82.69 60.48,82.8 60.48,82.95 60.37,83.06 59.87,83.06 59.77,83.17 59.77,83.32 59.87,83.43 60.37,83.43 60.48,83.53 60.48,83.68 60.37,83.79 59.87,83.79 59.77,83.9 59.77,84.05 59.87,84.16 60.37,84.16 60.48,84.26 60.48,84.42 60.37,84.52 59.87,84.52 59.77,84.63 59.77,84.78 59.87,84.89 60.37,84.89 60.48,85 60.48,85.15 60.37,85.25 59.87,85.25 59.77,85.36 59.77,85.9 61.4,87.54 61.4,96.62 61.4,97.36 60.02,98.75 60.02,100.02 57.66,102.38 57.66,111.79 56.97,112.48 56.97,113.41 57.28,113.72 57.28,114.24 57.38,114.35 57.83,114.35 57.94,114.46 57.94,114.61 57.83,114.72 57.38,114.72 57.28,114.82 57.28,114.98 57.38,115.08 57.83,115.08 57.94,115.19 57.94,115.34 57.83,115.45 57.38,115.45 57.28,115.56 57.28,115.71 57.38,115.81 57.83,115.81 57.94,115.92 57.94,116.07 57.83,116.18 57.38,116.18 57.28,116.29 57.28,120.93 57.18,121.03 56.21,121.03 56.08,120.9 56.08,116.76 55.29,115.97 v1(55.24,115.97)
GPMC0_AD15: length 19.1
  TOP w0.147: U8.16 61.89,118.37 62.47,118.95 62.47,120.4 60.12,122.75 53.57,122.75 51.05,125.26 J2.A19
GPMC0_AD15/FSI_TX0_D1: length 93.6
  TOP w0.147: v1(71.63,65.04) 71.63,64.44 71.48,64.29 RA3.16 ; U8.7 v1(56.54,115.33)
  L03_SIG1 w0.091: v1(71.63,65.04) 71.19,65.48 71.19,66.17 70.51,66.85 70.51,70.97 68.28,73.2 66.99,73.2 66.88,73.09 66.88,72.88 66.77,72.77 66.62,72.77 66.51,72.88 66.51,73.09 66.41,73.2 66.25,73.2 66.15,73.09 66.15,72.88 66.04,72.77 65.89,72.77 65.78,72.88 65.78,73.09 65.67,73.2 65.52,73.2 65.42,73.09 65.42,72.88 65.31,72.77 65.16,72.77 65.05,72.88 65.05,73.09 64.94,73.2 64.79,73.2 64.68,73.09 64.68,72.88 64.58,72.77 64.42,72.77 64.32,72.88 64.32,73.09 64.21,73.2 64.06,73.2 63.95,73.09 63.95,72.88 63.84,72.77 63.69,72.77 63.59,72.88 63.59,73.09 63.48,73.2 62.44,73.2 57.81,77.83 57.81,78.31 57.92,78.42 59.41,78.42 59.51,78.52 59.51,78.68 59.41,78.78 57.92,78.78 57.81,78.89 57.81,79.04 57.92,79.15 59.41,79.15 59.51,79.26 59.51,79.41 59.41,79.51 57.92,79.51 57.81,79.62 57.81,79.77 57.92,79.88 59.41,79.88 59.51,79.99 59.51,80.14 59.41,80.25 57.92,80.25 57.81,80.35 57.81,80.5 57.92,80.61 59.41,80.61 59.51,80.72 59.51,80.87 59.41,80.98 57.92,80.98 57.81,81.08 57.81,81.24 57.92,81.34 59.41,81.34 59.51,81.45 59.51,81.6 59.41,81.71 57.92,81.71 57.81,81.82 57.81,81.97 57.92,82.07 59.41,82.07 59.51,82.18 59.51,82.33 59.41,82.44 57.92,82.44 57.81,82.55 57.81,82.7 57.92,82.81 59.41,82.81 59.51,82.91 59.51,83.06 59.41,83.17 57.92,83.17 57.81,83.28 57.81,83.43 57.92,83.54 59.41,83.54 59.51,83.64 59.51,83.8 59.41,83.9 57.92,83.9 57.81,84.01 57.81,84.43 61.18,87.8 61.18,96.71 61.18,96.71 61.18,97.08 61.18,97.27 59.79,98.66 59.79,99.93 57.44,102.29 57.44,111.7 55.93,113.21 55.93,114.73 v1(56.54,115.33)
GPMC0_ADVN_ALE: length 56.8
  TOP w0.147: U23.P16 v1(88.26,72.7)
  L08_SIG2 w0.091: v1(83.31,59.7) 82.49,59.7 82.23,59.45 82.23,58.66 82.65,58.25 83.83,58.25 84.22,58.64 84.22,59.85 84.68,60.31 85.48,60.31 86.12,60.95 87.54,60.95 87.69,61.1 87.69,61.2 87.59,61.29 85.22,61.29 85.13,61.38 85.13,61.54 85.22,61.63 87.59,61.63 87.69,61.73 87.69,61.89 87.59,61.98 85.22,61.98 85.13,62.07 85.13,62.23 85.22,62.33 87.59,62.33 87.69,62.42 87.69,62.58 87.59,62.67 85.22,62.67 85.13,62.76 85.13,62.92 85.22,63.02 87.59,63.02 87.8,63.22 87.8,63.73 88.36,64.29 88.36,64.78 88.24,64.91 86.94,64.91 86.85,65 86.85,65.16 86.94,65.25 88.24,65.25 88.33,65.34 88.33,65.58 88.24,65.67 87.7,65.67 87.62,65.75 87.62,66.21 87.54,66.29 87.43,66.29 87.35,66.21 87.35,65.75 87.27,65.67 87.04,65.67 86.95,65.76 86.95,65.98 86.86,66.07 85.6,66.07 85.51,66.16 85.51,66.33 85.6,66.42 86.86,66.42 86.95,66.51 86.95,66.67 86.86,66.76 85.6,66.76 85.51,66.86 85.51,67.02 85.6,67.11 86.86,67.11 86.95,67.2 86.95,67.73 87.04,67.82 87.39,67.82 87.48,67.73 87.48,66.92 87.57,66.83 87.73,66.83 87.83,66.92 87.83,67.73 87.92,67.82 88.38,67.82 88.47,67.91 88.47,68.07 88.38,68.17 87.04,68.17 86.95,68.26 86.95,68.42 87.04,68.51 88.38,68.51 88.47,68.6 88.47,68.76 88.38,68.86 87.55,68.86 87.46,68.95 87.46,69.15 87.55,69.24 87.73,69.24 87.86,69.37 87.86,72.31 v1(88.26,72.7)
  BOTTOM w0.147: RA5.7 83.31,61.47 v1(83.31,59.7) 83.31,59.18 RA6.2
GPMC0_BE0N_CLE: length 56.9
  TOP w0.147: U23.P17 v1(88.26,71.9)
  L08_SIG2 w0.091: v1(88.26,71.9) 88.67,71.49 88.67,69.79 88.78,69.68 89.59,69.68 89.68,69.59 89.68,69.43 89.59,69.34 88.76,69.34 88.67,69.25 88.67,69.1 88.78,68.99 89.59,68.99 89.68,68.9 89.68,68.74 89.59,68.65 88.76,68.65 88.67,68.56 88.67,68.41 88.76,68.32 89.32,68.32 89.41,68.23 89.41,68.07 89.32,67.97 88.82,67.97 88.73,67.88 88.73,67.66 88.82,67.57 89.39,67.57 89.51,67.45 89.51,67.32 89.42,67.23 88.82,67.23 88.73,67.14 88.73,66.63 88.56,66.47 88.56,65.64 88.66,65.55 89.35,65.55 89.44,65.46 89.44,65.29 89.35,65.2 88.66,65.2 88.56,65.11 88.56,63.77 88.66,63.68 89.63,63.68 89.72,63.77 89.72,65.23 89.81,65.32 89.97,65.32 90.07,65.23 90.07,63.77 90.16,63.68 91.18,63.68 91.29,63.57 91.29,63.44 91.18,63.33 88.27,63.33 88.18,63.24 88.18,63.08 88.27,62.98 90.67,62.98 90.76,62.89 90.76,62.73 90.67,62.64 88.27,62.64 88.18,62.55 88.18,62.39 88.27,62.29 90.42,62.29 90.51,62.2 90.51,62.04 90.42,61.95 89.99,61.95 89.9,61.86 89.9,61.43 89.81,61.34 89.65,61.34 89.55,61.43 89.55,61.86 89.46,61.95 89.3,61.95 89.21,61.86 89.21,61.43 89.12,61.34 88.96,61.34 88.86,61.43 88.86,61.86 88.77,61.95 88.66,61.95 88.56,61.86 88.56,61.49 88.46,61.38 88.07,61.38 87.98,61.29 87.98,61.14 88.07,61.05 88.61,61.05 88.7,60.96 88.7,59.79 88.61,59.7 87.78,59.7 87.55,59.93 87.29,59.93 87.2,60.03 87.2,60.19 87.29,60.28 87.55,60.28 87.64,60.37 87.64,60.52 87.51,60.64 86.17,60.64 85.43,59.89 85.43,59.87 85.42,59.86 85.42,59.31 85.64,59.09 85.64,58.96 85.55,58.87 85.55,58.74 85.66,58.62 85.79,58.62 85.89,58.72 86.01,58.72 86.21,58.52 86.21,58.13 86.12,58.04 85.42,58.04 85.33,58.13 85.33,58.99 85.24,59.09 85.07,59.09 84.98,58.99 84.98,58.13 84.89,58.04 84.58,58.04 84.49,58.13 84.49,59.59 84.78,59.88 v1(84.86,59.88)
  BOTTOM w0.147: RA5.4 84.83,60.96 84.83,60.96 84.83,60.37 84.86,60.34 v1(84.86,59.88) 84.83,59.85 84.83,59.16 RA6.5
GPMC0_BE1N: length 56.9
  TOP w0.147: U23.T19 v1(86.66,70.3)
  L08_SIG2 w0.091: v1(85.34,60.85) 85.04,60.54 84.61,60.54 84.07,60.01 83.64,60.01 83.36,60.29 83.36,60.92 83.27,61.02 82.63,61.02 82.38,60.77 82.38,60.52 81.76,59.9 81.76,58.62 82.74,57.64 89.29,57.64 90.36,58.71 90.36,59.58 90.72,59.94 91.48,59.94 91.57,59.85 91.57,59.69 91.66,59.6 91.82,59.6 91.91,59.69 91.91,59.85 92,59.94 93.35,59.94 93.66,59.63 93.66,56.34 93.18,55.87 89.78,55.87 88.63,54.71 84.52,54.71 80.43,58.8 80.43,63.23 86.66,69.46 v1(86.66,70.3)
  BOTTOM w0.147: RA5.3 85.34,61.48 v1(85.34,60.85) 85.34,59.17 RA6.6
GPMC0_CLK: length 56
  TOP w0.147: U23.R17 v1(87.46,71.9)
  L08_SIG2 w0.091: v1(87.46,71.9) 87.46,71.63 87.03,71.2 87.03,70.96 86.99,70.92 86.99,70.86 86.81,70.68 86.5,70.68 86.23,70.4 86.23,70.15 86.05,69.97 86.05,69.17 80.25,63.36 80.25,58.72 84.44,54.53 88.71,54.53 89.87,55.69 93.89,55.69 94.28,56.08 94.28,59.74 93.88,60.15 90.67,60.15 90.18,59.66 90.18,58.8 89.22,57.84 82.79,57.84 81.94,58.7 81.94,59.73 v1(82.8,60.59)
  BOTTOM w0.147: RA6.1 82.75,60.08 82.8,60.14 v1(82.8,60.59) 82.78,60.62 82.78,61.46 RA5.8
GPMC0_CSN0: length 54.5
  TOP w0.147: U23.R19 v1(87.46,70.3)
  L08_SIG2 w0.091: v1(92.08,58.55) 91.44,59.18 91.06,59.18 90.81,58.93 90.81,57.83 88.73,55.75 87.79,55.75 87.41,56.13 87.41,56.94 87.33,57.02 87.22,57.02 87.14,56.94 87.14,56.04 87.06,55.96 85.65,55.96 85.45,55.75 83.99,55.75 83.9,55.84 83.9,55.96 84.21,56.26 84.21,56.38 84.13,56.46 84.02,56.46 83.71,56.15 83.59,56.15 83.51,56.23 83.51,56.34 83.82,56.65 83.82,56.77 83.74,56.85 83.63,56.85 83.32,56.54 83.21,56.54 83.13,56.62 83.13,56.73 83.43,57.04 83.43,57.15 83.35,57.23 83.24,57.23 82.93,56.93 82.82,56.93 81.39,58.35 81.39,60.8 81.47,60.88 81.47,61.23 80.8,61.9 80.8,63.02 80.94,63.16 81.05,63.16 81.95,62.26 82.07,62.26 82.15,62.34 82.15,62.45 81.24,63.36 81.24,63.47 81.32,63.55 81.44,63.55 82.34,62.64 82.46,62.64 82.54,62.72 82.54,62.84 81.63,63.74 81.63,63.86 81.71,63.94 81.82,63.94 82.73,63.03 82.84,63.03 82.92,63.11 82.92,63.23 82.02,64.13 82.02,64.25 83.07,65.3 83.18,65.3 83.77,64.71 83.89,64.71 83.97,64.79 83.97,64.9 83.38,65.49 83.38,65.61 83.46,65.69 83.57,65.69 84.16,65.1 84.27,65.1 84.36,65.18 84.36,65.29 83.77,65.88 83.77,65.99 83.85,66.07 83.96,66.07 84.55,65.49 84.66,65.49 84.74,65.57 84.74,65.68 84.17,66.25 84.17,66.37 84.39,66.59 84.51,66.59 85.02,66.08 85.13,66.08 85.21,66.16 85.21,66.28 84.7,66.79 84.7,66.9 85.61,67.81 85.72,67.81 86.17,67.36 86.29,67.36 86.37,67.44 86.37,67.56 85.92,68.01 85.92,68.12 86,68.2 86.11,68.2 86.56,67.75 86.67,67.75 86.75,67.83 86.75,67.95 86.31,68.39 86.31,68.51 87.46,69.66 v1(87.46,70.3)
  BOTTOM w0.147: R391.1 R390.1 91.94,58.41 v1(92.08,58.55)
GPMC0_CSN1: length 103
  TOP w0.147: J2.E19 v1(51.69,132.35) ; U23.R20 88.26,69.5 88.26,67.83 86.42,65.99 v1(86.42,65.19)
  L03_SIG1 w0.091: v1(86.42,65.19) 86.42,65.85 85.36,66.91 76.48,66.91 75.19,68.2 74.09,68.2 72.85,69.44 72.85,72.92 71.27,74.5 63.2,74.5 61.54,76.16 61.54,85.25 64.14,87.85 64.14,105.94 63.01,107.07 63.01,117.1 58.22,121.89 54.46,121.89 52.15,124.2 52.15,131.89 v1(51.69,132.35)
GPMC0_CSN2: length 98
  TOP w0.147: J2.D18 v1(52.96,131.08) ; U23.P19 v1(88.26,70.3)
  L03_SIG1 w0.091: v1(52.96,131.08) 52.33,130.45 52.33,124.28 54.44,122.16 58.24,122.16 63.23,117.18 63.23,107.16 64.34,106.05 64.34,87.74 62.59,85.99 62.59,75.56 63.43,74.72 72.34,74.72 73.74,73.33 73.74,71.71 73.9,71.54 73.9,69.56 75.08,68.38 75.27,68.38 76.52,67.13 85.53,67.13 88.26,69.87 v1(88.26,70.3)
GPMC0_CSN3: length 100.3
  TOP w0.147: v1(85.33,65.42) 87.86,67.95 U23.R21 ; J2.D19 v1(51.69,131.08)
  L03_SIG1 w0.091: v1(85.33,65.42) 84.06,66.69 76.44,66.69 75.12,68.01 73.26,68.01 72.62,68.65 72.62,72.46 70.8,74.28 63.11,74.28 61.32,76.07 61.32,85.35 63.93,87.96 63.93,105.83 61.98,107.79 61.98,117.78 58.05,121.71 54.29,121.71 50.85,125.15 50.85,130.24 v1(51.69,131.08)
GPMC0_DIR: length 100
  TOP w0.147: U23.N17 v1(89.06,71.9) ; J2.E18 v1(52.96,132.35)
  L03_SIG1 w0.091: v1(52.96,132.35) 53.42,131.89 53.42,123.84 54.91,122.35 58.32,122.35 63.45,117.21 63.45,107.25 64.54,106.16 64.54,87.63 62.81,85.9 62.81,75.65 63.52,74.94 72.5,74.94 73.94,73.51 73.94,71.76 74.08,71.62 74.08,69.74 75.26,68.56 75.34,68.56 76.55,67.36 85.07,67.36 87.86,70.14 87.86,71.27 88.09,71.5 88.66,71.5 v1(89.06,71.9)
GPMC0_OEN_REN: length 56.9
  TOP w0.147: U23.R18 v1(87.46,71.1)
  L08_SIG2 w0.091: v1(83.82,60.47) 83.82,62.03 83.36,62.48 82.68,62.48 82.23,62.04 82.23,61.02 81.57,60.36 81.57,58.54 82.69,57.43 89.69,57.43 90.54,58.28 90.54,58.92 91.04,59.42 92.51,59.42 92.74,59.18 92.74,57.56 92.65,57.47 91.13,57.47 88.58,54.92 87.89,54.92 87.8,55.02 87.8,55.49 87.7,55.58 87.54,55.58 87.45,55.49 87.45,55.02 87.36,54.92 87.2,54.92 87.11,55.02 87.11,55.49 87.01,55.58 86.85,55.58 86.76,55.49 86.76,55.02 86.67,54.92 84.56,54.92 80.61,58.87 80.61,63.1 87.09,69.57 87.09,70.64 87.2,70.75 87.2,70.84 v1(87.46,71.1)
  BOTTOM w0.147: RA6.3 83.82,59.17 v1(83.82,60.47) 83.82,61.48 RA5.6
GPMC0_WAIT0: length 56.9
  TOP w0.147: U23.W19 v1(84.26,70.3)
  L08_SIG2 w0.091: v1(85.85,59.72) 85.85,59.14 86.34,58.64 89.61,58.64 89.95,58.99 89.95,60.66 90.36,61.07 92.35,61.07 92.99,61.71 94.03,61.71 94.97,60.77 94.97,59.98 95.22,59.73 96.02,59.73 97.07,58.67 97.07,57.54 93.88,54.35 92.62,54.35 92.53,54.44 92.53,54.58 92.44,54.68 92.28,54.68 92.19,54.58 92.19,54.44 92.1,54.35 91.93,54.35 91.84,54.44 91.84,54.58 91.75,54.68 91.59,54.68 91.5,54.58 91.5,54.44 91.4,54.35 91.24,54.35 91.15,54.44 91.15,54.58 91.06,54.68 90.9,54.68 90.8,54.58 90.8,54.44 90.71,54.35 84.36,54.35 80.04,58.67 80.04,64.62 81.2,65.78 82.29,65.78 85.47,68.96 85.47,69.72 85.26,69.93 84.63,69.93 v1(84.26,70.3)
  BOTTOM w0.147: RA5.2 85.85,61.47 v1(85.85,59.72) 85.85,59.18 RA6.7
GPMC0_WAIT1: length 56.8
  TOP w0.147: U23.Y18 v1(83.46,71.1)
  L08_SIG2 w0.091: v1(86.49,60.21) 86.49,59.12 86.78,58.83 89.53,58.83 89.77,59.07 89.77,60.75 90.31,61.29 92.31,61.29 92.92,61.89 94.49,61.89 97.52,58.87 97.52,57.72 93.96,54.16 84.29,54.16 79.86,58.59 79.86,64.69 81.14,65.98 81.99,65.98 84.96,68.96 84.96,69.47 84.7,69.73 84.31,69.73 83.89,70.15 83.89,70.68 v1(83.46,71.1)
  BOTTOM w0.147: RA6.8 86.42,59.64 86.49,59.7 v1(86.49,60.21) 86.49,60.9 86.42,60.96 RA5.1
GPMC0_WEN: length 58.1
  TOP w0.147: v1(84.33,60.9) 84.33,58.76 84.18,58.61 82.63,58.61 82.52,58.49 82.52,58.33 82.63,58.21 84.21,58.21 84.33,58.09 84.33,57.93 84.21,57.81 82.63,57.81 82.52,57.69 82.52,57.53 82.63,57.41 84.21,57.41 84.33,57.29 84.33,57.12 84.21,57.01 82.63,57.01 82.52,56.89 82.52,56.72 82.63,56.61 84.21,56.61 84.33,56.49 84.33,56.32 84.21,56.2 82.63,56.2 82.52,56.09 82.52,55.92 82.63,55.8 84.21,55.8 84.33,55.69 84.33,55.52 84.21,55.4 82.63,55.4 82.52,55.28 82.52,55.12 82.63,55 84.21,55 84.33,54.88 84.33,54.72 84.21,54.6 82.63,54.6 82.52,54.48 82.52,54.32 82.63,54.2 84.21,54.2 84.33,54.08 84.33,52.73 84.1,52.5 79.61,52.5 78.59,53.52 78.59,59.14 79.27,59.82 79.27,64.03 80.14,64.89 83.92,64.89 87.06,68.02 U23.T21
  BOTTOM w0.147: RA5.5 84.33,61.49 84.33,60.9 v1(84.33,60.9) 84.33,60.39 84.33,60.39 RA6.4
GPMC0_WPN: length 54.4
  TOP w0.147: U23.N16 v1(89.06,72.7)
  L08_SIG2 w0.091: v1(89.06,72.7) 89.46,72.31 89.46,70.15 89.47,70.15 90.69,68.93 90.69,68.82 89.67,67.8 89.67,67.69 89.75,67.61 89.86,67.61 90.88,68.63 90.99,68.63 91.22,68.4 91.22,68.28 90.84,67.9 90.84,67.78 90.92,67.7 91.03,67.7 91.42,68.09 91.53,68.09 91.61,68.01 91.61,67.89 91.23,67.51 91.23,67.4 91.31,67.32 91.42,67.32 91.81,67.7 91.92,67.7 92.07,67.55 92.07,67.44 91.05,66.42 91.05,66.3 91.13,66.22 91.24,66.22 92.26,67.24 92.38,67.24 93.05,66.57 93.05,66.13 93.3,65.88 93.65,65.88 94.06,66.29 94.62,66.29 95.12,65.79 95.12,64.96 95.03,64.87 94.9,64.87 94.82,64.95 94.82,65.58 94.74,65.66 94.63,65.66 94.55,65.58 94.55,64.95 94.47,64.87 94.35,64.87 94.27,64.95 94.27,65.58 94.19,65.66 94.08,65.66 94,65.58 94,64.95 93.92,64.87 93.07,64.87 92.99,64.95 92.99,65.71 92.91,65.79 92.8,65.79 92.72,65.71 92.72,64.95 92.64,64.87 92.33,64.87 92.27,64.8 92.27,64.67 92.36,64.58 94.94,64.58 95.12,64.39 95.12,62.72 95.03,62.63 94.47,62.63 94.39,62.71 94.39,64.18 94.31,64.26 94.2,64.26 94.12,64.18 94.12,62.71 94.04,62.63 93.84,62.63 93.76,62.71 93.76,63.67 93.68,63.75 93.56,63.75 93.48,63.67 93.48,62.71 93.4,62.63 93.14,62.63 93.06,62.71 93.06,63.8 92.98,63.88 92.86,63.88 92.78,63.8 92.78,62.71 92.7,62.63 92.59,62.63 92.51,62.71 92.51,63.8 92.43,63.88 92.31,63.88 92.23,63.8 92.23,62.71 92.15,62.63 91.4,62.63 89.79,61.02 89.16,61.02 88.91,60.77 88.91,59.35 88.81,59.25 v1(88.11,59.25)
  BOTTOM w0.147: R392.1 R393.1 v1(88.11,59.25)
