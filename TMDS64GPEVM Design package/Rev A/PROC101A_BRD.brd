# Allegro board PROC101A_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PRG0_HSE_ETH1_CLK: length 21.1
  TOP w0.147: J2.A17 v1(54.23,127.27)
  L08_SIG2 w0.091: v1(61.21,112.79) 62.08,113.65 62.08,118.9 58.65,122.33 56.24,122.33 54.23,124.33 v1(54.23,127.27)
  BOTTOM w0.147: R236.2 v1(61.21,112.79)
PRG0_HSE_ETH2_CLK: length 22.9
  TOP w0.147: J2.B17 v1(54.23,128.54)
  L08_SIG2 w0.091: v1(62.48,112.79) 62.48,120.85 60.48,122.86 56.79,122.86 54.84,124.82 54.84,127.93 v1(54.23,128.54)
  BOTTOM w0.147: R235.2 v1(62.48,112.79)
PRG0_MDIO0_MDC: length 51.7
  TOP w0.147: J2.A5 68.83,125.87 v1(69.47,125.24) ; U23.P3 v1(88.26,83.9)
  L03_SIG1 w0.091: v1(88.26,83.9) 88.26,85.11 84.23,89.14 84.23,92.29 83.05,93.47 83.05,102.1 69.03,116.13 69.03,124.8 v1(69.47,125.24)
PRG0_MDIO0_MDIO: length 52.6
  TOP w0.147: U23.P2 88.26,84.7 88.26,85.27 88.17,85.36 88.17,87.1 84.2,91.07 84.2,91.94 80.76,95.39 80.76,103.17 77.86,106.06 77.86,108 70.52,115.34 70.52,117.91 72.73,120.12 R19.1 71.37,120.16 70.28,121.25 70.28,125.48 70.1,125.66 J2.A4
PRG0_PRU0_GPO9/CPSW_RGMII1_RX_C: length 41
  TOP w0.147: U23.W6 v1(84.26,81.5)
  L08_SIG2 w0.091: v1(84.26,81.5) 81.76,81.5 78.19,85.07 78.15,85.07 77.12,86.1 75.16,86.1 74.84,86.42 71.04,90.22 71.04,90.52 71.04,96.07 69.82,97.29 56.43,97.29 v1(56.16,97.03)
  BOTTOM w0.147: v1(56.16,97.03) 55.66,97.53 U75.6
PRG0_PRU0_GPO10/CPSW_RGMII1_RXC: length 39
  TOP w0.147: v1(76.71,85.6) 77.97,85.6 81.02,82.55 81.03,82.55 81.11,82.47 81.29,82.47 81.85,81.9 U23.AA5
  L08_SIG2 w0.091: v1(76.71,85.6) 75.15,85.6 75.01,85.74 70.68,90.07 70.68,90.12 70.6,90.19 70.6,95.97 69.7,96.87 69.4,96.87 57.24,96.87 56.77,96.39 55.61,96.39 v1(54.97,97.03)
  BOTTOM w0.147: U75.7 v1(54.97,97.03)
PRG0_PRU0GPO0: length 53.1
  TOP w0.147: U23.Y1 83.86,85.58 83.58,85.87 83.35,85.87 79.29,89.93 79.29,92.47 77,94.75 77,102.75 72.11,107.65 72.11,109.59 65.42,116.28 65.42,121.62 61.34,125.69 60.91,125.69 60.58,126.02 60.58,127.27 J2.B12
PRG0_PRU0GPO1: length 59.7
  TOP w0.147: U23.R4 v1(87.46,83.1) ; J2.E8 v1(65.66,132.35)
  L03_SIG1 w0.091: v1(65.66,132.35) 66.27,131.74 66.27,122.3 68.4,120.18 68.4,115.98 81.41,102.97 81.5,102.88 81.5,94.08 83.57,92.02 83.57,88.6 86.74,85.43 86.74,84.47 87.06,84.15 87.06,83.51 v1(87.46,83.1)
PRG0_PRU0GPO2: length 51.6
  TOP w0.147: J2.A8 65.02,124.1 66.89,122.23 66.89,116.89 76.39,107.39 76.39,105.45 79.28,102.56 79.28,94.55 80.76,93.08 80.76,90.54 83.31,87.99 83.56,87.99 84.21,87.99 85.86,86.33 85.86,84.7 U23.U2
PRG0_PRU0GPO3: length 51.8
  TOP w0.147: U23.V2 85.06,84.7 85.06,86.24 83.95,87.35 83.11,87.35 80.17,90.29 80.17,92.83 78.69,94.31 78.69,102.31 75.8,105.21 75.8,107.15 66.3,116.65 66.3,121.99 63.75,124.53 J2.A9
PRG0_PRU0GPO4: length 57.1
  TOP w0.147: U23.AA2 82.74,84.3 79.11,87.93 73.33,87.93 70.51,90.76 70.51,96.48 70.19,96.8 70.19,107.88 68.03,110.04 68.03,112.13 64.53,115.62 64.53,121.26 60.98,124.81 59.15,124.81 58.67,125.29 J2.A13
PRG0_PRU0GPO5: length 55.7
  TOP w0.147: J2.C6 v1(68.2,129.81) ; U23.R3 v1(87.46,83.9)
  L03_SIG1 w0.091: v1(87.46,83.9) 87.46,84.14 87,84.61 87,85.49 83.79,88.69 83.79,92.11 82.61,93.29 82.61,102.03 68.63,116.01 68.63,120.26 67.77,121.12 67.77,129.38 v1(68.2,129.81)
PRG0_PRU0GPO6: length 62.9
  TOP w0.147: J2.D8 v1(65.66,131.08) ; U23.T3 v1(86.66,83.9)
  L08_SIG2 w0.091: v1(86.66,83.9) 86.66,84.57 85.02,86.21 81.85,86.21 79,89.05 75.67,89.05 74.68,90.04 74.68,90.86 75.36,91.54 75.36,92.46 74.68,93.14 74.68,96.98 70.23,101.42 70.23,104.6 64.67,110.16 64.67,127.89 64.67,127.89 64.67,128.14 66.09,129.56 66.09,130.65 v1(65.66,131.08)
PRG0_PRU0GPO7: length 51.4
  TOP w0.147: J2.B7 66.88,127.32 66.88,123.5 67.77,122.6 67.77,117.26 77.27,107.76 77.27,105.82 80.17,102.92 80.17,95.14 83.61,91.7 83.61,90.83 87.06,87.38 U23.T1
PRG0_PRU0GPO8: length 50.9
  TOP w0.147: U23.T2 86.66,84.7 86.66,87.37 83.32,90.71 83.32,91.58 79.87,95.02 79.87,102.8 76.98,105.69 76.98,107.64 67.48,117.14 67.48,122.48 66.29,123.66 J2.A7
PRG0_PRU0GPO11: length 60.6
  TOP w0.147: J2.B14 57.99,127.32 57.99,125.01 58.48,124.52 60.85,124.52 64.24,121.13 64.24,115.46 67.73,111.96 67.73,109.87 69.9,107.7 69.9,96.67 70.04,96.52 70.05,96.52 70.22,96.36 70.22,90.63 73.21,87.64 78.81,87.64 81.23,85.22 81.43,85.22 82.74,83.9 83.22,83.9 83.62,83.5 U23.Y3
PRG0_PRU0GPO12: length 60.4
  TOP w0.147: J2.A14 57.4,124.83 58.01,124.22 60.73,124.22 63.94,121.01 63.94,115.34 67.44,111.84 67.44,109.74 69.6,107.58 69.6,98 67.96,96.36 67.96,92.38 73,87.35 78.63,87.35 81.14,84.84 81.4,84.84 82.73,83.5 U23.AA3
PRG0_PRU0GPO13: length 59.1
  TOP w0.147: U23.R6 v1(87.46,81.5) ; J2.C5 v1(69.47,129.81)
  L03_SIG1 w0.091: v1(69.47,129.81) 69.91,129.37 69.91,124.75 69.22,124.06 69.22,116.2 83.27,102.14 83.27,93.61 84.45,92.43 84.45,89.25 88.66,85.05 88.66,82.14 88.42,81.91 87.86,81.91 v1(87.46,81.5)
PRG0_PRU0GPO14: length 56.7
  TOP w0.147: U23.V4 v1(85.06,83.1) ; J2.C9 v1(64.39,129.81)
  L03_SIG1 w0.091: v1(64.39,129.81) 64.39,122.8 66.93,120.26 66.93,116.16 80.48,102.61 80.48,89.4 84.66,85.21 84.66,83.58 85.06,83.18 v1(85.06,83.1)
PRG0_PRU0GPO15: length 66.2
  TOP w0.147: J2.D12 v1(60.58,131.08) ; U23.T5 v1(86.66,82.3)
  L03_SIG1 w0.091: v1(86.66,82.3) 86.26,81.9 86.26,80.54 86.02,80.31 84.09,80.31 83.86,80.54 83.86,80.87 83.25,81.47 83.25,84.02 79.37,87.9 79.37,102.43 65.81,115.99 65.81,119.98 61.11,124.68 61.11,130.55 v1(60.58,131.08)
PRG0_PRU0GPO16: length 63.6
  TOP w0.147: U23.U4 v1(85.86,83.1) ; J2.E9 v1(64.39,132.35)
  L08_SIG2 w0.091: v1(85.86,83.1) 85.86,83.33 85.47,83.72 85.47,84.15 85.27,84.35 81.92,84.35 78.18,88.09 75.6,88.09 73.94,89.74 73.94,96.67 69.5,101.12 69.5,104.06 63.75,109.8 J2.E9 v1(64.39,132.35)
PRG0_PRU0GPO17: length 52.1
  TOP w0.147: U23.U1 86.26,86.35 84.33,88.28 83.43,88.28 81.06,90.66 81.06,93.2 79.58,94.68 79.58,102.68 76.68,105.57 76.68,107.52 67.18,117.02 67.18,122.35 65.61,123.93 65.61,127.32 J2.B8
PRG0_PRU0GPO18: length 52.3
  TOP w0.147: U23.V1 85.46,86.26 84.07,87.64 83.24,87.64 80.47,90.41 80.47,92.95 78.99,94.43 78.99,102.43 76.09,105.33 76.09,107.27 66.59,116.77 66.59,122.11 64.34,124.37 64.34,127.32 J2.B9
PRG0_PRU0GPO19: length 53
  TOP w0.147: J2.B11 61.85,127.27 61.85,126.45 61.93,126.37 61.93,125.94 66,121.87 66,116.53 75.5,107.03 75.5,105.08 78.4,102.19 78.4,94.19 79.88,92.71 79.88,90.17 83.04,87.01 83.82,87.01 84.66,86.17 U23.W1
PRG0_PRU1_GPO7/CPSW_RGMII1_RD0: length 42.1
  TOP w0.147: U23.W5 v1(84.26,82.3)
  L08_SIG2 w0.091: v1(56.16,99.03) 56.47,98.72 56.47,98.69 56.63,98.53 56.76,98.53 56.93,98.71 57.06,98.71 57.18,98.59 57.18,98.46 57,98.29 57,98.16 57.12,98.04 57.25,98.04 57.42,98.22 57.55,98.22 57.66,98.11 57.66,97.96 57.78,97.84 69.79,97.84 71.41,96.22 71.41,90.37 75.31,86.47 77.38,86.47 81.54,82.3 v1(84.26,82.3)
  BOTTOM w0.147: U75.2 55.17,99.53 55.35,99.35 55.84,99.35 v1(56.16,99.03)
PRG0_PRU1_GPO9/CPSW_RGMII1_RD1: length 42.6
  TOP w0.147: v1(54.97,99.03) 55.58,98.42 55.58,94.97 59.18,91.37 60.74,91.37 60.86,91.25 60.86,91.04 60.98,90.92 61.14,90.92 61.26,91.04 61.26,91.25 61.38,91.37 61.54,91.37 61.66,91.25 61.66,91.04 61.78,90.92 61.94,90.92 62.06,91.04 62.06,91.25 62.18,91.37 62.35,91.37 62.46,91.25 62.46,91.04 62.58,90.92 62.75,90.92 62.86,91.04 62.86,91.25 62.98,91.37 63.15,91.37 63.27,91.25 63.27,91.04 63.38,90.92 63.55,90.92 63.67,91.04 63.67,91.25 63.78,91.37 63.95,91.37 64.07,91.25 64.07,91.04 64.19,90.92 64.35,90.92 64.47,91.04 64.47,91.25 64.59,91.37 64.75,91.37 64.87,91.25 64.87,91.04 64.99,90.92 65.16,90.92 65.27,91.04 65.27,91.25 65.39,91.37 67.73,91.37 72.63,86.46 77.7,86.46 81.19,82.97 81.2,82.97 81.87,82.3 83.46,82.3 U23.Y5
  BOTTOM w0.147: U75.3 v1(54.97,99.03)
PRG0_PRU1_GPO10/CPSW_RGMII1_RD2: length 42.2
  TOP w0.147: U23.V6 v1(85.06,81.5)
  L08_SIG2 w0.091: v1(85.06,81.5) 84.66,81.9 81.65,81.9 77.27,86.29 75.24,86.29 75.02,86.5 71.22,90.3 71.22,90.45 71.22,96.14 69.83,97.54 56.34,97.54 56.16,97.71 v1(56.16,98.08)
  BOTTOM w0.147: U75.4 55.72,98.53 v1(56.16,98.08)
PRG0_PRU1_GPO17/CPSW_RGMII1_RD3: length 42.9
  TOP w0.147: U23.V5 v1(85.06,82.3)
  L08_SIG2 w0.091: v1(54.97,98.03) 55.62,98.67 55.62,99.14 56.03,99.55 56.55,99.55 58.08,98.02 69.86,98.02 71.59,96.29 71.59,90.45 75.39,86.65 77.48,86.65 81.43,82.7 84.43,82.7 84.68,82.45 84.91,82.45 v1(85.06,82.3)
  BOTTOM w0.147: U75.5 v1(54.97,98.03)
PRG0_PRU1GPO0: length 52.7
  TOP w0.147: U23.Y2 83.86,84.48 83.46,84.88 83.46,85.34 78.99,89.8 78.99,92.34 76.71,94.63 76.71,102.63 71.82,107.52 71.82,109.47 65.12,116.16 65.12,121.5 61.22,125.4 60.37,125.4 59.94,125.82 J2.A12
PRG0_PRU1GPO1: length 52.4
  TOP w0.147: U23.W2 84.26,84.7 84.26,86.01 83.54,86.72 82.91,86.72 79.58,90.05 79.58,92.59 78.11,94.07 78.11,102.07 72.41,107.77 72.41,109.71 65.71,116.41 65.71,121.74 61.63,125.82 61.63,126.21 J2.A11
PRG0_PRU1GPO2: length 57.2
  TOP w0.147: J2.D9 v1(64.39,131.08) ; U23.V3 v1(85.06,83.9)
  L03_SIG1 w0.091: v1(85.06,83.9) 85.06,85.26 80.7,89.63 80.7,102.65 67.51,115.83 67.51,119.93 64.82,122.63 64.82,130.65 v1(64.39,131.08)
PRG0_PRU1GPO3: length 56.9
  TOP w0.147: U23.T4 v1(86.66,83.1) ; J2.C8 v1(65.66,129.81)
  L03_SIG1 w0.091: v1(65.66,129.81) 65.66,122.4 67.96,120.1 67.96,115.91 81.14,102.73 81.14,89.81 86.26,84.69 86.26,83.51 v1(86.66,83.1)
PRG0_PRU1GPO4: length 60
  TOP w0.147: U23.W3 84.26,83.9 83.69,83.9 83.46,84.14 83.46,84.47 83.22,84.7 82.83,84.7 79.31,88.23 73.45,88.23 70.81,90.88 70.81,96.6 70.48,96.92 70.48,110.08 64.83,115.74 64.83,121.38 61.1,125.1 59.62,125.1 59.26,125.47 59.26,127.32 J2.B13
PRG0_PRU1GPO5: length 57.7
  TOP w0.147: J2.D6 v1(68.2,131.08) ; U23.P4 v1(88.26,83.1)
  L03_SIG1 w0.091: v1(88.26,83.1) 87.86,83.5 87.86,85 84.01,88.85 84.01,92.2 82.83,93.38 82.83,102.07 68.81,116.09 68.81,120.33 68.63,120.52 68.63,130.65 v1(68.2,131.08)
PRG0_PRU1GPO6: length 69
  TOP w0.147: J2.E11 v1(61.85,132.35) ; U23.R5 v1(87.46,82.3)
  L08_SIG2 w0.091: v1(87.46,82.3) 87.06,82.7 86.51,82.7 86.26,82.96 86.26,84.3 85.75,84.81 82.27,84.81 78.39,88.69 75.52,88.69 74.31,89.89 74.31,96.83 69.87,101.27 69.87,104.33 64.29,109.91 64.29,128.78 64.87,129.36 64.87,132.54 64.52,132.89 62.39,132.89 v1(61.85,132.35)
PRG0_PRU1GPO8: length 51
  TOP w0.147: U23.R1 87.86,87.01 87.65,87.22 87.64,87.22 83.91,90.95 83.91,91.82 80.46,95.27 80.46,103.04 77.57,105.94 77.57,107.88 69.51,115.94 69.51,120.86 69.92,121.27 69.92,125.43 69.51,125.84 69.51,127.31 J2.B4
PRG0_PRU1GPO11: length 58.7
  TOP w0.147: J2.D11 v1(61.85,131.08) ; U23.W4 v1(84.26,83.1)
  L03_SIG1 w0.091: v1(84.26,83.1) 83.91,83.45 83.91,85.2 80.03,89.08 80.03,102.54 66.4,116.17 66.4,120.17 62.28,124.29 62.28,130.65 v1(61.85,131.08)
PRG0_PRU1GPO12: length 64.1
  TOP w0.147: U23.Y4 83.46,83.1 82.36,83.1 81.9,83.56 81.9,83.94 81.66,84.19 81.65,84.19 81.32,84.51 81.05,84.51 78.51,87.05 72.88,87.05 67.67,92.26 67.67,96.48 69.31,98.12 69.31,106.32 63.65,111.98 63.65,120.89 60.61,123.93 57.34,123.93 56.74,124.53 56.74,127.29 J2.B15
PRG0_PRU1GPO13: length 63.3
  TOP w0.147: J2.D5 v1(69.47,131.08) ; U23.T6 v1(86.66,81.5)
  L03_SIG1 w0.091: v1(86.66,81.5) 87.06,81.11 89.22,81.11 89.46,81.34 89.46,84.83 89.18,85.1 88.89,85.1 84.68,89.32 84.68,92.52 83.49,93.71 83.49,102.18 69.4,116.28 69.4,123.93 70.13,124.66 70.13,130.42 v1(69.47,131.08)
PRG0_PRU1GPO14: length 64.4
  TOP w0.147: J2.E12 v1(60.58,132.35) ; U23.U6 v1(85.86,81.5)
  L03_SIG1 w0.091: v1(85.86,81.5) 85.46,81.11 84.01,81.11 83.47,81.64 83.47,84.11 79.59,88 79.59,102.46 65.99,116.06 65.99,120.06 61.3,124.75 61.3,131.63 v1(60.58,132.35)
PRG0_PRU1GPO15: length 60.6
  TOP w0.147: U23.U5 v1(85.86,82.3) ; J2.C11 v1(61.85,129.81)
  L03_SIG1 w0.091: v1(61.85,129.81) 61.85,124.46 66.18,120.13 66.18,116.14 79.81,102.5 79.81,88.99 83.69,85.1 83.69,82.18 83.97,81.91 85.46,81.91 v1(85.86,82.3)
PRG0_PRU1GPO16: length 58.9
  TOP w0.147: J2.A15 v1(55.5,126) ; v1(81.48,83.77) 81.48,83.31 82.09,82.7 U23.AA4
  L08_SIG2 w0.091: v1(81.48,83.77) 77.77,87.48 77.76,87.48 77.74,87.5 75.66,87.5 73.58,89.59 73.58,96.52 69.13,100.97 69.13,103.38 63.37,109.14 63.37,120.7 59.36,124.71 56.78,124.71 v1(55.5,126)
PRG1_ETH2_D0M: length 29
  BOTTOM w0.108: U80.2 34.96,64 34.86,63.89 21.2,63.89 19.79,65.3 16.72,65.3 13.04,68.98 J21.B2
PRG1_ETH2_D0P: length 29
  BOTTOM w0.108: J21.B1 12.45,72.09 12.75,71.79 12.75,68.86 16.6,65.01 19.67,65.01 21.08,63.6 34.77,63.6 34.88,63.5 U80.1
PRG1_ETH2_D1M: length 28.8
  BOTTOM w0.108: U80.5 35.06,65.5 34.95,65.39 32.01,65.39 31.48,64.86 27.58,64.86 27.47,64.97 27.47,65.69 27.19,65.96 26.74,65.96 26.46,65.69 26.46,64.97 26.35,64.86 26.13,64.86 26.03,64.97 26.03,65.69 25.75,65.96 25.29,65.96 25.02,65.69 25.02,64.97 24.91,64.86 23.53,64.86 18.49,69.9 16.48,69.9 15.77,70.61 15.77,71.84 15.48,72.14 15.48,73.26 J21.B4
PRG1_ETH2_D1P: length 28.8
  BOTTOM w0.108: J21.B3 15.11,72.09 15.49,71.72 15.49,70.49 16.36,69.61 18.37,69.61 23.41,64.57 25.03,64.57 25.31,64.85 25.31,65.57 25.41,65.67 25.63,65.67 25.74,65.57 25.74,64.85 26.01,64.57 26.47,64.57 26.75,64.85 26.75,65.57 26.86,65.67 27.07,65.67 27.18,65.57 27.18,64.85 27.46,64.57 31.6,64.57 32.13,65.1 34.95,65.1 35.05,65 U80.4
PRG1_ETH2_D2M: length 28.9
  BOTTOM w0.108: U80.8 34.82,67 34.72,66.89 29.83,66.89 29.72,67 29.72,67.82 29.45,68.1 28.99,68.1 28.71,67.82 28.71,67 28.6,66.89 28.39,66.89 28.28,67 28.28,67.82 28,68.1 27.55,68.1 27.27,67.82 27.27,67 27.16,66.89 26.95,66.89 26.84,67 26.84,67.82 26.56,68.1 26.1,68.1 25.83,67.82 25.83,67 25.72,66.89 25.5,66.89 25.39,67 25.39,67.82 25.12,68.1 24.66,68.1 24.38,67.82 24.38,67 24.28,66.89 22.84,66.89 18.28,71.46 18.28,71.74 18.12,71.9 J21.B6
PRG1_ETH2_D2P: length 28.9
  BOTTOM w0.108: J21.B5 17.52,72.09 17.99,71.62 17.99,71.34 22.72,66.61 24.4,66.61 24.67,66.88 24.67,67.7 24.78,67.81 25,67.81 25.11,67.7 25.11,66.88 25.38,66.61 25.84,66.61 26.12,66.88 26.12,67.7 26.22,67.81 26.44,67.81 26.55,67.7 26.55,66.88 26.83,66.61 27.28,66.61 27.56,66.88 27.56,67.7 27.67,67.81 27.88,67.81 27.99,67.7 27.99,66.88 28.27,66.61 28.72,66.61 29,66.88 29,67.7 29.11,67.81 29.33,67.81 29.43,67.7 29.43,66.88 29.71,66.61 34.71,66.61 34.82,66.5 U80.7
PRG1_ETH2_D3M: length 28.9
  BOTTOM w0.108: U80.11 34.75,68.5 34.65,68.39 32.52,68.39 31.83,69.08 31.01,69.08 30.9,69.19 30.9,70.11 30.62,70.38 30.17,70.38 29.89,70.11 29.89,69.19 29.78,69.08 29.57,69.08 29.46,69.19 29.46,70.11 29.18,70.38 28.72,70.38 28.45,70.11 28.45,69.19 28.34,69.08 28.12,69.08 28.01,69.19 28.01,70.11 27.74,70.38 27.28,70.38 27,70.11 27,69.19 26.9,69.08 26.68,69.08 26.57,69.19 26.57,70.11 26.29,70.38 25.84,70.38 25.56,70.11 25.56,69.19 25.45,69.08 25.24,69.08 25.13,69.19 25.13,70.11 24.85,70.38 24.4,70.38 24.12,70.11 24.12,69.19 24.01,69.08 22.95,69.08 20.61,71.42 20.61,73.31 J21.B8
PRG1_ETH2_D3P: length 28.9
  BOTTOM w0.108: J21.B7 20.12,72.09 20.32,71.89 20.32,71.3 22.83,68.79 24.13,68.79 24.41,69.07 24.41,69.99 24.52,70.09 24.73,70.09 24.84,69.99 24.84,69.07 25.12,68.79 25.57,68.79 25.85,69.07 25.85,69.99 25.96,70.09 26.17,70.09 26.28,69.99 26.28,69.07 26.56,68.79 27.02,68.79 27.29,69.07 27.29,69.99 27.4,70.09 27.62,70.09 27.73,69.99 27.73,69.07 28,68.79 28.46,68.79 28.74,69.07 28.74,69.99 28.84,70.09 29.06,70.09 29.17,69.99 29.17,69.07 29.45,68.79 29.9,68.79 30.18,69.07 30.18,69.99 30.29,70.09 30.5,70.09 30.61,69.99 30.61,69.07 30.89,68.79 31.71,68.79 32.4,68.1 34.74,68.1 34.85,68 U80.10
PRG1_ETH2_GPIO_1: length 42.8
  BOTTOM w0.147: U80.22 40.74,70.61 R341.1 R340.2 42.55,71.02 43.18,71.65 43.18,73.05 42.7,73.53 42.7,75.82 41.48,77.04 41.48,84.09 41.03,84.53 36.37,84.53 35,85.9 25.83,85.9 25.17,86.56 18.87,86.56 18.26,87.17 R617.2
PRG1_ETH2_LED1: length 3.2
  BOTTOM w0.147: Q14.3 11.22,71.05 J21.B11
PRG1_ETH2_LED2: length 7.6
  BOTTOM w0.147: Q21.3 14.33,83.01 14.45,82.89 R616.1 13.73,82.25 J21.B14
PRG1_ETH2_LED3: length 9.4
  BOTTOM w0.147: R615.1 3.74,78.7 3.74,78.7 Q16.3 6.44,78.12 7.13,77.43 8.91,77.43 J21.B13
PRG1_ETH2_LED_1000/RX_ER: length 118.2
  TOP w0.147: U23.AA13 82.85,75.5 82.83,75.49 82.49,75.49 82.47,75.5 79.75,75.5 79.2,74.96 76.5,74.96 75.54,73.99 73.51,73.99 71.92,75.58 71.92,76.97 67.85,81.03 67.16,81.03 66.53,81.66 62.73,81.66 56.29,75.23 56.29,70.77 51.84,66.32 49.71,66.32 46.86,63.47 46.86,61.85 45.61,60.59 43.44,60.59 41.72,58.87 36.07,58.87 v1(35.31,59.64)
  L08_SIG2 w0.091: v1(35.31,59.64) 34.55,59.64 30.61,63.57 20.75,63.57 19.05,61.86 13.59,61.86 12.63,62.82 9.17,62.82 4.62,67.36 4.62,68.55 3.1,70.08 3.1,75.83 v1(2.48,76.45)
  BOTTOM w0.147: R386.1 36.25,58.61 R388.2 v1(35.31,59.64) 35.31,61.1 35.84,61.64 36.47,61.64 36.54,61.7 36.57,61.7 36.71,61.83 36.87,61.83 37.24,62.2 U80.46 ; R343.2 v1(2.48,76.45)
PRG1_ETH2_LED_ACT: length 39.1
  L08_SIG2 w0.091: v1(36.34,59.48) 35.74,60.09 34.41,60.09 30.75,63.74 30.7,63.74 30.69,63.75 25.35,63.75 19.68,69.42 13.34,69.42 v1(10.27,66.35)
  BOTTOM w0.147: R324.1 v1(10.27,66.35) ; R387.2 37.41,58.61 R385.1 37.31,58.68 36.75,59.23 36.59,59.23 v1(36.34,59.48) 36.02,59.8 36.02,60.69 36.21,60.88 36.21,60.88 36.47,61.14 36.48,61.14 36.87,61.54 37,61.54 37.67,62.21 37.67,62.34 37.74,62.41 U80.45
PRG1_ETH2_LED_LINK: length 75.8
  TOP w0.147: U23.U12 v1(85.86,75.9)
  L08_SIG2 w0.091: v1(34.67,61.17) 35.37,61.86 37.41,61.86 38.72,60.55 41.02,60.55 41.4,60.93 41.4,62.89 42.58,64.08 43.45,64.08 43.7,63.82 43.7,62.64 43.11,62.05 42.87,62.05 42.62,61.79 42.62,61.43 43.2,60.85 45.57,60.85 46.1,61.37 46.1,61.91 46.8,62.61 46.8,63.18 61.33,77.71 75.22,77.71 76.8,76.13 81.01,76.13 81.26,76.38 82.75,76.38 83.06,76.07 83.06,75.74 83.29,75.51 85.46,75.51 v1(85.86,75.9)
  BOTTOM w0.147: U80.47 36.74,62.28 36.45,61.99 35.5,61.99 v1(34.67,61.17) 34.04,60.53 R563.1 R562.2
PRG1_ETH3_D0M: length 27.3
  TOP w0.108: U20.2 35.07,84.12 34.96,84.24 33.23,84.24 32.07,85.39 19.43,85.39 13.04,79.01 J21.A2
PRG1_ETH3_D0P: length 27.3
  TOP w0.108: U20.1 35.02,84.62 34.92,84.52 33.35,84.52 32.19,85.68 19.31,85.68 12.75,79.13 12.75,78.98 12.47,78.69 J21.A1
PRG1_ETH3_D1M: length 27
  TOP w0.108: J21.A4 15.58,78.84 15.79,79.06 15.79,79.88 17.8,81.89 24.77,81.89 25.61,82.74 26.11,82.74 26.39,83.01 26.39,83.7 26.49,83.81 26.71,83.81 26.82,83.7 26.82,83.01 27.09,82.74 27.55,82.74 27.83,83.01 27.83,83.7 27.94,83.81 28.15,83.81 28.26,83.7 28.26,83.01 28.54,82.74 34.96,82.74 35.07,82.62 U20.5
PRG1_ETH3_D1P: length 27
  TOP w0.108: J21.A3 15.02,78.69 15.51,79.18 15.51,80 17.68,82.18 24.65,82.18 25.49,83.02 25.99,83.02 26.1,83.13 26.1,83.82 26.37,84.1 26.83,84.1 27.11,83.82 27.11,83.13 27.21,83.02 27.43,83.02 27.54,83.13 27.54,83.82 27.82,84.1 28.27,84.1 28.55,83.82 28.55,83.13 28.66,83.02 34.92,83.02 35.02,83.12 U20.4
PRG1_ETH3_D2M: length 26.7
  TOP w0.108: J21.A6 18.12,80.1 18.81,80.79 24.95,80.79 25.05,80.68 25.05,79.83 25.33,79.55 25.79,79.55 26.06,79.83 26.06,80.68 26.17,80.79 26.39,80.79 26.5,80.68 26.5,79.83 26.77,79.55 27.23,79.55 27.51,79.83 27.51,80.68 27.62,80.79 27.83,80.79 27.94,80.68 27.94,79.83 28.22,79.55 28.67,79.55 28.95,79.83 28.95,80.68 29.06,80.79 29.85,80.79 30.3,81.24 34.76,81.24 34.88,81.12 U20.8
PRG1_ETH3_D2P: length 26.8
  TOP w0.108: J21.A5 17.55,78.69 17.83,78.98 17.83,80.22 18.69,81.08 25.07,81.08 25.34,80.8 25.34,79.95 25.45,79.84 25.67,79.84 25.78,79.95 25.78,80.8 26.05,81.08 26.51,81.08 26.79,80.8 26.79,79.95 26.89,79.84 27.11,79.84 27.22,79.95 27.22,80.8 27.5,81.08 27.95,81.08 28.23,80.8 28.23,79.95 28.34,79.84 28.55,79.84 28.66,79.95 28.66,80.8 28.94,81.08 29.73,81.08 30.18,81.53 34.75,81.53 34.84,81.62 U20.7
PRG1_ETH3_D3M: length 27
  TOP w0.108: U20.11 35.07,79.62 34.96,79.74 32.61,79.74 31.52,78.64 31.29,78.64 31.19,78.55 31.19,77.21 30.92,76.94 30.55,76.94 30.28,77.21 30.28,78.55 30.19,78.64 30.05,78.64 29.95,78.55 29.95,77.21 29.69,76.94 29.31,76.94 29.04,77.21 29.04,78.55 28.95,78.64 28.81,78.64 28.72,78.55 28.72,77.21 28.45,76.94 28.07,76.94 27.81,77.21 27.81,78.55 27.71,78.64 24.2,78.64 22.91,79.94 21.37,79.94 20.66,79.23 J21.A8
PRG1_ETH3_D3P: length 27
  TOP w0.108: J21.A7 20.1,78.69 20.37,78.96 20.37,79.35 21.25,80.22 23.03,80.22 24.32,78.93 27.83,78.93 28.1,78.66 28.1,77.33 28.19,77.23 28.33,77.23 28.43,77.33 28.43,78.66 28.69,78.93 29.07,78.93 29.33,78.66 29.33,77.33 29.43,77.23 29.57,77.23 29.66,77.33 29.66,78.66 29.93,78.93 30.31,78.93 30.57,78.66 30.57,77.33 30.67,77.23 30.8,77.23 30.9,77.33 30.9,78.66 31.17,78.93 31.4,78.93 32.49,80.02 34.92,80.02 35.02,80.12 U20.10
PRG1_ETH3_GPIO_1: length 39.6
  TOP w0.147: v1(43.23,76.99) 43.05,77.17 R115.1 R114.2 40.87,77.58 U20.22 ; R614.2 v1(17.47,90.6)
  BOTTOM w0.147: v1(43.23,76.99) 42.36,77.86 42.36,84.52 41.49,85.39 41.42,85.39 41.4,85.42 36.84,85.42 35.46,86.79 26.71,86.79 22.8,90.7 18.84,90.7 18.74,90.6 v1(17.47,90.6)
PRG1_ETH3_LED1: length 3.7
  BOTTOM w0.147: J21.A11 7,72.35 6.88,72.24 Q15.3
PRG1_ETH3_LED2: length 12.4
  TOP w0.147: Q20.3 13.55,86.25 13.55,86.25 R613.1 12.95,83.32 J21.A14
PRG1_ETH3_LED3: length 14.7
  TOP w0.147: J21.A13 4.6,79.89 4.6,84.3 6.52,86.23 R612.1 8.55,86.23 8.56,86.23 Q4.3
PRG1_ETH3_LED_1000/RX_ER: length 97.9
  TOP w0.147: R96.1 36.38,89.51 R94.2 v1(35.43,88.48) 35.43,87.01 35.96,86.49 36.77,86.49 36.97,86.28 37.05,86.28 37.37,85.97 U20.46 ; R99.2 13.01,89.67 13.69,90.35 v1(14.94,90.35) ; U23.V13 v1(85.06,75.1)
  L03_SIG1 w0.091: v1(73.15,90.18) 73.15,87.64 75.92,84.88 75.92,82.79 80.37,78.35 80.37,77.62 81.59,76.4 82.7,76.4 83.04,76.06 83.04,75.71 83.22,75.52 84.64,75.52 v1(85.06,75.1)
  BOTTOM w0.147: v1(73.15,90.18) 73.15,90.95 72.9,91.2 72.14,91.2 70.99,90.06 60.71,90.06 59.01,88.37 50.11,88.37 48.84,89.64 45.88,89.64 42.54,86.29 37.17,86.29 35.43,88.03 v1(35.43,88.48) 34.25,88.48 32.79,89.94 29.95,89.94 28.65,91.24 16.28,91.24 15.39,90.35 v1(14.94,90.35)
PRG1_ETH3_LED_ACT: length 56.4
  TOP w0.147: R95.2 37.53,89.51 R97.1 37.44,89.44 36.88,88.88 36.8,88.88 36.55,88.63 v1(36.47,88.63) 36.15,88.32 36.15,87.18 36.45,86.88 36.79,86.88 37.1,86.58 37.22,86.58 37.87,85.94 U20.45
  L08_SIG2 w0.091: v1(1.51,70.61) 2.31,71.42 2.31,74.42 1.85,74.88 1.85,79.73 7.98,85.85 27.8,85.85 31.75,89.8 35.3,89.8 v1(36.47,88.63)
  BOTTOM w0.147: R334.1 v1(1.51,70.61)
PRG1_ETH3_LED_LINK: length 71.8
  TOP w0.147: R564.2 R565.1 34.16,87.68 v1(34.5,87.35) 34.82,87.03 34.82,86.93 35.63,86.12 36.7,86.12 36.87,85.96 U20.47 ; U23.W13 v1(84.26,75.1)
  L03_SIG1 w0.091: v1(72.64,90.69) 72.64,87.77 75.65,84.76 75.65,82.7 79.63,78.72 79.63,76.91 80.95,75.59 82.19,75.59 82.56,75.22 84.14,75.22 v1(84.26,75.1)
  BOTTOM w0.147: v1(34.5,87.35) 35.6,87.35 36.96,85.99 42.66,85.99 44.88,88.21 44.88,88.21 45.98,89.31 48.7,89.31 49.97,88.04 59.1,88.04 60.83,89.76 71.71,89.76 v1(72.64,90.69)
PRG1_IEP0_EDC_LATCH_IN0: length 30.1
  TOP w0.147: U23.V7 v1(85.06,80.7)
  L08_SIG2 w0.091: J17.1 67.02,96.5 69.55,96.5 70.23,95.82 70.23,90.35 70.23,90.35 70.23,90.04 70.31,89.96 70.31,89.92 74.11,86.12 75.26,84.96 77.93,84.96 78,84.89 78.09,84.89 81.88,81.1 84.66,81.1 v1(85.06,80.7)
PRG1_IEP0_EDC_LATCH_IN1: length 61.4
  TOP w0.147: U23.U13 v1(85.86,75.1)
  L08_SIG2 w0.091: J15.1 58.17,95.39 57.91,95.65 55.43,95.65 53.75,97.32 53.75,99.05 54.73,100.02 56.7,100.02 58.34,98.39 70.02,98.39 71.96,96.45 71.96,90.62 75.44,87.14 77.59,87.14 81.34,83.39 82.47,83.39 82.85,83.77 84.58,83.77 84.84,83.52 85.27,83.52 85.43,83.35 85.43,82.89 85.59,82.73 86.03,82.73 86.26,82.5 86.26,78.87 86.41,78.71 86.85,78.71 87.06,78.51 87.06,77.37 86.28,76.6 86.28,75.53 v1(85.86,75.1)
PRG1_IEP0_EDC_SYNC_OUT0: length 25.7
  TOP w0.147: U23.W7 v1(84.26,80.7)
  L08_SIG2 w0.091: v1(84.26,80.7) 81.99,80.7 77.98,84.71 74.93,84.71 67.82,91.82 67.82,94.12 J18.1
PRG1_IEP0_EDC_SYNC_OUT2: length 57.2
  TOP w0.147: U23.U7 v1(85.86,80.7)
  L08_SIG2 w0.091: v1(85.86,80.7) 85.46,81.11 85.46,82.43 85.16,82.73 84.84,82.73 84.63,82.93 84.63,83.29 84.42,83.5 83.12,83.5 82.7,83.08 81.36,83.08 77.61,86.83 77.53,86.83 77.48,86.88 75.42,86.88 71.77,90.53 71.77,96.37 69.94,98.2 58.21,98.2 56.61,99.8 54.82,99.8 53.97,98.96 53.97,97.41 55.55,95.84 57.72,95.84 58.39,96.5 61.63,96.5 J16.1
PRG1_MDIO_MDC: length 61.8
  TOP w0.147: U20.42 39.37,85.9 38.71,86.55 R104.2 39.1,87.11 v1(39.32,86.89) ; U23.Y6 83.46,81.5 81.35,81.5 80.19,82.66 79.62,82.66 78.95,83.33 77.87,84.42 v1(71.91,84.42) ; U27.8 v1(51.58,87.21)
  L08_SIG2 w0.091: v1(39.32,86.89) 40.55,88.12 40.55,89.63 42.06,91.14 46.91,91.14 49.39,88.66 50.5,88.66 51.58,87.59 v1(51.58,87.21) 52.04,87.68 59.84,87.68 60.02,87.5 60.02,87.25 59.79,87.02 57.51,87.02 57.25,86.77 57.25,86.26 57.51,86 61.82,86 63.41,84.42 v1(71.91,84.42)
PRG1_MDIO_MDIO: length 50.3
  TOP w0.147: v1(70.52,83.75) 71.08,83.2 74.68,83.2 75.06,83.58 78.29,83.58 78.31,83.56 79.5,82.37 80.07,82.37 81.34,81.1 U23.AA6 ; v1(49.5,87.86) 49.36,87.71 U27.2 ; U20.41 39.87,86.37 40.04,86.55 R103.1 40.06,87.11 40.61,87.11 40.64,87.14 v1(40.67,87.14)
  L08_SIG2 w0.091: v1(40.67,87.14) 41.95,88.42 48.95,88.42 v1(49.5,87.86) 49.88,87.86 49.95,87.93 50.65,87.93 51.13,87.45 51.13,86.94 52.35,85.72 61.47,85.72 63.12,84.07 70.2,84.07 v1(70.52,83.75)
PRG1_PRU1GPO18: length 79
  TOP w0.147: v1(71.37,76.72) 71.37,75.67 73.38,73.66 75.82,73.66 76.63,74.47 79.53,74.47 80.16,75.1 83.46,75.1 U23.Y13 ; J2.E13 v1(59.31,132.35)
  L03_SIG1 w0.091: v1(59.31,132.35) 59.74,131.92 59.74,125.32 65.44,119.61 65.44,112.41 66.35,111.49 66.35,107.16 67.78,105.74 67.78,99.29 70.9,96.17 70.9,91.17 68.07,88.35 68.07,83.02 71.37,79.72 v1(71.37,76.72)
PRG1_PRU1GPO19: length 66.6
  TOP w0.147: U23.V12 v1(85.06,75.9) ; J2.C12 v1(60.58,129.81)
  L03_SIG1 w0.091: v1(85.06,75.9) 84.68,76.29 83.17,76.29 81.14,78.31 80.84,78.31 76.33,82.82 76.33,84.96 73.79,87.5 73.79,106.19 65.63,114.35 65.63,119.69 60.58,124.73 v1(60.58,129.81)
PRG1_RGMII1_ETH3_CLK: length 51.7
  TOP w0.147: U20.20 39.87,77.63 v1(40.26,77.24)
  L08_SIG2 w0.091: v1(59.94,112.79) 57.78,110.63 54.36,110.63 48.12,104.39 43.56,104.39 40.26,101.09 40.26,96.14 39.38,95.26 39.38,88.76 38.61,87.99 38.61,85.27 39.21,84.67 39.21,78.28 v1(40.26,77.24)
  BOTTOM w0.147: R237.2 v1(59.94,112.79)
PRG1_RGMII1_ETH3_CLK_OUT: length 4.9
  TOP w0.147: TP17.1 40.77,88.66 40.95,88.47 41.15,88.28 41.15,86.89 40.37,86.11 U20.40
PRG1_RGMII1_ETH3_RBIAS: length 1.3
  TOP w0.147: U20.12 R110.2
PRG1_RGMII1_RD0: length 48.6
  TOP w0.147: U23.Y7 83.46,80.7 81.22,80.7 80.52,81.41 79.5,81.41 78.75,82.16 78.75,82.45 77.94,83.26 75.86,83.26 75.37,83.26 74.53,82.42 70.63,82.42 69.13,83.92 68.46,83.92 66.76,85.62 56.18,85.62 56.03,85.47 56.03,85.34 55.88,85.19 55.59,85.19 55.44,85.34 55.44,85.47 55.29,85.62 55,85.62 54.85,85.47 54.85,85.34 54.7,85.19 54.41,85.19 54.26,85.34 54.26,85.47 54.11,85.62 53.82,85.62 53.67,85.47 53.67,85.34 53.52,85.19 53.23,85.19 53.08,85.34 53.08,85.47 52.93,85.62 50.55,85.62 47.58,82.65 45.85,82.65 45.74,82.76 R108.1 v1(45.09,83.45) 44.76,83.12 U20.33
  BOTTOM w0.147: R108.1 v1(45.09,83.45)
PRG1_RGMII1_RD1: length 49.7
  TOP w0.147: U23.U8 v1(85.86,79.9) ; R107.1 v1(45.09,84.59) 44.11,83.62 U20.34
  L08_SIG2 w0.091: v1(85.86,79.9) 85.43,80.33 84.1,80.33 83.93,80.5 81.91,80.5 79.09,83.32 70.28,83.32 69.78,83.82 62.87,83.82 61.29,85.39 52.5,85.39 50.93,83.82 49.02,83.82 47.42,85.42 45.54,85.42 45.09,84.97 v1(45.09,84.59)
  BOTTOM w0.147: R107.1 v1(45.09,84.59)
PRG1_RGMII1_RD2: length 48.3
  TOP w0.147: U20.35 43.21,84.12 v1(43.43,84.35) ; U23.W8 v1(84.26,79.9)
  L08_SIG2 w0.091: v1(43.43,84.35) 43.82,83.96 44.05,83.96 44.14,84.05 44.14,84.79 44.23,84.88 44.4,84.88 44.49,84.79 44.49,84.05 44.58,83.96 45.59,83.96 45.68,84.05 45.68,84.52 45.77,84.62 45.93,84.62 46.02,84.52 46.02,84.05 46.11,83.96 46.28,83.96 46.37,84.05 46.37,84.52 46.46,84.62 46.62,84.62 46.71,84.52 46.71,84.05 46.8,83.96 47.64,83.96 48.72,82.89 69.68,82.89 69.98,82.59 78.3,82.59 78.98,81.92 78.98,81.3 79.97,80.3 83.35,80.3 83.75,79.9 v1(84.26,79.9)
PRG1_RGMII1_RD3: length 48.2
  TOP w0.147: U23.V8 v1(85.06,79.9) ; v1(43.69,85.49) 43.36,85.16 42.75,85.16 42.62,85.02 U20.36
  L08_SIG2 w0.091: v1(43.69,85.49) 42.93,84.73 42.93,83.9 44.02,82.8 46.74,82.8 47.02,82.52 69.53,82.52 69.82,82.22 76.27,82.22 77.06,81.43 78.23,81.43 79.73,79.93 83.43,79.93 83.66,79.7 83.93,79.7 84.1,79.53 84.69,79.53 v1(85.06,79.9)
PRG1_RGMII1_RESETN: length 14.5
  TOP w0.147: v1(38.48,88.79) 38.1,88.41 38.1,86.63 38.87,85.86 U20.43 ; v1(31.11,87.25) 31.11,87.88 R102.1 29.74,87.9 U19.4
  L08_SIG2 w0.091: v1(38.48,88.79) 37.59,87.9 34.44,87.9 33.53,86.99 31.38,86.99 v1(31.11,87.25)
PRG1_RGMII1_RX_CTL: length 48.5
  TOP w0.147: v1(45.3,87.99) 44.77,87.99 R101.2 R100.1 43.43,87.36 42.33,86.25 41.77,86.25 41.37,85.85 U20.38 ; U23.Y8 83.46,79.9 81.53,79.9 81.43,79.8 80.6,79.8 78.46,81.94 78.46,82.32 78.11,82.67 75.62,82.67 74.99,82.04 70.17,82.04 68.83,83.39 68.14,83.39 66.69,84.84 v1(50.55,84.84)
  BOTTOM w0.147: v1(45.3,87.99) 46.58,87.99 49.73,84.84 v1(50.55,84.84)
PRG1_RGMII1_RXC: length 48.2
  TOP w0.147: v1(80.26,80.9) 80.91,80.25 82.52,80.25 82.58,80.3 U23.AA7 ; U20.32 44.39,82.62 44.79,82.23 47.76,82.23 48.52,82.99 48.57,82.99 v1(48.9,83.31)
  L08_SIG2 w0.091: v1(48.9,83.31) 51.94,83.31 52.45,83.82 52.79,83.82 52.88,83.91 52.88,84.36 52.97,84.45 53.15,84.45 53.24,84.36 53.24,83.91 53.34,83.82 53.52,83.82 53.61,83.91 53.61,84.36 53.7,84.45 53.88,84.45 53.98,84.36 53.98,83.91 54.07,83.82 54.25,83.82 54.34,83.91 54.34,84.36 54.43,84.45 54.62,84.45 54.71,84.36 54.71,83.91 54.8,83.82 54.98,83.82 55.07,83.91 55.07,84.36 55.16,84.45 55.35,84.45 55.44,84.36 55.44,83.91 55.53,83.82 55.71,83.82 55.8,83.91 55.8,84.36 55.9,84.45 56.08,84.45 56.17,84.36 56.17,83.91 56.26,83.82 62.1,83.82 62.61,83.31 69.77,83.31 70.13,82.96 78.45,82.96 79.34,82.07 79.34,81.82 v1(80.26,80.9)
PRG1_RGMII1_TD0: length 55.2
  TOP w0.147: U23.AA8 79.87,79.5 77.97,81.41 77.72,81.41 76.9,82.23 75.59,82.23 74.81,81.45 70.35,81.45 68.71,83.09 68.02,83.09 67.38,83.73 52.59,83.73 52.48,83.61 52.48,82.85 52.36,82.73 52.19,82.73 52.08,82.85 52.08,83.61 51.96,83.73 51.79,83.73 51.67,83.61 51.67,82.85 51.56,82.73 51.39,82.73 51.27,82.85 51.27,83.61 51.16,83.73 50.47,83.73 49.7,82.96 49.7,82.79 50.26,82.23 50.26,82.07 50.15,81.95 49.98,81.95 49.42,82.51 49.25,82.51 49.14,82.39 49.14,82.23 49.7,81.67 49.7,81.5 49.58,81.38 49.41,81.38 48.85,81.94 48.69,81.94 47.94,81.19 46.94,81.19 46.74,80.99 46.74,78.74 46.35,78.36 44.45,78.36 44.07,78.74 44.07,80.13 43.98,80.22 43.98,80.36 43.87,80.46 43.37,80.46 43.2,80.62 U20.28
PRG1_RGMII1_TD1: length 55.6
  TOP w0.147: U23.U9 v1(85.86,79.1) ; v1(43.58,80) 43.45,80.12 U20.27
  BOTTOM w0.114: v1(85.86,79.1) 85.46,79.5 83.76,79.5 83.35,79.91
  BOTTOM w0.147: v1(43.58,80) 44.32,80.74 44.32,81.55 45.17,82.4 49.32,82.4 49.5,82.21 49.5,81.43 49.62,81.31 49.78,81.31 49.9,81.43 49.9,82.28 50.02,82.4 50.19,82.4 50.3,82.28 50.3,81.43 50.42,81.31 50.59,81.31 50.7,81.43 50.7,82.28 50.82,82.4 50.99,82.4 51.11,82.28 51.11,81.91 51.22,81.79 51.39,81.79 51.51,81.91 51.51,82.28 51.63,82.4 51.79,82.4 51.91,82.28 51.91,81.43 52.03,81.31 52.19,81.31 52.31,81.43 52.31,82.17 52.54,82.4 68.51,82.4 71.41,85.29 72.72,85.29 73.69,84.33 78.93,84.33 83.35,79.91
PRG1_RGMII1_TD2: length 55.2
  TOP w0.147: v1(43.59,78.18) 43.59,79.36 43.41,79.54 43.39,79.54 43.31,79.62 U20.26 ; U23.W9 v1(84.26,79.1)
  L08_SIG2 w0.091: v1(43.59,78.18) 43.14,78.63 43.14,81.59 43.24,81.68 43.6,81.68 43.69,81.77 43.69,81.95 43.6,82.05 43.24,82.05 43.14,82.14 43.14,82.26 43.43,82.55 44.26,82.55 44.35,82.46 44.35,82.11 44.44,82.02 44.61,82.02 44.7,82.11 44.7,82.49 44.79,82.58 44.95,82.58 45.04,82.49 45.04,81.89 45.13,81.8 45.3,81.8 45.39,81.89 45.39,82.49 45.48,82.58 45.64,82.58 45.73,82.49 45.73,81.89 45.83,81.8 45.99,81.8 46.08,81.89 46.08,82.49 46.17,82.58 46.33,82.58 46.42,82.49 46.42,81.89 46.52,81.8 46.68,81.8 46.77,81.89 46.77,82.2 46.86,82.3 69.49,82.3 69.75,82.04 76.1,82.04 76.89,81.25 78.15,81.25 79.57,79.83 79.57,79.83 79.67,79.73 83.26,79.73 83.89,79.1 v1(84.26,79.1)
PRG1_RGMII1_TD3: length 55.1
  TOP w0.147: U23.AA9 81.48,78.7 81.37,78.81 79.73,78.81 77.72,80.82 77.48,80.82 77.14,81.16 75.35,81.16 75.06,80.86 70.11,80.86 69.93,81.03 68.67,82.3 67.69,82.3 66.85,83.14 53.86,83.14 51.28,80.56 51.28,80.4 51.8,79.88 51.8,79.71 51.69,79.6 51.52,79.6 51,80.11 50.83,80.11 50.72,80 50.72,79.83 51.24,79.31 51.24,79.15 51.12,79.03 50.95,79.03 50.43,79.55 50.27,79.55 50.15,79.43 50.15,79.26 50.67,78.74 50.67,78.58 50.55,78.46 50.38,78.46 49.87,78.98 49.7,78.98 49.58,78.86 49.58,78.7 50.1,78.18 50.1,78.01 49.98,77.89 49.82,77.89 49.3,78.41 49.13,78.41 49.01,78.29 49.01,78.13 49.53,77.61 49.53,77.44 49.42,77.33 49.25,77.33 48.73,77.84 48.56,77.84 47.32,76.6 44.27,76.6 42.62,78.25 U20.25
PRG1_RGMII1_TX_CTL: length 55.4
  TOP w0.147: v1(44.58,77.1) 45.31,77.84 48.14,77.84 53.73,83.43 67.06,83.43 67.82,82.68 68.71,82.68 70.23,81.16 74.93,81.16 75.23,81.45 77.26,81.45 77.6,81.11 77.85,81.11 79.85,79.1 83.46,79.1 U23.Y9 ; v1(43.05,85.74) 42.93,85.74 42.64,85.45 42.63,85.45 42.55,85.37 U20.37
  L08_SIG2 w0.091: v1(43.05,85.74) 42.67,85.36 42.67,78.37 43.94,77.1 v1(44.58,77.1)
PRG1_RGMII1_TXC: length 55.3
  TOP w0.147: U23.V9 v1(85.06,79.1) ; v1(43.81,80.91) 43.52,80.91 43.31,81.12 U20.29
  L08_SIG2 w0.091: v1(43.81,80.91) 44.19,80.91 44.6,81.33 47.96,81.33 48.56,81.93 49.73,81.93 49.82,81.84 49.82,80.99 49.91,80.9 50.1,80.9 50.19,80.99 50.19,81.84 50.28,81.93 50.46,81.93 50.55,81.84 50.55,80.86 50.64,80.77 50.83,80.77 50.92,80.86 50.92,81.84 51.01,81.93 51.19,81.93 51.28,81.84 51.28,80.86 51.38,80.77 51.56,80.77 51.65,80.86 51.65,81.84 51.74,81.93 51.92,81.93 52.02,81.84 52.02,80.86 52.11,80.77 52.29,80.77 52.38,80.86 52.38,81.84 52.47,81.93 52.66,81.93 52.75,81.84 52.75,80.86 52.87,80.75 53,80.75 53.11,80.86 53.11,81.82 53.2,81.92 69.36,81.92 69.6,81.68 75.94,81.68 76.74,80.88 78,80.88 79.42,79.47 79.42,79.47 79.52,79.37 82.94,79.37 83.6,78.71 84.66,78.71 v1(85.06,79.1)
PRG1_RGMII2_ETH2_CLK: length 57.8
  L08_SIG2 w0.091: v1(58.67,112.79) 58.67,111.92 57.67,110.92 54.24,110.92 47.97,104.65 43.31,104.65 40.01,101.35 40.01,96.27 39.16,95.42 39.16,88.85 38.32,88.02 38.32,85.24 38.99,84.58 38.99,73.17 40.13,72.02 v1(40.13,70.88)
  BOTTOM w0.147: R238.2 v1(58.67,112.79) ; U80.20 39.74,70.49 v1(40.13,70.88)
PRG1_RGMII2_ETH2_CLK_OUT: length 5.1
  BOTTOM w0.147: U80.40 40.24,62.01 40.64,61.61 40.89,61.61 41.09,61.42 41.09,58.76 TP78.1
PRG1_RGMII2_ETH2_RBIAS: length 1.3
  BOTTOM w0.147: U80.12 R349.2
PRG1_RGMII2_FET_ENN: length 1.8
  TOP w0.147: U27.9 53.98,87.71 53.99,87.7 R121.1
PRG1_RGMII2_FET_SEL: length 67.8
  TOP w0.147: v1(46.58,88.85) 46.51,88.77 R120.1 47.1,88.21 47.1,88.21 U27.1
  L03_SIG1 w0.091: v1(46.58,88.85) 46.3,88.57 46.3,76.56 43.84,74.09 43.84,63.14 43.76,63.07 43.76,60.25 40.45,56.93 40.45,48.7 41.81,47.35 43.59,47.35 50.04,40.89 50.04,34.08 50.7,33.41 v1(51.07,33.41)
  BOTTOM w0.147: U91.13 v1(51.07,33.41)
PRG1_RGMII2_MDC: length 40.4
  TOP w0.147: U27.6 v1(50.88,86.21)
  L08_SIG2 w0.091: v1(39.19,61.23) 39.19,64.01 39.52,64.34 39.52,69.24 40.46,70.18 40.51,70.18 40.61,70.28 40.61,72.92 41.71,74.02 41.71,85.57 43.43,87.3 49.38,87.3 49.83,86.84 50.25,86.84 v1(50.88,86.21)
  BOTTOM w0.147: v1(39.19,61.23) 39.19,61.11 39.09,61.01 R369.2 38.58,61.56 39.24,62.22 U80.42
PRG1_RGMII2_MDIO: length 38.8
  TOP w0.147: U27.4 49.41,86.71 v1(49.68,86.44)
  L08_SIG2 w0.091: v1(40.62,61.15) 39.83,61.94 39.83,69.14 41.58,70.89 41.58,73.05 42.85,74.32 42.85,75.74 41.99,76.61 41.99,85.45 43.56,87.02 49.1,87.02 v1(49.68,86.44)
  BOTTOM w0.147: v1(40.62,61.15) 40.62,61.15 40.48,61.01 39.92,61.01 R370.1 39.92,61.57 39.74,61.75 U80.41
PRG1_RGMII2_RD0: length 63.3
  TOP w0.147: R126.2 44.09,65.26 44.37,65.55 v1(44.83,65.55) ; U23.W11 v1(84.26,77.5)
  L08_SIG2 w0.091: v1(84.26,77.5) 83.55,77.5 82.36,78.69 79.41,78.69 77.84,80.26 76.58,80.26 75.72,81.13 69.37,81.13 69.22,81.28 59.94,81.28 51.41,72.75 44.42,72.75 42.18,70.51 42.18,68.11 41.95,67.88 41.67,67.88 41.58,67.79 41.58,67.62 41.67,67.53 42.2,67.53 42.29,67.44 42.29,67.3 42.2,67.2 41.7,67.2 41.61,67.11 41.61,66.95 41.7,66.86 41.98,66.86 42.29,66.55 42.29,65.84 43.35,64.78 44.07,64.78 v1(44.83,65.55)
  BOTTOM w0.147: v1(44.83,65.55) 44.37,65.55 44.09,65.26 R126.2 43.53,64.67 43.2,65 U80.33
PRG1_RGMII2_RD1: length 62.7
  TOP w0.147: R128.2 44.09,62.99 v1(44.2,62.88) ; U23.V11 v1(85.06,77.5)
  L08_SIG2 w0.091: v1(85.06,77.5) 84.66,77.9 83.74,77.9 82.64,79 79.37,79 79.33,79.04 79.32,79.04 77.85,80.52 76.59,80.52 75.79,81.31 69.45,81.31 69.22,81.53 59.82,81.53 51.28,72.99 44.29,72.99 41.15,69.85 41.15,66.69 44.2,63.64 v1(44.2,62.88)
  BOTTOM w0.147: U80.34 43.22,64.5 43.61,64.1 43.62,64.1 43.89,63.83 43.89,63.82 44.09,63.62 R128.2 44.09,63.24 44.2,63.13 v1(44.2,62.88)
PRG1_RGMII2_RD2: length 61.9
  TOP w0.147: U23.AA12 v1(82.66,75.9)
  L08_SIG2 w0.091: v1(43.27,63.13) 43.27,63.52 43.18,63.61 42.44,63.61 41.69,62.86 41.69,62.64 41.78,62.55 42.13,62.55 42.22,62.46 42.22,62.3 42.13,62.21 41.78,62.21 41.69,62.11 41.69,60.75 41.81,60.62 42.77,60.62 42.86,60.53 42.86,59.97 42.95,59.88 43.12,59.88 43.21,59.97 43.21,60.53 43.3,60.62 43.46,60.62 43.55,60.53 43.55,59.97 43.64,59.88 43.81,59.88 43.9,59.97 43.9,60.53 43.99,60.62 44.15,60.62 44.24,60.53 44.24,59.97 44.34,59.88 44.5,59.88 44.59,59.97 44.59,60.53 44.68,60.62 44.84,60.62 44.93,60.53 44.93,60.06 45.03,59.97 45.19,59.97 45.28,60.06 45.28,60.53 45.37,60.62 45.66,60.62 46.32,61.28 46.32,61.88 46.98,62.54 46.98,63.1 61.41,77.53 75.15,77.53 76.73,75.95 81.18,75.95 81.53,75.59 82.35,75.59 v1(82.66,75.9)
  BOTTOM w0.147: U80.35 43.08,64 43.27,63.81 v1(43.27,63.13)
PRG1_RGMII2_RD3: length 61.6
  TOP w0.147: U23.Y12 v1(83.46,75.9)
  L08_SIG2 w0.091: v1(83.46,75.9) 83.28,76.09 83.28,76.16 82.86,76.58 81.15,76.58 80.89,76.33 76.86,76.33 75.3,77.89 61,77.89 52.27,69.16 50.9,69.16 50.09,68.35 50.09,66.73 49.89,66.52 49.76,66.52 49.57,66.71 49.44,66.71 49.31,66.58 49.31,66.45 49.5,66.27 49.5,66.14 48.87,65.51 47.58,65.51 47.49,65.42 47.49,64.25 47.39,64.16 47.24,64.16 47.12,64.28 47.12,65.42 47.03,65.51 46.81,65.51 46.62,65.31 46.62,63.93 46.52,63.83 46.36,63.83 46.27,63.93 46.27,65.31 46.18,65.4 45.67,65.4 44.9,64.64 44.9,64.34 44.99,64.25 45.3,64.25 45.39,64.16 45.39,63.98 45.3,63.89 44.99,63.89 44.9,63.79 44.9,62.94 45.16,62.69 45.9,62.69 46,62.79 v1(46.37,62.79)
  BOTTOM w0.147: U80.36 42.49,63.07 43.26,62.3 44.38,62.3 44.7,62.63 44.83,62.63 44.99,62.79 v1(46.37,62.79)
PRG1_RGMII2_RESETN: length 18.3
  TOP w0.147: v1(28.3,61.85) 27.81,61.35 U31.4
  L08_SIG2 w0.091: v1(28.3,61.85) 28.83,62.37 31.5,62.37 35.43,58.43 37.47,58.43 v1(38.35,59.32)
  BOTTOM w0.147: U80.43 38.74,62.26 37.97,61.49 37.97,59.7 v1(38.35,59.32) ; R367.1 v1(28.3,61.85)
PRG1_RGMII2_RX_CTL: length 63.2
  TOP w0.147: R135.1 v1(43.05,61.61) ; U23.W12 v1(84.26,75.9)
  L08_SIG2 w0.091: v1(84.26,75.9) 83.86,76.3 83.46,76.3 83.31,76.45 83.27,76.45 82.86,76.86 81.14,76.86 80.79,76.51 76.98,76.51 75.38,78.11 60.68,78.11 51.92,69.34 50.83,69.34 49.89,68.4 49.89,67.48 49.1,66.69 49.1,65.99 48.83,65.72 48.67,65.72 48.58,65.81 48.58,66.61 48.49,66.7 48.31,66.7 48.22,66.61 48.22,65.81 48.12,65.72 47.13,65.72 47.04,65.81 47.04,66.59 46.95,66.68 46.79,66.68 46.7,66.59 46.7,65.81 46.6,65.72 46.44,65.72 46.35,65.81 46.35,66.59 46.26,66.68 46.1,66.68 46,66.59 46,65.81 45.91,65.72 45.69,65.72 44.69,64.71 44.69,64.58 44.6,64.49 44.06,64.49 43.97,64.4 43.97,64.21 44.06,64.12 44.6,64.12 44.69,64.03 44.69,61.83 44.2,61.34 43.32,61.34 v1(43.05,61.61)
  BOTTOM w0.147: R135.1 v1(43.05,61.61) 42.6,61.61 42.34,61.86 41.66,61.86 41.24,62.28 U80.38
PRG1_RGMII2_RXC: length 61.9
  TOP w0.147: U23.U11 v1(85.86,77.5)
  L08_SIG2 w0.091: v1(85.86,77.5) 85.86,77.43 85.17,76.74 83.65,76.74 82.29,78.09 79.18,78.09 78.41,78.87 75.25,78.87 75.18,78.8 60.47,78.8 51.85,70.18 49.9,70.18 49.81,70.09 49.81,69.69 49.72,69.6 49.56,69.6 49.44,69.71 49.44,70.48 49.35,70.57 49.17,70.57 49.08,70.48 49.08,69.81 48.98,69.72 48.8,69.72 48.71,69.81 48.71,70.48 48.62,70.57 48.44,70.57 48.34,70.48 48.34,69.81 48.25,69.72 48.07,69.72 47.98,69.81 47.98,70.48 47.89,70.57 47.7,70.57 47.61,70.48 47.61,69.81 47.52,69.72 47.34,69.72 47.25,69.81 47.25,70.48 47.16,70.57 46.97,70.57 46.88,70.48 46.88,69.81 46.79,69.72 46.61,69.72 46.52,69.81 46.52,70.48 46.42,70.57 44.49,70.57 43.48,69.57 43.17,69.57 42.93,69.32 42.93,68.2 44.17,66.95 44.17,65.98 43.68,65.49 v1(43.31,65.49)
  BOTTOM w0.147: U80.32 43.3,65.5 v1(43.31,65.49)
PRG1_RGMII2_TD0: length 59.5
  TOP w0.147: U23.AA10 82.58,77.9 82.4,77.72 79.62,77.72 77.47,79.88 73.03,79.88 72.64,80.27 69.86,80.27 68.22,81.91 67.53,81.91 66.89,82.55 57.4,82.55 55.34,80.49 55.34,79.76 55.2,79.62 54.25,79.62 54.1,79.47 54.1,79.17 54.25,79.03 55.2,79.03 55.34,78.88 55.34,78.58 55.2,78.44 54.25,78.44 54.1,78.29 54.1,78 54.25,77.85 55.2,77.85 55.34,77.7 55.34,77.41 55.2,77.26 54.25,77.26 54.1,77.11 54.1,76.82 54.25,76.67 55.2,76.67 55.34,76.52 55.34,74.5 53.29,72.44 49.4,72.44 47.3,70.34 46.05,70.34 45.83,70.12 v1(44.83,70.12)
  BOTTOM w0.147: U80.28 43.35,67.5 44.2,68.34 44.2,69.48 v1(44.83,70.12)
PRG1_RGMII2_TD1: length 60
  TOP w0.147: U23.V10 v1(85.06,78.3)
  L08_SIG2 w0.091: v1(85.06,78.3) 85.46,77.91 85.46,77.34 85.08,76.96 83.74,76.96 82.24,78.46 79.38,78.46 78.02,79.83 75.69,79.83 75.03,79.17 60.32,79.17 52.2,71.04 50.98,71.04 50.89,71.14 50.89,71.77 50.8,71.86 50.61,71.86 50.52,71.77 50.52,71.1 50.43,71.01 49.3,71.01 49.21,71.1 49.21,71.77 49.12,71.86 48.94,71.86 48.85,71.77 48.85,71.1 48.76,71.01 48.57,71.01 48.48,71.1 48.48,71.77 48.39,71.86 48.21,71.86 48.12,71.77 48.12,71.1 48.02,71.01 47.81,71.01 47.72,71.1 47.72,71.36 47.63,71.45 47.45,71.45 47.36,71.36 47.36,71.1 47.26,71.01 47.08,71.01 46.99,71.1 46.99,71.41 46.9,71.5 46.71,71.5 46.62,71.41 46.62,71.1 46.53,71.01 46.35,71.01 46.26,71.1 46.26,71.41 46.17,71.5 45.98,71.5 45.89,71.41 45.89,71.1 45.8,71.01 45.62,71.01 45.53,71.1 45.53,71.41 45.43,71.5 45.25,71.5 45.16,71.41 45.16,71.1 45.07,71.01 44.32,71.01 v1(43.31,69.99)
  BOTTOM w0.147: v1(43.31,69.99) 43.81,69.48 43.81,69.17 43.82,69.16 43.82,68.79 43.81,68.78 43.81,68.38 43.43,68 U80.27
PRG1_RGMII2_TD2: length 60
  TOP w0.147: U23.U10 v1(85.86,78.3)
  L08_SIG2 w0.091: v1(43.36,68.98) 44.24,68.1 44.46,68.1 44.55,68.19 44.55,68.37 44.64,68.46 44.81,68.46 44.9,68.37 44.9,68.19 44.99,68.1 45.15,68.1 45.38,68.33 45.58,68.33 45.81,68.1 46.16,68.1 46.25,68.01 46.25,66.95 46.35,66.86 46.51,66.86 46.6,66.95 46.6,68.01 46.69,68.1 46.85,68.1 46.94,68.01 46.94,66.95 47.04,66.86 47.2,66.86 47.29,66.95 47.29,68.01 47.38,68.1 47.78,68.1 47.87,68.01 47.87,67.65 47.97,67.56 48.13,67.56 48.22,67.65 48.22,68.01 48.31,68.1 48.47,68.1 48.57,68.01 48.57,67.65 48.66,67.56 48.82,67.56 48.91,67.65 48.91,68.01 49,68.1 49.17,68.1 49.26,68.01 49.26,67.65 49.35,67.56 49.51,67.56 49.6,67.65 49.6,68.73 50.55,69.67 51.86,69.67 60.62,78.43 75.62,78.43 76.45,77.6 79.07,77.6 79.17,77.7 82.38,77.7 83.55,76.52 85.52,76.52 86.26,77.25 86.26,77.91 v1(85.86,78.3)
  BOTTOM w0.147: U80.26 43.22,68.5 43.36,68.64 v1(43.36,68.98)
PRG1_RGMII2_TD3: length 59.6
  TOP w0.147: v1(41.65,68.82) 42.37,69.54 45.67,69.54 46.18,70.04 47.42,70.04 49.44,72.06 53.62,72.06 55.67,74.11 55.67,78.07 55.82,78.22 56.49,78.22 56.64,78.37 56.64,78.66 56.49,78.81 55.82,78.81 55.67,78.96 55.67,79.25 55.82,79.4 56.49,79.4 56.64,79.55 56.64,79.84 56.49,79.99 55.82,79.99 55.67,80.14 55.67,80.37 57.56,82.25 66.77,82.25 67.41,81.62 68.1,81.62 72.16,77.56 72.5,77.21 72.5,75.93 73.71,74.73 75.43,74.73 76.47,75.77 78.48,75.77 79.14,76.43 81.16,76.43 81.83,77.1 U23.AA11
  BOTTOM w0.147: v1(41.65,68.82) 41.65,68.83 41.81,69 U80.25
PRG1_RGMII2_TX_CTL: length 59.7
  TOP w0.147: v1(41.53,63.64) 41.85,63.32 41.85,63.18 42.67,62.36 44.82,62.36 45.14,62.68 45.55,62.68 49.6,66.73 51.79,66.73 56,70.93 56,75.35 62.6,81.96 66.65,81.96 67.29,81.32 67.98,81.32 72.04,77.26 72.21,77.09 72.21,75.72 73.49,74.44 75.56,74.44 76.45,75.34 78.47,75.34 79.26,76.13 81.28,76.13 81.57,76.43 81.57,76.49 81.78,76.7 83.46,76.7 U23.Y11
  BOTTOM w0.147: U80.37 41.74,63.43 v1(41.53,63.64)
PRG1_RGMII2_TXC: length 60
  TOP w0.147: v1(75.82,80.39) 77.55,80.39 79.64,78.3 83.46,78.3 U23.Y10
  L08_SIG2 w0.091: v1(43.31,67) 42.55,67.77 42.55,70.33 44.09,71.88 46.1,71.88 46.48,72.26 52.53,72.26 59.8,79.53 60.6,79.53 60.69,79.62 60.69,80.68 60.78,80.77 60.96,80.77 61.05,80.68 61.05,79.62 61.15,79.53 61.33,79.53 61.42,79.62 61.42,80.68 61.51,80.77 61.69,80.77 61.79,80.68 61.79,79.62 61.88,79.53 62.06,79.53 62.15,79.62 62.15,80.68 62.24,80.77 62.43,80.77 62.52,80.68 62.52,79.62 62.61,79.53 62.89,79.53 62.98,79.62 62.98,80.66 63.07,80.75 63.25,80.75 63.34,80.66 63.34,79.62 63.44,79.53 68.99,79.53 69.85,80.39 v1(75.82,80.39)
  BOTTOM w0.147: U80.29 43.3,67 v1(43.31,67)
PRG1_RGMII_INTN: length 151.2
  TOP w0.147: U20.44 38.37,85.85 37.72,86.5 37.72,86.85 37.48,87.1 R105.1 37.13,87.1 36.8,87.43 v1(36.79,87.43)
  L03_SIG1 w0.091: v1(36.79,87.43) 36.79,85.4 36.8,85.39 36.8,70.91 36.66,70.77 v1(36.66,60.69)
  L08_SIG2 w0.091: v1(36.66,60.69) 37.62,60.69 39.37,58.94 45.31,58.94 46.78,60.42 46.78,62.08 47.17,62.46 47.17,63.02 61.48,77.34 75.07,77.34 76.67,75.75 80.32,75.75 81.02,75.75 82.06,74.71 86.91,74.71 87.07,74.87 87.07,76.59 87.87,77.38 87.87,79.27 88.09,79.49 91.72,79.49 91.85,79.36 91.85,77.38 92.1,77.13 94.12,77.13 94.25,77.26 94.25,77.79 94.39,77.92 94.81,77.92 95.08,77.66 95.08,74.86 95.23,74.7 95.7,74.7 95.88,74.52 95.88,72.53 95.89,72.53 96.14,72.28 98.09,72.28 98.3,72.07 98.3,70.71 101.7,67.31 101.7,64.83 101.37,64.5 v1(101.37,62.24)
  BOTTOM w0.147: v1(101.37,62.24) 100.86,62.24 99.46,63.64 R597.1 ; v1(36.66,60.69) 36.67,60.69 37,61.02 R368.1 37.59,61.28 37.59,61.62 38.24,62.26 U80.44 ; v1(36.79,87.43) 36.96,87.6 36.96,89.93 35.94,90.95 35.94,96.28 36.7,97.04 36.7,104.79 37.59,105.68 R250.1
PRG1_RGMII_INTN_RC: length 9.8
  TOP w0.147: v1(101.27,65.7) 100.82,65.7 99.06,67.46 99.06,68.47 98.66,68.87 98.66,70.07 98.42,70.3 97.86,70.3 U23.C19
  BOTTOM w0.147: R597.2 C491.1 100.73,65.15 v1(101.27,65.7)
PRG_EARTH: length 3.3
  BOTTOM w0.254: v1(2.18,85.84) 2.24,85.9 C295.1 2.24,86.86 v1(3.45,86.86)
  BOTTOM w0.381: R304.1 5.17,87.74 v1(5.5,88.06)
PRI_INN: length 7.2
  TOP w0.147: v1(63.11,105.56) 62.66,105.12 62.66,103.72 v1(63.5,102.88) R55.1
  BOTTOM w0.147: C252.2 R55.1 v1(63.5,102.88) ; U70.14 v1(63.11,105.56)
RESETSTATZ: length 234.8
  TOP w0.147: v1(108.08,42.81) 106.96,41.7 TP68.1 ; U23.F16 v1(95.46,72.7) ; U54.2 v1(116.46,25.03) ; v1(40.19,37.78) 44.77,37.78 46.91,35.64 58.01,35.64 v1(59.95,33.7) ; U105.8 53.81,53.96 v1(54.31,53.47)
  L03_SIG1 w0.091: 116.46,26.43 122.76,32.73 122.76,47.75 122.75,47.76 122.75,48.69 121.96,49.48 120.85,49.48 120.02,50.31 120.02,50.49 117.31,53.2 109.25,53.2 106.68,55.77 106.68,63.64 103.98,66.33 103.98,70.3 103.62,70.66 103.01,70.66 v1(102.74,70.4) ; 116.46,26.43 v1(116.46,25.03) ; 116.46,26.43 113.41,29.48 113.41,37.04 113.06,37.39 113.06,38.97 109.22,42.81 v1(108.08,42.81) ; v1(59.95,33.7) 59.95,39.75 54.31,45.39 v1(54.31,53.47)
  L08_SIG2 w0.091: v1(116.46,25.03) 116.46,24.02 110.94,18.5 102.28,18.5 99.46,21.32 93.51,21.32 91.03,18.84 82.01,18.84 77.34,23.51 64.39,23.51 60.96,26.94 60.96,32.77 60.3,33.43 60.22,33.43 v1(59.95,33.7)
  BOTTOM w0.114: 98.39,73.1 97.31,73.1 95.86,73.1 v1(95.46,72.7)
  BOTTOM w0.147: U85.2 v1(108.08,42.81) 106.95,41.69 R435.2 ; 98.39,73.1 99.17,73.1 101.31,70.97 102.17,70.97 v1(102.74,70.4) 103.07,70.73 104.06,70.73 R344.2 ; U91.28 59.21,33.41 59.5,33.7 v1(59.95,33.7) ; U86.3 32.27,44.2 32.77,43.7 33.66,43.7 33.94,43.99 38.06,43.99 38.23,43.83
  BOTTOM w0.254: v1(40.19,37.78) 39.61,37.78 38.23,39.17 U88.2 38.23,43.83
SEL_XDS: length 51.8
  TOP w0.147: U56.4 121.1,51.27 v1(121.46,50.9) ; U47.4 104.76,33.43 104.52,33.67 v1(104.52,34.3) ; v1(94.61,35.57) 94.75,35.57 94.88,35.44 U45.6
  L08_SIG2 w0.091: v1(121.46,50.9) 121.2,50.64 121.2,50.46 117.88,47.14 117.88,46.53 116.33,44.98 116.33,37.24 112.27,33.17 105.65,33.17 v1(104.52,34.3) 102.55,36.27 95.31,36.27 v1(94.61,35.57)
  BOTTOM w0.147: v1(121.46,50.9) 122.15,51.59 123.72,51.59 125.32,53.18 125.32,53.93 ; 125.32,53.93 125.46,53.79 125.68,53.79 125.82,53.93 U98.14 ; 125.32,53.93 U98.15
SEL_XDS110_INV: length 154.7
  TOP w0.147: U60.15 109.02,13.43 109.52,13.93 109.52,16.56 110.59,17.63 111.44,17.63 113.16,19.34 113.16,31.59 v1(112.24,32.5) 112.2,32.54 R184.1 R183.1 109.2,32.54 108.97,32.78 U47.2 ; U37.14 87.69,46.5 87.88,46.3 v1(87.88,46.28) 88.19,46.58 U37.15 ; v1(71.72,26.42) 73.44,26.42 73.62,26.6 U52.1 74.32,27.55 75.45,26.42 v1(77.31,26.42) 79,26.42 79.21,26.63 U53.1 ; v1(73.27,37.58) 73.27,38.09 72.48,38.88 72.01,38.88 71.63,39.26 71.63,39.64 71.88,39.89 J25.8 ; v1(133.2,25.07) 134.32,26.19 136.25,26.19 136.7,25.73 138.27,25.73 138.55,26.01 U55.6 ; v1(91.69,33.03) 91.69,33.31 91.28,33.73 U46.4
  L03_SIG1 w0.091: v1(91.69,33.03) 91.69,38.62 89.79,40.53 89.79,44.38 v1(87.88,46.28)
  L08_SIG2 w0.091: v1(77.31,26.42) 73.28,30.45 73.28,37.2 73.27,37.21 v1(73.27,37.58) ; v1(133.2,25.07) 129.83,25.07 129.29,24.53 119.7,24.53 112.24,31.98 v1(112.24,32.5)
  BOTTOM w0.147: v1(112.24,32.5) 104.95,32.5 103.1,30.65 94.72,30.65 92.33,33.03 v1(91.69,33.03) ; 75.86,38.52 75.86,38.38 76.27,37.97 81.77,37.97 87.88,44.08 v1(87.88,46.28) ; 75.86,38.52 75.71,38.37 74.05,38.37 v1(73.27,37.58) ; 75.86,38.52 75.86,38.77 76.72,39.63 J33.58 ; v1(77.31,26.42) 77.27,26.45 77.27,27.52 U93.1 ; U94.1 v1(71.72,26.42)
SERDES0_ATB_0: length 4.6
  TOP w0.147: U23.W15 v1(84.26,73.5)
  BOTTOM w0.114: TP66.1 83.86,76.22 83.86,73.9 v1(84.26,73.5)
SERDES0_ATB_1: length 10.6
  TOP w0.147: U23.V16 v1(85.06,72.7)
  L08_SIG2 w0.091: v1(85.06,72.7) 84.66,73.1 84.09,73.1 83.87,72.88 83.87,72.81 83.86,72.79 83.86,72.5 83.51,72.15 82.8,72.15 82.04,71.39 82.04,70.58 81.33,69.87 81.33,69.59 80.04,68.3 v1(78.66,68.3)
  BOTTOM w0.147: v1(78.66,68.3) 78.56,68.2 TP73.1
SERDES0_REXT: length 22.2
  TOP w0.147: U23.T13 v1(86.66,75.1)
  L03_SIG1 w0.091: v1(86.66,75.1) 86.27,74.72 86.27,73.18 86.18,73.09 85.64,73.09 85.44,72.89 85.44,72.42 85.32,72.3 84.9,72.3 84.64,72.04 84.64,71.75 84.42,71.52 82.05,71.52 81.71,71.18 75.79,71.18 75.47,71.5 75.47,71.96 75.66,72.15 75.66,73.3 74.91,74.06 74.91,74.69 74.42,75.18 74.42,75.52 74.45,75.55 74.45,75.68 74.4,75.73 v1(74.4,76.1)
  BOTTOM w0.147: v1(74.4,76.1) 74.4,75.47 74.42,75.44 74.42,75.24 73.94,74.76 R338.1
SERDES_REFCLK0_N: length 81.8
  L08_SIG2 w0.081: v1(76.38,73.05) 77.17,73.05 arc(77.38,73.14) 77.47,73.36 77.47,73.46 arc(77.41,73.6) 77.27,73.66 74.34,73.66 arc(73.91,73.75) 73.54,73.99 73.49,74.05 arc(73.41,74.1) 73.31,74.12 62.93,74.12 arc(62,73.93) 61.22,73.41 52.92,65.11 arc(52.15,63.96) 51.88,62.6 51.88,58.93 arc(51.41,56.58) 50.08,54.58 45.01,49.51 arc(42.78,48.02) 40.14,47.5 35.28,47.5 arc(33.49,47.14) 31.97,46.13 arc(31.2,44.97) 30.92,43.6 30.92,38.87 arc(30.78,38.52) 30.43,38.38 30.35,38.38 arc(30.32,38.37) 30.29,38.36 v1(30.02,38.09)
  BOTTOM w0.108: v1(76.38,73.05) 76.57,73.05 arc(76.69,73) 76.73,72.89 76.73,72.58 arc(76.8,72.42) 76.95,72.36 77.07,72.36 arc(77.15,72.39) 77.18,72.46 77.18,73.23 arc(77.21,73.31) 77.28,73.34 R680.1 77.72,74.34 R622.2 R624.2 ; v1(30.02,38.09) 29.71,38.39 29.3,38.39 28.41,37.51 27.44,37.51 27.02,37.93 27.02,38.44 26.86,38.6 26.46,38.6 26.35,38.49 R665.2
