# Allegro board PROC101A_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SYS_BOOTMODE3: length 72.9
  TOP w0.147: SW2.4 v1(87,20.77)
  L08_SIG2 w0.091: v1(67.81,67.86) 67.31,67.36 67.31,66.31 68.02,65.6 68.02,64.84 68.89,63.97 68.89,61.54 68.45,61.1 68.45,57.67 69.02,57.11 69.02,55.56 72.47,52.1 72.47,45.89 78.78,39.59 78.78,35.07 82.29,31.56 82.29,20.49 82.86,19.92 86.15,19.92 v1(87,20.77)
  BOTTOM w0.147: R510.1 v1(87,20.77) 88.19,19.57 91.86,19.57 93.26,20.97 93.26,22.53 93.85,23.11 U96.4 ; U79.6 v1(67.81,67.86)
SYS_BOOTMODE4: length 73
  TOP w0.147: SW2.5 v1(88.27,20.77)
  L08_SIG2 w0.091: v1(66.81,66.72) 66.81,66.28 67.8,65.3 67.8,62.27 68.12,61.94 68.12,55.59 71.45,52.27 71.45,46.6 78.56,39.49 78.56,35.04 82.11,31.48 82.11,20.41 82.78,19.74 87.24,19.74 v1(88.27,20.77)
  BOTTOM w0.147: U96.5 93.85,23.61 92.97,22.73 92.97,21.09 91.74,19.86 89.17,19.86 v1(88.27,20.77) R503.1 ; v1(66.81,66.72) 67.31,67.22 U79.7
SYS_BOOTMODE5: length 74.4
  TOP w0.147: SW2.6 v1(89.53,20.77)
  L08_SIG2 w0.091: v1(66.81,67.86) 66.29,67.34 66.29,66.05 66.64,65.71 66.64,62.33 67.84,61.12 67.84,55.36 71.22,51.98 71.22,46.43 78.33,39.32 78.33,35 81.93,31.41 81.93,20.34 82.7,19.56 88.33,19.56 v1(89.53,20.77)
  BOTTOM w0.147: 90.14,20.16 91.57,20.16 92.67,21.26 92.67,22.94 93.85,24.11 U96.6 ; 90.14,20.16 v1(89.53,20.77) ; 90.14,20.16 v1(89.53,20.77) ; v1(89.53,20.77) R498.1 ; U79.8 v1(66.81,67.86)
SYS_BOOTMODE6: length 73.9
  TOP w0.147: SW2.7 v1(90.8,20.77)
  L08_SIG2 w0.091: v1(90.8,20.77) 89.41,19.37 82.63,19.37 81.74,20.26 81.74,31.33 78.11,34.96 78.11,39.23 71,46.34 71,51.88 67.62,55.26 67.62,60.92 66.4,62.13 66.4,65.44 65.81,66.03 v1(65.81,66.72)
  BOTTOM w0.147: R489.1 v1(90.8,20.77) 91.49,20.77 92.35,21.63 92.35,23.54 93.43,24.61 U96.7 ; v1(65.81,66.72) 66.31,67.22 U79.9
SYS_BOOTMODE7: length 76
  TOP w0.147: v1(91.77,23.28) 92.07,22.98 SW2.8
  L08_SIG2 w0.091: v1(91.77,23.28) 91.77,21.02 89.94,19.19 82.55,19.19 81.56,20.18 81.56,31.26 77.89,34.92 77.89,39.14 70.78,46.25 70.78,51.79 66.6,55.97 66.6,57.38 66.72,57.5 66.72,59.79 65.53,60.97 65.53,65.8 65.38,65.96 65.38,67.42 v1(65.81,67.86)
  BOTTOM w0.147: R474.1 90.78,23.46 90.83,23.41 90.83,23.41 90.96,23.28 v1(91.77,23.28) 91.77,23.54 93.35,25.11 U96.8 ; U79.10 v1(65.81,67.86)
SYS_BOOTMODE8: length 61
  TOP w0.147: SW3.1 v1(102.95,23.13)
  L08_SIG2 w0.091: v1(77.29,51.83) 77.29,48.61 86.03,39.87 86.03,34.84 88.28,32.59 93.48,32.59 v1(102.95,23.13)
  BOTTOM w0.147: U81.3 76.68,53.1 76.83,52.95 76.83,52.29 v1(77.29,51.83) ; U96.9 95.4,26.66 97.35,28.62 100.54,28.62 102.64,26.52 102.64,23.43 v1(102.95,23.13) 103.89,23.13 104.24,23.48 R473.1
SYS_BOOTMODE9: length 66.2
  TOP w0.147: SW3.2 v1(104.22,20.84)
  L08_SIG2 w0.091: v1(76.29,52.85) 76.73,52.41 76.73,48.86 85.81,39.78 85.81,34.75 88.16,32.4 93.34,32.4 101.73,24.02 101.73,21.96 102.84,20.84 v1(104.22,20.84)
  BOTTOM w0.147: U81.4 76.18,52.96 v1(76.29,52.85) ; R488.1 v1(104.22,20.84) 102.93,20.84 102.3,21.47 102.3,26.44 100.42,28.32 97.56,28.32 95.9,26.66 U96.10
SYS_BOOTMODE10: length 69.7
  TOP w0.147: SW3.3 v1(105.49,20.84)
  L08_SIG2 w0.091: v1(105.49,20.84) 104.56,19.92 103.42,19.92 101.54,21.8 101.54,23.94 94.8,30.69 89.56,30.69 85.59,34.66 85.59,39.69 76.28,48.99 76.28,51.38 76.29,51.39 v1(76.29,51.83)
  BOTTOM w0.147: v1(76.29,51.83) 75.75,52.38 75.75,53.15 75.68,53.22 U81.5 ; U96.11 96.4,26.67 97.76,28.03 100.3,28.03 102.01,26.32 102.01,21.35 103.17,20.18 104.83,20.18 v1(105.49,20.84) R497.1
SYS_BOOTMODE11: length 72.3
  TOP w0.147: SW3.4 v1(106.76,20.84)
  L08_SIG2 w0.091: v1(106.76,20.84) 105.65,19.73 103.35,19.73 101.36,21.72 101.36,23.87 94.76,30.46 89.47,30.46 85.37,34.57 85.37,39.59 75.73,49.23 75.73,52.41 v1(75.29,52.85)
  BOTTOM w0.147: v1(75.29,52.85) 75.18,52.96 U81.6 ; R502.1 v1(106.76,20.84) 105.8,19.89 103.05,19.89 101.71,21.23 101.71,26.2 100.18,27.73 97.99,27.73 96.9,26.65 U96.12
SYS_BOOTMODE12: length 75.1
  TOP w0.147: SW3.5 v1(108.03,20.84)
  L08_SIG2 w0.091: v1(108.03,20.84) 106.73,19.55 102.9,19.55 101.06,21.39 101.06,23.91 94.73,30.24 89.38,30.24 85.15,34.48 85.15,39.5 75.29,49.36 v1(75.29,51.83)
  BOTTOM w0.147: v1(75.29,51.83) 74.75,52.38 74.75,53.15 74.68,53.22 U81.7 ; U96.13 97.4,26.73 98.11,27.44 100.06,27.44 101.42,26.08 101.42,21.11 102.93,19.59 106.78,19.59 v1(108.03,20.84) R509.1
SYS_BOOTMODE13: length 77.8
  TOP w0.147: SW3.6 v1(109.3,20.84)
  L08_SIG2 w0.091: v1(74.3,52.85) 74.73,52.41 74.73,49.61 84.93,39.41 84.93,34.38 89.29,30.02 94.69,30.02 100.87,23.84 100.87,21.32 102.89,19.3 107.76,19.3 v1(109.3,20.84)
  BOTTOM w0.147: v1(74.3,52.85) 74.18,52.96 U81.8 ; R513.1 v1(109.3,20.84) 107.75,19.3 102.81,19.3 101.12,20.98 101.12,25.95 99.93,27.14 98.23,27.14 97.9,26.81 U96.14
SYS_BOOTMODE14: length 80.3
  TOP w0.147: SW3.7 v1(110.57,20.84)
  L08_SIG2 w0.091: v1(110.57,20.84) 108.84,19.12 102.74,19.12 100.69,21.17 100.69,23.76 94.65,29.8 89.2,29.8 84.71,34.29 84.71,39.32 74.3,49.73 v1(74.3,51.83)
  BOTTOM w0.147: R518.1 v1(110.57,20.84) 108.73,19 102.64,19 100.83,20.81 100.83,25.83 99.85,26.81 98.63,26.81 98.4,26.58 U96.15 ; v1(74.3,51.83) 73.68,52.45 U81.9
SYS_BOOTMODE15: length 83.1
  TOP w0.147: SW3.8 v1(111.84,20.84)
  L08_SIG2 w0.091: v1(111.84,20.84) 111.84,20.44 110.34,18.94 102.57,18.94 100.51,21 100.51,23.69 94.61,29.58 89.11,29.58 84.48,34.2 84.48,39.28 75.95,47.82 74.63,47.82 73.35,49.09 73.35,52.78 v1(73.15,52.97)
  BOTTOM w0.147: U81.10 73.18,53 v1(73.15,52.97) ; R528.1 v1(111.84,20.84) 111.84,20.81 109.73,18.71 102.51,18.71 100.53,20.69 100.53,25.62 100.24,25.91 U96.16
SYSBOOT_BUF_ENZ: length 3
  BOTTOM w0.147: R435.1 R434.1 108.98,39.18 108.97,39.16 U90.1
TCA6424_EXP_INT: length 2.3
  BOTTOM w0.147: U96.32 95.4,20 94.97,19.58 R533.1
TEMP_DIODE_P: length 23.8
  TOP w0.147: U23.F12 v1(95.46,75.9)
  L08_SIG2 w0.091: v1(109.65,63.26) 107.98,64.93 107.98,68.61 104.26,72.33 100.33,72.33 98.98,73.67 98.98,74.51 97.97,75.53 95.83,75.53 v1(95.46,75.9)
  BOTTOM w0.147: v1(109.65,63.26) 109.68,63.24 110.11,63.24 110.13,63.26 TP75.1
TEST_GPIO1: length 67.3
  L08_SIG2 w0.091: v1(70.33,18.23) 71.39,19.29 74.3,19.29 79.46,14.13 92.55,14.13 94.4,15.98 105.49,15.98 106.51,17.01 113.35,17.01 116.95,20.61 117.32,20.61 122.54,20.61 123.84,21.9 123.84,22.55 124.15,22.86 126.38,22.86 126.79,22.45 v1(128.46,22.45)
  BOTTOM w0.147: R545.1 v1(70.33,18.23) R523.1 ; Q17.1 v1(128.46,22.45)
TEST_GPIO2: length 36.7
  TOP w0.147: v1(69.19,18.23) 69.19,27.22 68.2,28.21 59.56,28.21 58.56,29.21 58.56,31.08 59.19,31.71 59.88,31.71 60.5,32.33 60.5,32.74 60.09,33.14 58.06,33.14 57.26,33.94 v1(51.82,33.94)
  BOTTOM w0.147: R546.1 v1(69.19,18.23) R524.1 ; U91.14 51.84,33.91 v1(51.82,33.94)
TEST_GPIO3: length 92
  TOP w0.147: TP41.1 68.05,18.66 v1(68.05,18.23) 68.05,15.48 66.17,13.6 54.74,13.6 53.59,12.46 J30.1
  L03_SIG1 w0.091: v1(68.05,18.23) 69.12,17.16 89.21,17.16 94.33,12.05 102.65,12.05 108.54,17.94 108.54,22.88 111.1,25.44 111.1,29.95 111.79,30.65 111.79,36.05 v1(111,36.84)
  BOTTOM w0.147: R525.1 v1(68.05,18.23) R547.1 ; U90.2 110.39,37.61 110.41,37.62 R439.2 v1(111,36.84)
TEST_GPIO4: length 38.8
  TOP w0.147: v1(66.9,18.23) 66.9,18.91 TP40.1
  L08_SIG2 w0.091: v1(96.9,18.86) 92.39,14.35 79.55,14.35 74.39,19.51 68.18,19.51 v1(66.9,18.23)
  BOTTOM w0.147: U96.28 97.4,19.36 v1(96.9,18.86) ; R548.1 v1(66.9,18.23) R526.1
TEST_LED1: length 71.3
  L08_SIG2 w0.091: v1(103.8,16.42) 103.02,16.42 98.82,20.62 94.13,20.62 91.61,18.11 81.68,18.11 78.71,21.08 65.53,21.08 58.42,28.19 53.34,28.19 52.7,28.83 52.7,33.66 51.94,34.42 51.56,34.42 51.31,34.67 51.31,35.69 v1(52.2,36.58)
  BOTTOM w0.147: R553.2 R549.2 v1(103.8,16.42) ; v1(52.2,36.58) 52.95,36.58 53.49,36.03 U91.17
TEST_LED2: length 279.6
  TOP w0.147: U23.A7 99.54,80.3 99.56,80.29 101.57,80.29 v1(101.96,80.68)
  L03_SIG1 w0.091: J1.7 147.01,126.32 147.01,121.25 147.36,120.89 153.36,120.89 154.62,119.64 154.62,104.61 150.5,100.48 150.5,89.3 148.46,87.26 148.46,58.69 149.61,57.55 149.61,50.56 v1(156.21,43.96)
  L08_SIG2 w0.091: v1(156.21,43.96) 156.21,40.78 155.19,39.77 155.19,18.81 152.65,16.27 152.65,11.44 152.15,10.94 147.83,10.94 146.2,12.56 117.27,12.56 113.56,16.27 106.81,16.27 105.13,14.59 95.73,14.59 95.38,14.25 v1(93.95,14.25) ; v1(101.96,80.68) 108.23,86.94 108.23,89.94 110.94,92.66 112.08,92.66 116.79,97.37 116.79,116.39 122.45,122.05 140.26,122.05 142.15,123.93 144.62,123.93 J1.7
  BOTTOM w0.147: v1(93.95,14.25) R554.2 R552.2
TEST_PORZN: length 66.2
  TOP w0.147: v1(130.36,22.45) Q9.1
  L08_SIG2 w0.091: v1(72.62,18.23) 73.23,18.85 74.11,18.85 79.28,13.69 92.67,13.69 93.79,14.81 104.94,14.81 106.7,16.56 113.53,16.56 117.13,20.16 122.72,20.16 124.16,21.6 129.52,21.6 v1(130.36,22.45)
  BOTTOM w0.147: R543.1 v1(72.62,18.23) R521.1
TEST_POWERDOWN: length 140.5
  L08_SIG2 w0.091: v1(170.45,49.18) 170.45,43.01 171.42,42.04 171.42,17.3 163.79,9.67 144.27,9.67 141.63,12.31 117.12,12.31 113.41,16.02 106.93,16.02 104.39,13.48 96.9,13.48 96.65,13.73 93.73,13.73 93.43,13.43 78.56,13.43 v1(73.76,18.23)
  BOTTOM w0.147: R412.1 v1(170.45,49.18) ; v1(73.76,18.23) R542.1
TEST_WARMRESETN: length 63.1
  TOP w0.147: Q10.1 v1(126.17,22.42)
  L08_SIG2 w0.091: v1(126.17,22.42) 125.68,21.93 124.16,21.93 124.06,21.82 124.06,21.81 122.63,20.39 117.04,20.39 113.44,16.78 106.61,16.78 105.58,15.76 94.46,15.76 92.61,13.91 79.37,13.91 74.2,19.07 72.31,19.07 v1(71.47,18.23)
  BOTTOM w0.147: R544.1 v1(71.47,18.23) R522.1
TM4C129_TCK: length 3.9
  TOP w0.147: TP37.1 157.95,31.33 U59.100
TM4C129_TDI: length 4.1
  TOP w0.147: U59.98 158.75,32.2 TP36.1
TM4C129_TDO: length 2.8
  TOP w0.147: U59.97 159.15,30.7 159.68,31.23 TP38.1
TM4C129_TMS: length 3.5
  TOP w0.147: U59.99 158.35,32.33 TP35.1
TMP1_ADD0: length 3.2
  TOP w0.147: U18.5 R72.2 R68.2
TMP1_ADD1: length 3.1
  TOP w0.147: R98.2 R93.2 U18.3
TMP2_ADD0: length 3.1
  TOP w0.147: U29.5 R133.2 R132.1
TMP2_ADD1: length 3.1
  TOP w0.147: U29.3 121.48,68.75 121.41,68.82 R125.2 R124.2
USB0_AB_DM: length 8.5
  TOP w0.107: J24.2 4.87,53.58 5.14,53.85 5.68,53.85 v1(5.91,53.62)
  BOTTOM w0.107: FL22.4 6.95,56.93 6.68,56.66 6.27,56.66 5.95,56.34 5.95,55.55 5.06,54.66 5.06,54.12 5.36,53.82 5.71,53.82 v1(5.91,53.62) 6.18,53.9 6.66,53.9 U38.1
USB0_AB_DP: length 8.5
  TOP w0.107: v1(5.91,54.44) 5.98,54.44 6.04,54.38 6.04,54.17 5.94,54.07 5.03,54.07 4.87,54.23 J24.3
  BOTTOM w0.107: U38.2 6.63,54.12 6.23,54.12 v1(5.91,54.44) 5.91,54.16 5.79,54.04 5.45,54.04 5.28,54.21 5.28,54.57 6.17,55.46 6.17,56.25 6.36,56.44 6.64,56.44 6.95,56.13 FL22.3
USB0_AB_ID: length 111.6
  TOP w0.147: J24.4 5.64,54.88 5.94,55.18 v1(6.73,55.18) ; U23.U16 v1(85.86,72.7)
  L03_SIG1 w0.203: v1(6.73,55.18) 6.73,49.24 6.15,48.66 3.73,48.66 J23.5
  L08_SIG2 w0.091: v1(85.86,72.7) 85.64,72.7 85.24,72.3 83.97,72.3 83.44,71.77 82.77,71.77 82.3,71.29 82.3,71.27 82.29,71.26 82.29,70.95 82.3,70.94 82.3,70.55 81.53,69.78 81.53,69.46 79.52,67.45 77.22,67.45 76.09,68.58 75.34,68.58 75.16,68.76 70.05,68.76 69.65,69.16 65.55,69.16 63.86,67.47 63.86,63.11 63.3,62.54 63.3,61.8 63.16,61.66 63.16,60.62 59.11,56.57 58.84,56.57 v1(58.57,56.31)
  BOTTOM w0.147: U38.3 6.77,55.14 v1(6.73,55.18) 7.19,55.18 7.44,55.44 8.18,55.44 10.62,53 34.68,53 37.52,50.16 41.63,50.16 42.34,50.88 52.83,50.88 57.75,55.8 58.06,55.8 v1(58.57,56.31)
USB0_DM: length 94.6
  TOP w0.14: U23.AA20 v1(82.66,69.5)
  L08_SIG2 w0.094: v1(58.59,54.53) 58.8,54.73 59.98,54.73 60.65,55.41 60.65,57 63.8,60.15 63.8,61.39 64.5,62.09 64.5,67.2 65.82,68.52 69.31,68.52 69.71,68.12 74.9,68.12 76.29,66.72 80.76,66.72 82.04,68.01 82.04,69.66 82.16,69.78 82.38,69.78 v1(82.66,69.5)
  BOTTOM w0.107: v1(58.59,54.53) 58.8,54.74 59.37,54.74 59.83,55.19 59.83,56.26 58.44,57.66 52.68,57.66 52.34,58 41.39,58 37.59,54.21 14.54,54.21 12.11,56.64 10.31,56.64 10.01,56.93 FL22.1
USB0_DP: length 94.5
  TOP w0.14: U23.AA19 v1(82.66,70.3)
  L08_SIG2 w0.094: v1(82.66,70.3) 82.38,70.03 82.06,70.03 81.8,69.76 81.8,68.11 80.66,66.97 76.39,66.97 75,68.36 69.81,68.36 69.41,68.76 65.71,68.76 64.26,67.3 64.26,62.19 63.55,61.49 63.55,60.25 60.41,57.1 60.41,55.51 59.88,54.98 58.55,54.98 58.45,55.07 58.45,55.21 v1(58.59,55.35)
  BOTTOM w0.107: v1(58.59,55.35) 58.59,55.06 58.7,54.96 59.28,54.96 59.61,55.29 59.61,56.17 58.35,57.44 52.59,57.44 52.25,57.78 41.48,57.78 37.68,53.99 14.45,53.99 12.02,56.42 10.31,56.42 10.01,56.13 FL22.2
USB0_DRVBUS: length 123.5
  TOP w0.147: v1(93.34,49.17) 93.34,48.43 92.33,47.43 91.32,47.43 77.98,34.09 62.94,34.09 60.99,36.04 60.99,40.01 61.42,40.44 61.42,46.91 60.6,47.73 57.71,47.73 57,47.02 55.37,47.02 53.87,45.52 51.35,45.52 50.92,45.09 46.1,45.09 44.42,46.76 43.66,46.76 43.13,46.23 39.67,46.23 39.09,45.64 36.96,45.64 36.45,46.15 34.57,46.15 33.99,45.57 30.76,45.57 27.1,49.23 27.1,55.04 27.83,55.77 U36.4 30.18,55.77 30.3,55.64 R151.1 ; U23.E19 v1(96.26,70.3)
  BOTTOM w0.147: v1(93.34,49.17) 97.44,53.27 97.44,62.58 96.6,63.42 96.6,66.43 96.75,66.58 96.75,67.81 96.26,68.3 v1(96.26,70.3)
USB0_RCALIB: length 16.5
  TOP w0.147: U23.U17 v1(85.86,71.9)
  L03_SIG1 w0.091: v1(85.86,71.9) 85.7,71.9 85.32,71.52 84.9,71.52 84.64,71.26 84.64,70.95 84.42,70.72 81.82,70.72 81.68,70.87 75.43,70.87 74.88,71.41 74.88,71.98 74.76,72.1 74.76,72.65 v1(75.23,73.13)
  BOTTOM w0.147: R605.1 74.13,72.75 TP67.1 75.23,73.24 v1(75.23,73.13)
USB0_VBUS: length 11.4
  TOP w0.381: J24.1 5.23,52.93 5.33,52.82
  BOTTOM w0.254: J23.1 5.94,45.79 5.94,43.45 5.61,43.12 3.23,43.12 2.94,42.83 R428.1 ; v1(5.92,52.72) 6.77,52.72 7.37,53.33 U38.6
USB1_SHIELD: length 4.2
  TOP w0.508: J24.9 v1(2.73,54.23)
  L03_SIG1 w0.508: 2.79,58.31 2.79,58.32 J24.10 ; 2.59,50.23 2.5,50.14 J24.8
  vias: v1(3.3,49.9) v1(4.19,50.79) v1(4.47,58.99)
VCOMH: length 3
  BOTTOM w0.254: J36.2 5.75,16.31 6.3,15.76 C473.1
VIO_CAN: length 19.4
  TOP w0.381: v1(26.03,126.68) C8.1 U4.5 ; U3.5 15.4,125.78 15.54,125.64 C3.1 16.26,124.71 16.47,124.5 FB1.2 16.13,122.87 v1(16.13,122.32)
  BOTTOM w0.147: v1(16.13,122.32) 17.78,123.97 19.05,123.97 21.77,126.68 v1(26.03,126.68)
VMAIN: length 54.1
  TOP w0.254: U17.1 149.3,92.45 149.08,92.23 C65.2
  TOP w0.305: U30.25 157.99,61.48 157.92,61.56 157.3,61.56 156.41,60.67 C123.1 v1(155.83,61.61)
  TOP w0.381: R80.2 172.97,95.77
  L03_SIG1 w0.254: v1(139.57,73.28) 139.19,72.9 136.4,72.9 134.75,74.55 v1(120.02,74.55)
  L08_SIG2 w0.254: v1(139.57,73.28) 144.16,73.28 v1(155.83,61.61)
  BOTTOM w0.254: v1(120.02,74.55) 119.51,75.06 R604.1 ; v1(58.04,26.68) 58.17,26.56 58.8,26.56 59.05,26.3 R500.1 ; 58.04,24.02 58.05,24.01 U97.2 ; R408.2 v1(172.34,52.08)
  vias: v1(57.02,26.68) v1(57.53,27.32) v1(57.53,26.18) v1(160.43,83.47) v1(160.43,82.45) v1(160.43,81.43) v1(161.44,83.47) v1(161.44,82.45) v1(161.44,81.43) v1(161.65,89.82) v1(161.65,88.61) v1(162.59,83.47) v1(162.59,82.45) v1(162.59,81.43) v1(162.86,89.82) v1(162.86,88.61) v1(163.6,83.47) v1(163.6,82.45) v1(163.6,81.43) v1(164.08,89.82) v1(164.08,88.61) v1(165.07,90.82) v1(165.07,89.88) v1(165.07,88.66) v1(166.29,90.82) v1(166.29,89.88) v1(166.29,88.66) v1(167.51,91.1) v1(167.51,89.88) v1(167.51,88.66) v1(168.73,91.1) v1(168.73,89.88) v1(168.73,88.66) v1(169.95,91.1) v1(169.95,89.88) v1(169.95,88.66) v1(171.17,91.1) v1(171.17,89.88) v1(171.17,88.66)
VMAIN_EN: length 13.1
  TOP w0.254: R577.1 164.47,55.59 165.35,54.7 165.35,52.85 166.12,52.08 SW1.2
  BOTTOM w0.254: R408.1 SW1.2 ; R408.1 170.45,51.44 170.95,50.94 171.2,50.94 171.43,50.71 R412.2 ; R408.1 C406.1
VPHY_3V3_FT4232: length 3.9
  BOTTOM w0.254: C425.2 133.33,40.44 U87.4
  BOTTOM w0.381: FB24.1 131.63,40.93 C425.2
VPLL_3V3_FT4232: length 6.8
  BOTTOM w0.254: U87.9 133.59,42.94 133.49,42.83 C422.2 132.32,42.83 132.21,42.94 FB23.1
  BOTTOM w0.381: R417.2 130.41,44.74 131.4,43.75 FB23.1
VPP_1V8: length 93.3
  TOP w0.147: U23.G15 v1(94.66,73.5)
  L05_PWR1 w0.114: 98.15,72.3 95.1,72.3 95.1,72.3 94.49,72.3 94.26,72.54 94.26,73.1 v1(94.66,73.5) 95.06,73.1 98.23,73.1 98.42,72.91 98.42,72.9 98.42,72.02 98.15,72.3
  L05_PWR1 w0.381: TP52.1 140.46,101.92 139.55,101 139.55,99.35 136,95.8 129.95,95.8 127.64,93.49 127.64,84.98 126.36,83.71 123.06,83.71 119.25,87.52 111.51,87.52 110.13,86.14 110.13,84.35 111,83.49 111,82.06 110.24,81.29 109.6,81.29 109.09,80.79 109.09,77.74 109.73,77.1 109.73,75.07 110.62,74.18 110.62,70.75 110.24,70.37 105.28,70.37 104.42,69.51 100.05,69.51 98.93,70.63 98.93,71.52 98.42,72.02
  BOTTOM w0.254: 141.82,105.04 142.17,104.7 U72.1 141.9,102.92 141.55,102.92 141.44,102.81 141.04,102.81
VPP_DDR_2V5: length 21
  BOTTOM w0.508: 81.28,110.63 81.28,119.52 82.55,120.79 88.52,120.79 TP47.1
VPP_LDO_EN: length 197.8
  TOP w0.147: v1(132.08,23.13) 132.08,27.19 130.94,28.34 130.94,31.89 132.5,33.45 146.47,33.45 149.22,36.21 149.22,37.35 150.37,38.5 151.51,38.5 153.67,40.65 153.67,42.94 152.15,44.46 v1(150.75,44.46)
  L03_SIG1 w0.091: v1(145.03,99.84) 144.34,99.15 144.34,93.89 142.88,92.42 142.88,58.18 146.81,54.24 146.81,48.4 v1(150.75,44.46)
  L08_SIG2 w0.091: v1(132.08,23.13) 131.65,23.56 123.49,23.56 122.05,22.11 115.19,22.11 111.36,18.28 102.19,18.28 99.41,21.06 93.77,21.06 91.34,18.62 81.92,18.62 77.25,23.29 64.3,23.29 60.74,26.85 60.74,26.91 52.7,34.94 v1(51.82,34.94)
  BOTTOM w0.147: R582.2 R263.2 145.54,101.11 TP53.1 145.16,99.96 v1(145.03,99.84) ; v1(51.82,34.94) 51.84,34.91 U91.16
VREF: length 9.6
  TOP w0.203: U59.9 143.86,24.73 143.66,24.54
  TOP w0.381: 143.66,24.54 C180.1 v1(142.39,24)
  BOTTOM w0.254: R505.2 141.48,24 v1(142.39,24) ; C180.1 143.78,24 144.11,23.67 U95.3
  BOTTOM w0.381: v1(142.39,24) C180.1
VSENSE: length 12.9
  TOP w0.254: v1(145.59,95.88) 145.59,95.86 146.07,95.38 U17.6
  BOTTOM w0.381: R294.1 R279.2 C272.2 150.98,95.41 150.12,96.28 145.99,96.28 v1(145.59,95.88)
XDS110_DIR: length 3.8
  BOTTOM w0.147: U98.2 124.9,57.92 124.64,58.19 R507.2 125.31,59.14 125.82,58.63 U98.3
XDS110_EMU0: length 24.5
  TOP w0.147: v1(148.59,11.7) 148.95,12.06 R202.2 149.56,12.06 150.35,12.85 U59.42 ; U55.8 v1(137.03,26.81)
  L08_SIG2 w0.091: v1(137.03,26.81) 140.92,22.92 141.53,22.92 146.94,17.51 146.94,12.75 147.99,11.7 v1(148.59,11.7)
XDS110_EMU1: length 24.1
  TOP w0.147: v1(151.49,12.06) R203.2 150.79,12.52 150.75,12.56 U59.43 ; U55.1 v1(137.03,23.51)
  L08_SIG2 w0.091: v1(151.49,12.06) 150.69,11.26 148.01,11.26 146.69,12.59 146.69,14.38 137.56,23.51 v1(137.03,23.51)
XDS110_TCK: length 83.2
  TOP w0.147: U59.35 147.55,15.05 147.52,15.09 147.52,15.63 147.7,15.82 v1(147.7,16.27)
  BOTTOM w0.147: U98.12 126.82,53.49 125.64,52.31 125.64,50.89 123.98,49.23 123.98,48.08 122.78,46.89 122.78,34.08 119.28,30.57 119.28,26.76 113.1,20.58 113.1,15.78 115.17,13.71 144.24,13.71 146.8,16.27 v1(147.7,16.27)
XDS110_TDI: length 82.7
  TOP w0.147: U59.38 v1(148.75,12.87)
  BOTTOM w0.147: U98.13 126.32,53.41 125.35,52.43 125.35,51.01 123.6,49.26 123.6,48.18 122.49,47.08 122.49,34.2 118.99,30.7 118.99,26.89 112.81,20.71 112.81,15.66 115.05,13.42 148.21,13.42 v1(148.75,12.87)
XDS110_TDO: length 62.6
  TOP w0.147: U56.7 120.3,53.66 v1(120.26,53.7) ; v1(147.96,12.33) 148.27,12.65 148.27,13.04 148.35,13.11 U59.37
  L03_SIG1 w0.091: v1(147.96,12.33) 146.53,13.76 146.53,16.26 142.44,20.35 131.37,20.35 125.07,26.64 125.07,49.23 121.67,52.63 120.93,52.63 120.26,53.3 v1(120.26,53.7)
XDS110_TMS: length 84.1
  TOP w0.147: v1(148,15.38) 147.95,15.33 U59.36
  BOTTOM w0.147: v1(148,15.38) 148.36,15.74 148.36,16.64 148.2,16.8 146.78,16.8 143.99,14.01 115.3,14.01 113.4,15.91 113.4,20.46 119.58,26.64 119.58,30.36 123.15,33.93 123.15,46.7 125.26,48.81 125.26,49.25 125.43,49.42 125.94,49.92 127.32,51.31 U98.11
XDS110_TRST#: length 87.2
  TOP w0.147: U59.40 v1(149.55,12.84)
  BOTTOM w0.147: v1(149.55,12.84) 149.89,13.18 149.89,15.82 148.62,17.09 146.66,17.09 143.87,14.3 115.42,14.3 113.69,16.03 113.69,20.34 119.87,26.52 119.87,30.23 123.44,33.81 123.44,46.58 125.55,48.69 125.55,49.12 127.82,51.39 U98.10
XDS_RSTN: length 3.3
  TOP w0.147: U59.70 161.51,17.53 161.78,17.79 R199.1 R198.1
XDS_USB_DM: length 24.7
  TOP w0.107: U58.5 170.88,23.38 171.02,23.24 171.22,23.24 171.32,23.35 171.32,23.76 171.58,24.02 171.89,24.02 v1(172.25,24.37) 172.55,24.07 172.84,24.07 173.05,24.29 J28.2 ; U59.93 159.66,26.73 159.59,26.8 158.48,26.8 158.37,26.69 v1(158.37,26.52)
  BOTTOM w0.107: v1(158.37,26.52) 158.47,26.52 158.58,26.63 158.58,26.8 158.48,26.9 157.88,26.9 157.57,26.59 157.57,25.63 158.49,24.71 166.75,24.71 167.39,24.07 171.95,24.07 v1(172.25,24.37)
XDS_USB_DP: length 24.7
  TOP w0.107: J28.3 173.04,23.64 172.82,23.85 172.55,23.85 v1(172.25,23.55) 172,23.8 171.67,23.8 171.54,23.67 171.54,23.26 171.31,23.02 171.03,23.02 170.89,22.88 U58.4 ; U59.94 159.66,27.13 159.56,27.02 158.69,27.02 v1(158.37,27.34)
  BOTTOM w0.107: v1(172.25,23.55) 171.95,23.85 167.3,23.85 166.66,24.49 158.4,24.49 157.35,25.54 157.35,26.68 157.79,27.12 158.15,27.12 v1(158.37,27.34)
XDS_USB_ID: length 22.2
  TOP w0.147: U58.2 v1(169.16,23.38)
  TOP w0.254: v1(171.96,22.62) 172.32,22.99 J28.4
  BOTTOM w0.147: v1(169.16,23.38) 169.93,23.38 170.69,22.62 v1(171.96,22.62) 172.72,22.62 173.23,23.13 173.23,25.03 172.47,25.8 168.28,25.8 167.39,26.68 165.74,26.68 164.98,27.44 R478.2
XDS_USB_VBUS: length 6.4
  TOP w0.147: v1(170.43,24.83) 170.43,24.38 170.5,24.31 U58.6
  TOP w0.254: J28.1 172.67,24.94 v1(172.47,25.14) ; v1(165.61,12.59) 165.61,12.31 166.02,11.9 U61.2 ; U61.8 v1(171.03,12.55)
  BOTTOM w0.254: v1(162.26,31.38) 162.22,31.34 R467.1 ; v1(143.64,31.38) 143.68,31.34 R469.1
  vias: v1(164.47,13.6) v1(164.59,12.84)
N5126260: length 13.1
  TOP w0.147: v1(35.94,97.04) 36.39,97.04 36.49,97.14 U15.13 ; TP11.1 34.28,104.73 v1(35.81,104.73) U15.48
  L03_SIG1 w0.091: v1(35.94,97.04) 35.94,97.48 35.81,97.61 v1(35.81,104.73)
N15202140: length 2.3
  TOP w0.147: U59.95 v1(159.3,27.53)
  BOTTOM w0.147: v1(159.3,27.53) 159.39,27.44 R478.1
N15204440: length 14.2
  TOP w0.254: U61.5 169.95,8.93 169.21,8.19 163.53,8.19 162.94,8.78 162.94,9.52 C198.2 R204.2 v1(162.05,10.81)
  BOTTOM w0.254: C198.2 162.35,9.54 162.05,9.84 v1(162.05,10.81)
N15205319: length 3.2
  TOP w0.147: R200.1 163.31,16.52 163.29,16.5 C193.2 161.95,16.5 161.72,16.73 U59.68
N15212041: length 4.2
  TOP w0.147: R205.1 155.56,11.17 155.56,11.41 157.15,13.01 U59.59
N15239696: length 3.2
  TOP w0.147: U59.96 160.65,28.58 v1(160.91,28.84)
  BOTTOM w0.147: v1(160.91,28.84) 160.91,28.89 160.99,28.97 C447.2 R467.2
N15241750: length 3.2
  TOP w0.147: U59.1 145.25,28.63 v1(145.03,28.84)
  BOTTOM w0.147: R469.2 R468.1 144.91,28.97 v1(145.03,28.84)
N15242949: length 6.6
  TOP w0.147: v1(140.95,28.49) 141.48,27.95 143.38,27.95 144.21,27.13 U59.3
  BOTTOM w0.147: R466.1 v1(140.95,28.49)
N15242980: length 2.7
  TOP w0.147: v1(141.99,28.97) 142.19,29.18 LD22.2
  BOTTOM w0.147: v1(141.99,28.97) 141.86,29.1 141.86,30.17 R466.2
N15243226: length 10.2
  TOP w0.147: v1(140.08,29.22) 140.08,28.59 141.1,27.57 143.26,27.57 144.1,26.73 U59.4
  BOTTOM w0.147: v1(140.08,29.22) 140.08,31 140.82,31.74 R462.1
N15365714: length 4.4
  BOTTOM w0.147: J38.27 70.41,15.12 71.15,15.85 72.48,15.85 72.62,15.99 R543.2
N15365947: length 3.3
  BOTTOM w0.147: J38.30 68.91,14.87 69.82,15.78 69.82,16.07 70.29,16.54 R545.2
N15366015: length 3
  BOTTOM w0.147: R546.2 69.19,15.79 68.41,15.01 J38.31
N15366091: length 2.7
  BOTTOM w0.147: J38.32 67.91,15.13 68.05,15.26 R547.2
N15507744: length 1.6
  TOP w0.147: C159.2 165.74,35.34 U43.2
N15584817: length 2.2
  TOP w0.147: SW2.13 v1(87,28.21)
  BOTTOM w0.147: R508.1 v1(87,28.21)
N15584821: length 2.2
  TOP w0.147: SW2.14 v1(85.73,28.21)
  BOTTOM w0.147: R512.1 v1(85.73,28.21)
N15584825: length 2.2
  TOP w0.147: SW2.15 v1(84.46,28.21)
  BOTTOM w0.147: R517.1 v1(84.46,28.21)
N15584829: length 2.2
  TOP w0.147: SW2.16 v1(83.19,28.21)
  BOTTOM w0.147: R527.1 v1(83.19,28.21)
N15591045: length 2.2
  TOP w0.147: SW2.9 v1(92.07,28.21)
  BOTTOM w0.147: R472.1 v1(92.07,28.21)
N15591049: length 2.2
  TOP w0.147: SW2.10 v1(90.8,28.21)
  BOTTOM w0.147: R487.1 v1(90.8,28.21)
N15591053: length 2.2
  TOP w0.147: SW2.11 v1(89.53,28.21)
  BOTTOM w0.147: R496.1 v1(89.53,28.21)
N15591057: length 2.2
  TOP w0.147: SW2.12 v1(88.27,28.21)
  BOTTOM w0.147: R501.1 v1(88.27,28.21)
N15854407: length 1.9
  TOP w0.147: U14.3 126.62,106.42 R43.1
N15854417: length 5.3
  TOP w0.147: U14.8 126.62,98.79 126.89,98.52 ; R73.1 126.32,97.91 126.34,97.93 C47.2 126.89,98.52 ; 126.89,98.52 127.12,98.75 U14.9
N15854427: length 3.8
  TOP w0.147: R74.1 128.7,97.91 128.68,97.93 C47.1 127.87,98.57 127.62,98.82 U14.10
N15854463: length 1.8
  TOP w0.147: U6.3 R28.1
N15854467: length 7.8
  TOP w0.147: U6.9 150.12,122.05 150.24,121.93 150.5,121.93 150.62,122.06 U6.8 150.62,124.22 150.49,124.35 v1(150.24,124.35)
  BOTTOM w0.147: R216.1 149.29,122.51 149.61,122.82 C204.2 150.18,123.84 150.24,123.9 v1(150.24,124.35)
N15854483: length 6.7
  TOP w0.147: v1(150.24,125.11) 149.62,124.49 U6.10
  BOTTOM w0.147: v1(150.24,125.11) 151.16,124.19 C204.1 151.76,122.82 152.04,122.55 R215.1
N15854545: length 2.8
  TOP w0.147: U11.3 v1(147.19,108.22)
  BOTTOM w0.147: R244.1 146.62,108.09 146.74,108.22 v1(147.19,108.22)
N15854547: length 1.7
  TOP w0.147: U28.3 138.56,72.91 138.54,72.93 R122.1
N15854553: length 33.1
  TOP w0.147: v1(139.84,107.72) U11.9 142.24,107.72 142.37,107.85 142.37,108.09 142.24,108.22 U11.8
  BOTTOM w0.147: R229.1 131.08,115.84 C214.2 129.67,116.85 128.78,115.97 128.78,113.93 127.76,112.92 126.62,112.92 125.86,112.16 125.86,107.58 126.15,107.29 138.39,107.29 139.14,108.04 139.51,108.04 v1(139.84,107.72)
N15854557: length 10.5
  TOP w0.147: v1(138.94,68.59) 139.06,68.48 U28.9 139.06,66.42 138.95,66.31 138.69,66.31 138.56,66.44 U28.8
  BOTTOM w0.147: v1(138.94,68.59) 138.94,67.56 C393.2 138.83,67.09 138.56,66.82 135.96,66.82 134.47,68.3 R350.1
N15854581: length 9
  TOP w0.147: v1(139.95,68.59) 139.56,68.2 U28.10
  BOTTOM w0.147: R352.1 135.13,66.94 135.64,66.44 139.57,66.44 139.83,66.69 139.83,66.84 139.81,66.86 C393.1 139.81,68.45 v1(139.95,68.59)
N15854603: length 33.7
  TOP w0.147: v1(139.32,107.33) 139.43,107.22 U11.10
  BOTTOM w0.147: v1(139.32,107.33) 138.98,106.99 125.95,106.99 125.35,107.58 125.35,112.28 126.62,113.55 127.64,113.55 128.27,114.19 128.27,116.6 129.41,117.74 131.83,117.74 132.06,117.51 C214.1 132.06,116.18 132.68,115.57 R228.1
N15854737: length 1.8
  TOP w0.147: U1.3 R1.1
N15854741: length 5.7
  TOP w0.147: R11.1 86.36,123.19 U1.8 86.36,125.24 v1(86.74,125.62) 86.86,125.5 U1.9
  BOTTOM w0.147: v1(86.74,125.62) 86.42,125.3 86.42,125.03 86.51,124.94 C203.2
N15854757: length 5.4
  TOP w0.147: v1(87.63,125.62) 87.36,125.35 U1.10 87.36,123.31 87.38,123.29 87.38,123.2 87.52,123.06 R10.1
  BOTTOM w0.147: v1(87.63,125.62) 87.48,125.47 C203.1
N15854857: length 2.1
  TOP w0.254: R12.2 131.7,124.73
N15854859: length 2.4
  TOP w0.254: R13.2 129.29,123.42 129.16,123.55 J4.1
N16248811: length 3.3
  TOP w0.147: R60.1 v1(60.45,102)
  BOTTOM w0.147: U70.20 59.94,103.14 60.07,103.01 60.07,102.38 v1(60.45,102) R60.1
N16248833: length 3.4
  TOP w0.147: R61.1 v1(61.72,102)
  BOTTOM w0.147: U70.18 60.94,103.16 61.21,102.88 61.21,102.5 v1(61.72,102) R61.1
N16248855: length 6.5
  TOP w0.147: R65.1 v1(62.99,101.23)
  BOTTOM w0.147: R272.1 63.72,100.34 63.61,100.45 R65.1 v1(62.99,101.23) 62.99,103.01 62.24,103.76 U70.17
N16248877: length 2.8
  BOTTOM w0.147: U70.8 61.44,109.62 61.82,110 61.98,110 62.48,110.5 R235.1
N16248899: length 2.4
  BOTTOM w0.147: R236.1 61.21,110.7 60.94,110.43 U70.7
N16248921: length 2.3
  BOTTOM w0.147: U70.5 59.94,110.7 59.94,110.7 R237.1
N16248943: length 2.4
  BOTTOM w0.147: U70.3 58.94,110.43 58.67,110.7 R238.1
N16248965: length 2.5
  BOTTOM w0.147: R239.1 57.4,110.5 57.94,109.97 U70.1
N16303893: length 2.2
  TOP w0.147: SW3.11 v1(109.3,28.23)
  BOTTOM w0.147: v1(109.3,28.23) R515.1
N16303897: length 2.2
  TOP w0.147: SW3.12 v1(108.03,28.23)
  BOTTOM w0.147: v1(108.03,28.23) R511.1
N16303901: length 2.2
  TOP w0.147: SW3.13 v1(106.76,28.23)
  BOTTOM w0.147: v1(106.76,28.23) R504.1
N16303905: length 2.2
  TOP w0.147: SW3.14 v1(105.49,28.23)
  BOTTOM w0.147: v1(105.49,28.23) R499.1
N16303921: length 2.2
  TOP w0.147: SW3.9 v1(111.84,28.23)
  BOTTOM w0.147: v1(111.84,28.23) R530.1
N16303925: length 2.2
  TOP w0.147: SW3.10 v1(110.57,28.23)
  BOTTOM w0.147: v1(110.57,28.23) R520.1
N16679303: length 4.5
  TOP w0.147: v1(156.51,11.57) 157.55,12.62 U59.60
  TOP w0.203: v1(156.51,11.57) R206.2
  BOTTOM w0.203: v1(156.51,11.57) R206.2
N16679944: length 5
  TOP w0.147: v1(160.32,11.66) 159.86,11.66 158.75,12.77 U59.63
  TOP w0.203: v1(160.32,11.66) R209.2
  BOTTOM w0.203: v1(160.32,11.66) R209.2
N16679981: length 4.1
  TOP w0.147: U59.61 157.95,12.55 157.78,12.38 v1(157.78,11.57)
  TOP w0.203: v1(157.78,11.57) R207.2
  BOTTOM w0.203: v1(157.78,11.57) R207.2
N16680014: length 4.4
  TOP w0.147: v1(159.05,11.66) 158.35,12.35 U59.62
  TOP w0.203: R208.2 v1(159.05,11.66)
  BOTTOM w0.203: v1(159.05,11.66) R208.2
N16753626: length 4.8
  BOTTOM w0.147: J33.6 63.72,39.42 65.02,38.12 65.02,37.68 65.49,37.21 R449.2
N16753680: length 4.3
  BOTTOM w0.147: R409.2 65.39,50.2 66.22,49.36 J33.15
N16754334: length 5.9
  BOTTOM w0.147: R447.2 68.03,37.21 67.15,38.09 66.01,38.09 65.22,38.88 J33.12
N16756061: length 1.5
  TOP w0.147: R685.1 76.35,41.48 76.32,41.51 J25.2
N16814557: length 1.4
  BOTTOM w0.147: R445.2 153,38 U89.5
N16814563: length 2.2
  BOTTOM w0.147: U89.4 153.76,39.42 154.05,39.13 154.05,38.64 R438.1
N16814605: length 2.4
  BOTTOM w0.147: R400.2 133.88,54.26 134.78,53.36 U84.5
N16814611: length 2.2
  BOTTOM w0.147: U84.4 133.65,52.56 133.1,53.1 R406.1
N16814651: length 2
  BOTTOM w0.147: U82.5 141.29,54.43 141.08,54.64 R397.2
N16814659: length 2.4
  BOTTOM w0.147: R403.1 140.22,54.62 140.34,54.51 140.34,54.12 140.62,53.83 U82.4
N16879988: length 2.8
  TOP w0.147: R38.1 94.69,106.84 U13.F9
N16880168: length 7.1
  TOP w0.147: TP15.1 97.03,95.65 96.79,95.89 95.8,95.89 95.69,95.99 95.69,96.35 95.18,96.86 93.4,96.86 92.57,97.69 92.57,97.7 92.4,97.86 U13.T7
N16887346: length 7.4
  TOP w0.147: U23.H5 v1(93.86,82.3)
  BOTTOM w0.114: 98.81,81.1 96.07,81.1 95.86,81.31 95.86,81.34 95.86,81.65 95.86,81.65 95.86,81.67 95.62,81.9 94.45,81.9 94.05,82.3 v1(93.86,82.3)
  BOTTOM w0.147: R320.1 99.13,80.79 98.81,81.1
N16887366: length 0.6
  TOP w0.147: U23.K2 v1(92.26,84.7)
N16887368: length 4.4
  TOP w0.147: U23.K1 91.84,85.12 91.84,85.76 93.58,87.5 v1(94.87,87.5)
N16887377: length 0.6
  TOP w0.147: U23.H3 v1(93.86,83.9)
N16887386: length 0.6
  TOP w0.147: U23.F3 v1(95.46,83.9)
N16887395: length 0.6
  TOP w0.147: U23.E4 v1(96.26,83.1)
N16887404: length 0.6
  TOP w0.147: U23.F5 v1(95.46,82.3)
N16937764: length 1.8
  TOP w0.147: R147.1 86.87,51.9 86.69,51.72 U37.5
N16938293: length 1.5
  BOTTOM w0.147: R506.1 126.82,58.68 126.82,58.68 U98.5
N17211229: length 2.9
  BOTTOM w0.147: J38.33 67.41,15.31 66.9,15.82 R548.2
N17247526: length 2.3
  TOP w0.147: LD16.2 v1(36.35,75.93)
  BOTTOM w0.147: v1(36.35,75.93) R421.2
N17247539: length 2.5
  TOP w0.147: LD17.2 v1(34.32,75.93)
  BOTTOM w0.147: R420.2 34.82,75.3 34.64,75.48 34.64,75.61 v1(34.32,75.93)
N17247599: length 2.3
  TOP w0.147: LD18.2 v1(32.28,75.9)
  BOTTOM w0.147: R419.2 v1(32.28,75.9)
N17247637: length 2.4
  TOP w0.147: LD19.2 v1(30.25,75.95)
  BOTTOM w0.147: R418.2 v1(30.25,75.95)
N17247662: length 2.2
  TOP w0.147: LD14.2 52.12,71.4 v1(51.99,71.53)
  BOTTOM w0.147: v1(51.99,71.53) R381.2
N17247701: length 2.1
  TOP w0.147: v1(51,70.61) 50.93,70.69 LD13.2
  BOTTOM w0.147: R382.2 50.64,70.25 v1(51,70.61)
N17247743: length 2.2
  TOP w0.147: LD12.2 v1(22.66,90.18)
  BOTTOM w0.147: R383.2 22.53,89.45 22.66,89.58 v1(22.66,90.18)
N17247786: length 2.1
  TOP w0.147: v1(19.61,89.04) 19.9,89.33 LD11.2
  BOTTOM w0.147: R384.2 19.75,88.9 v1(19.61,89.04)
N17248427: length 2.9
  TOP w0.147: R413.2 37.02,50.28 36.7,49.97 U34.7
N17248432: length 2.2
  TOP w0.147: R402.2 36.83,40.91 36.7,41.04 U34.10
N17248439: length 2.8
  TOP w0.147: U34.9 35.43,41.93 34.91,41.4 34.28,41.4 33.69,40.81 R401.2
N17546132: length 5.1
  BOTTOM w0.147: J38.26 70.91,15.2 71.22,15.51 71.6,15.51 71.6,15.51 73.28,15.51 73.76,15.99 R542.2
N17546158: length 3.3
  BOTTOM w0.147: J38.28 69.91,15.04 71.42,16.54 R544.2
N17682848: length 2.8
  TOP w0.147: R92.4 129.31,96.26 129.29,96.29 R74.2
N17682861: length 2.8
  TOP w0.147: R73.2 125.73,96.06 125.71,96.04 R92.1
N17683733: length 3.4
  BOTTOM w0.147: R227.3 R215.2
N17683748: length 3.4
  BOTTOM w0.147: R227.2 R216.2
N17685678: length 1.8
  BOTTOM w0.147: R233.1 132.99,113.55 132.72,113.83 R228.2
N17685693: length 1.7
  BOTTOM w0.147: R233.4 130.24,113.49 130.68,113.93 R229.2
N17685736: length 2
  BOTTOM w0.147: R351.1 132.84,66.25 133.5,66.91 R352.2
N17685749: length 2
  BOTTOM w0.147: R351.4 132.88,69 133.5,68.38 R350.2
N17686321: length 1.6
  TOP w0.147: R22.2 88.83,121.46 88.9,121.53 R10.2
N17686333: length 1.4
  TOP w0.147: R11.2 86.11,121.4 86.08,121.38 R22.3
N17786037: length 2.1
  TOP w0.254: 33.15,118.76 32.86,118.48 U9.2
N17786049: length 4.7
  TOP w0.254: v1(34.42,116.6) 34.29,116.48 U9.4
  BOTTOM w0.254: v1(34.42,116.6) 33.38,115.57 R231.1 33.38,113.92 33.4,113.9 R232.2
N18116794: length 1.9
  BOTTOM w0.147: Q13.1 33.47,95.43 33.73,95.17 R286.2
N18116818: length 2.1
  BOTTOM w0.147: R230.1 27.59,113.39 27.69,113.3 28.37,113.3 Q12.1
N18116875: length 1.4
  TOP w0.147: Q3.1 33.23,112 R30.1
N18117332: length 1.2
  BOTTOM w0.147: Q14.1 R324.2
N18117389: length 1.4
  BOTTOM w0.147: Q16.1 R343.1
N18275385: length 1.8
  TOP w0.147: U48.6 94.88,31.89 v1(94.64,32.13)
  BOTTOM w0.147: R459.1 v1(94.64,32.13)
N18276744: length 1.5
  TOP w0.147: R190.2 C169.1
N18280417: length 2
  TOP w0.254: U53.4 R195.2
N18280437: length 2.9
  BOTTOM w0.147: R491.2 79.67,26.04 79.21,25.58 U93.4
N18280477: length 2
  TOP w0.254: U52.4 R194.2
N18280857: length 2.2
  BOTTOM w0.147: R492.2 75.06,25.66 74.15,24.75 U94.4
N18289350: length 2.3
  BOTTOM w0.147: C277.1 131.5,93.76 130.73,93.76 130.61,93.64 U76.5
N18321769: length 2.2
  BOTTOM w0.147: U70.31 55.84,107.56 55.23,108.18 R243.1
N18546027: length 3.8
  TOP w0.381: R64.2 161.56,94.13 160.99,94.13 159.83,92.98 LD5.1
N18546044: length 2.1
  TOP w0.381: LD5.2 159.78,96.98 D2.1
N18867885: length 3.8
  BOTTOM w0.147: R325.2 70.83,74.71 70.21,74.09 69.5,74.09 68.81,73.4 U79.21
N18867903: length 3
  BOTTOM w0.147: R326.2 69.56,74.71 68.31,73.47 U79.20
N18867905: length 2.7
  BOTTOM w0.147: R327.2 68.33,74.15 67.81,73.64 U79.19
N18867915: length 2.6
  BOTTOM w0.147: U79.18 67.31,73.89 67.06,74.15 R328.2
N18867925: length 2.9
  BOTTOM w0.147: U79.17 66.81,73.72 65.82,74.71 R329.2
N18867943: length 3.7
  BOTTOM w0.147: R330.2 64.55,74.71 65.21,74.06 65.91,74.06 66.31,73.65 U79.16
N18867953: length 4.2
  BOTTOM w0.147: R331.2 63.28,74.71 64.34,73.65 65.43,73.65 65.81,73.27 U79.15
N18867955: length 4.8
  BOTTOM w0.147: R332.2 62.01,74.71 63.45,73.27 64.96,73.27 65.31,72.92 U79.14
N18968782: length 1.5
  TOP w0.254: U36.5 R153.2
N18977129: length 5.6
  BOTTOM w0.147: U87.3 132.83,39.94 C433.1 132.02,39.13 Y3.2
N18977189: length 8.9
  BOTTOM w0.147: U87.2 133.4,39.44 133.17,39.21 133.17,35.91 132.93,35.67 C439.1 131.89,35.67 131.55,35.33 Y3.1
N19031494: length 2.4
  TOP w0.254: U9.9 30.87,116.98 v1(30.86,116.98)
  BOTTOM w0.254: v1(30.86,116.98) 30.35,116.98 30.12,117.22 C215.1
N19312123: length 3.3
  BOTTOM w0.147: R427.1 R428.2 3.92,41.58 3.94,41.57 D7.3
N19753713: length 8.5
  TOP w0.254: U30.11 164.85,64.28 165.23,64.66 165.56,64.66 165.57,64.65 C116.2 166.22,69.04 165.45,69.81 D5.1
N19753729: length 7.8
  TOP w0.147: U30.10 166.03,63.48 C116.1 166.65,63.67 168.78,65.8 168.78,68.85
N19753760: length 2.7
  TOP w0.254: R112.1 174.39,78.25 174.5,78.35 175.51,78.35 175.73,78.14 175.73,77.41
N19753772: length 20.2
  TOP w0.147: U30.8 166.73,62.48 167.3,63.04 R129.2 168.81,63.04 v1(169,63.23)
  TOP w0.254: v1(166.93,77.48) 166.89,77.45 U26.4
  L08_SIG2 w0.091: v1(166.93,77.48) 167.74,76.67 167.74,64.49 v1(169,63.23)
N19753820: length 23.4
  TOP w0.254: U30.13 v1(163.17,65.5)
  L08_SIG2 w0.091: v1(171.07,80.66) 168.15,80.66 163.17,75.69 v1(163.17,65.5)
  BOTTOM w0.147: v1(171.07,80.66) 170.7,80.29 R317.1
N19753822: length 6.2
  TOP w0.254: U22.4 v1(165.9,79.69)
  BOTTOM w0.147: R317.2 166.51,80.29 v1(165.9,79.69) 166.57,79.02 R321.2
N19753872: length 27.5
  TOP w0.147: U30.4 166.26,60.48 v1(166.69,60.06)
  TOP w0.254: R112.2 172.85,78.23 C85.1 171.74,77.57 v1(171.73,77.56)
  L08_SIG2 w0.091: v1(166.69,60.06) 167.12,60.49 167.12,62.12 166.4,62.85 166.4,77.64 166.83,78.07 169.54,78.07 170.05,77.56 v1(171.73,77.56)
N19753878: length 27.9
  TOP w0.147: v1(166.69,61.4) 166.26,60.98 U30.5
  TOP w0.254: R109.2 172.84,79.21 C85.2 171.34,79.21 v1(171.11,79.44)
  L08_SIG2 w0.091: v1(171.11,79.44) 171.42,79.12 171.42,78.32 171.12,78.02 170.38,78.02 169.95,78.45 166.85,78.45 165.84,77.43 165.84,62.25 v1(166.69,61.4)
N19753964: length 1.2
  TOP w0.147: C125.1 168.17,60.16 168.16,60.14 R141.1
N19754006: length 1.5
  TOP w0.147: U30.30 158.66,58.98 158.06,58.38 C131.1
N19754185: length 1.8
  TOP w0.147: U30.1 165.65,58.98 166.44,58.18 C132.1
N19754201: length 5.2
  TOP w0.147: U30.21 157.96,63.48 157.51,63.93 C115.2 156.71,63.95
  TOP w0.254: 155.44,64.28 155.77,63.95 156.12,63.95 ; 156.12,63.95 156.12,64.31 155.8,64.63 ; 156.12,63.95 155.67,64.4 ; 156.12,63.95 156.71,63.95
N19754203: length 8.2
  TOP w0.254: D4.1 157.69,68.92 157.51,68.73 C115.1 158.23,64.93 158.88,64.28 U30.20
N19754223: length 1.5
  TOP w0.147: U30.22 158.24,62.98 158.2,63.02 R130.2
N19754237: length 16.9
  TOP w0.147: U30.23 156.95,62.48 156.67,62.19 v1(156.55,62.19) 156.55,63 R130.1
  TOP w0.254: v1(156.34,72.79) 155.8,73.32 U24.4
  BOTTOM w0.254: v1(156.55,62.19) 156.55,62.7 156.34,62.92 v1(156.34,72.79)
N19754314: length 4.6
  TOP w0.254: U21.4 156.92,82.12 v1(156.75,82.3)
  BOTTOM w0.147: R319.1 156.16,81.71 v1(156.75,82.3) 157.43,81.62 R318.1
N19754320: length 17.3
  TOP w0.254: U30.19 160.18,64.92 159.85,65.24 v1(159.6,65.24)
  L08_SIG2 w0.091: v1(156.59,78.25) 159.6,75.24 v1(159.6,65.24)
  BOTTOM w0.147: R319.2 156.16,78.68 v1(156.59,78.25)
N19754322: length 17.3
  TOP w0.254: v1(160.62,65.37) 160.68,65.31 U30.18
  L08_SIG2 w0.091: v1(157.61,79) 161.16,75.44 161.16,65.92 v1(160.62,65.37)
  BOTTOM w0.147: R318.2 157.43,79.17 v1(157.61,79)
N19754431: length 3.7
  TOP w0.147: R129.1 167.63,63.88 167.07,63.32 167.07,63.32 166.72,62.98 U30.9
N19754435: length 22.5
  TOP w0.254: U30.12 163.67,65.05 164.12,65.5 v1(164.63,65.5)
  L08_SIG2 w0.091: v1(164.63,65.5) 164.63,76.66 166.79,78.81 170.73,78.81 v1(170.99,78.55)
  BOTTOM w0.147: v1(170.99,78.55) 170.52,79.02 R321.1
N19754522: length 2.9
  TOP w0.254: 144.5,74.02 144.5,74.71 144.75,74.97 R119.1
N19754526: length 25.2
  TOP w0.147: v1(157.7,61.02) 158.15,61.02 158.19,60.98 U30.26
  TOP w0.254: v1(149.26,75.88) 149.2,75.94 C94.1 147.63,75.94 R113.2
  L08_SIG2 w0.091: v1(157.7,61.02) 157.7,73.89 155.7,75.88 v1(149.26,75.88)
N19754534: length 24.8
  TOP w0.147: v1(157.73,60.21) 157.93,60.21 158.2,60.48 U30.27
  TOP w0.254: 148.71,74.97 C94.2 ; 148.71,74.97 R119.2 ; 148.71,74.97 148.72,74.97 v1(149.26,74.97)
  L08_SIG2 w0.091: v1(149.26,74.97) 155.52,74.97 157.26,73.23 157.26,60.69 v1(157.73,60.21)
N19754630: length 1.5
  TOP w0.147: C137.2 160.07,57.2 160.18,57.31 U30.32
N19754677: length 1.1
  TOP w0.147: C136.1 155.01,57.91 R142.1
N20142928: length 1.7
  BOTTOM w0.254: C200.1 89.64,126.74 90.04,127.14 U62.2
N20753582: length 2.5
  BOTTOM w0.254: R267.2 R261.2 C248.1
N23484157: length 3.5
  TOP w0.147: v1(55.88,103.52) R53.1
  BOTTOM w0.147: R53.1 v1(55.88,103.52) 56.65,103.52 56.9,103.76 U70.24
N23484680: length 3.2
  TOP w0.147: v1(59.18,102) R59.1
  BOTTOM w0.147: R59.1 v1(59.18,102) 58.94,102.24 U70.22
N24658557: length 2.8
  TOP w0.147: LD20.2 v1(143.38,32.4)
  BOTTOM w0.147: R462.2 142.35,32.53 142.48,32.4 v1(143.38,32.4)
N24754956: length 11.7
  TOP w0.147: v1(35.52,62.91) 36.24,63.62 v1(36.24,70.96)
  BOTTOM w0.147: TP69.1 35.35,70.96 v1(36.24,70.96) U80.13 ; U80.48 35.68,62.75 v1(35.52,62.91)
N24775601: length 13.7
  TOP w0.147: TP19.1 34.33,86.37 34.75,85.95 v1(34.75,85.37) 35.33,85.37 35.33,85.37 U20.48 ; U20.13 v1(36.37,77.15)
  BOTTOM w0.147: v1(36.37,77.15) 36.37,83.88 35.2,85.05 35.07,85.05 v1(34.75,85.37)
N24776171: length 1.4
  BOTTOM w0.147: R334.2 Q15.1
N24776230: length 1.4
  TOP w0.147: Q4.1 10.09,89.43 R99.1
N24826481: length 4.3
  BOTTOM w0.147: U74.3 173.95,101.48 174.34,101.87 R266.2 R260.1 C245.1
N24972917: length 1.8
  BOTTOM w0.147: R295.3 138.94,94.43 R280.2
N24972919: length 1.8
  BOTTOM w0.147: R295.2 137.41,94.52 R281.2
N24972921: length 6.8
  TOP w0.147: U16.8 137.41,97.02 137.52,96.92 137.81,96.92 137.91,97.02 U16.9 137.91,98.97 v1(137.69,99.2)
  BOTTOM w0.147: v1(137.69,99.2) C269.2 137.69,97.21 137.41,96.94 R281.1
N24972925: length 4.5
  TOP w0.147: U16.10 138.41,99.06 v1(138.68,99.33)
  BOTTOM w0.147: R280.1 138.94,96.94 138.67,97.21 C269.1 138.67,98.42 138.68,98.44 v1(138.68,99.33)
N24973001: length 1.8
  TOP w0.147: U16.3 R48.1
N25209998: length 1.8
  BOTTOM w0.14: U71.1 73.66,102.69 73.64,102.68 R268.1
N25294505: length 1.6
  TOP w0.254: LD6.2 R80.1
N25395961: length 2.8
  TOP w0.147: v1(100.4,76.34) 99.94,76.34 99.91,76.3 U23.A12
  BOTTOM w0.147: v1(100.4,76.34) 100.4,77.05 100.58,77.23 R323.2
N25526660: length 3
  BOTTOM w0.147: R254.2 64.41,106.02 64.24,106.19 63.88,106.19 63.5,106.56 U70.12
N25657725: length 1.6
  TOP w0.147: U23.A19 v1(99.65,70.7)
  BOTTOM w0.147: v1(99.65,70.7) 100.01,70.34 R345.1
N25657961: length 4.8
  BOTTOM w0.147: J36.3 5.92,16.81 6.13,16.6 8.43,16.6 9.11,17.29 R541.2
N25658118: length 1.8
  BOTTOM w0.147: U99.3 R516.2
N26002209: length 4
  TOP w0.147: R157.2 96.52,45.86 U40.B2
N26002808: length 1.9
  BOTTOM w0.147: Q19.1 94.86,16.66 R552.1
N26002814: length 1.9
  TOP w0.147: LD26.2 R210.1
N26002874: length 2.1
  BOTTOM w0.147: R553.1 102.34,14 101.89,14.46 Q18.1
N26002883: length 1.8
  TOP w0.147: LD23.2 R197.1
N26004018: length 3.4
  TOP w0.254: U17.7 145.6,94.88 145.34,95.14 R82.1 144.51,95.75 144.78,96.03 C49.1
N26004022: length 1.3
  TOP w0.254: C48.2 143.51,95.82 143.53,95.8 R82.2
N26004036: length 12.8
  TOP w0.147: 150.22,94.17 150.13,94.17 ; 149.85,93.89 149.83,93.88
  TOP w0.254: 150.36,93.88 150.37,93.87
  TOP w0.305: U17.2 149.85,93.88 ; 150.13,94.17 149.85,93.89 149.85,93.88 ; 149.85,93.88 150.19,93.54 ; 149.85,93.88 150.87,93.88 v1(151,93.74)
  TOP w0.381: C54.1 v1(142.62,93.87)
  BOTTOM w0.381: v1(151,93.74) 150.11,92.85 146.05,92.85 145.03,93.87 v1(142.62,93.87)
N26004038: length 1.8
  TOP w0.254: C54.2 145.54,93.87 145.55,93.88 U17.9
N26004052: length 2.3
  BOTTOM w0.381: R277.2 R279.1 C272.1
N26016842: length 1.6
  BOTTOM w0.305: 58.04,19.06 58.05,19.07 U97.9
N26016868: length 4.2
  BOTTOM w0.147: U97.7 59.05,19.94 59.44,19.55 R535.1 60.79,18.54 60.81,18.56 TP98.1
N26016893: length 1.9
  BOTTOM w0.147: R500.2 58.55,24.04 U97.3
N26118637: length 2.9
  TOP w0.147: U4.1 v1(20.7,121.93)
  BOTTOM w0.147: R221.2 v1(20.7,121.93)
N26118639: length 2.9
  TOP w0.147: U4.4 v1(24.51,121.93)
  BOTTOM w0.147: R220.2 v1(24.51,121.93)
N26120249: length 2.9
  TOP w0.147: U3.1 v1(10.8,121.93)
  BOTTOM w0.147: R223.2 v1(10.8,121.93)
N26120251: length 2.9
  TOP w0.147: U3.4 v1(14.6,121.93)
  BOTTOM w0.147: R222.2 v1(14.6,121.93)
N26140693: length 3.1
  BOTTOM w0.147: R372.2 78.19,59.09 77.54,58.43 76.68,58.43 76.18,57.94 U81.21
N26140695: length 2.3
  BOTTOM w0.147: U81.20 75.68,57.91 76.85,59.09 R373.2
N26140697: length 1.9
  BOTTOM w0.147: R374.2 75.69,58.54 75.18,58.02 U81.19
N26140699: length 1.8
  BOTTOM w0.147: U81.18 74.68,58.28 74.42,58.54 R375.2
N26140701: length 2.2
  BOTTOM w0.147: U81.17 74.18,58.1 73.19,59.09 R376.2
N26140703: length 2.9
  BOTTOM w0.147: U81.16 73.68,58.06 73.21,58.53 72.48,58.53 71.92,59.09 R377.2
N26140705: length 4.1
  BOTTOM w0.147: U81.15 73.18,58.06 73.06,58.18 70.87,58.18 70.61,58.43 R378.2
N26140707: length 4.1
  BOTTOM w0.147: R379.2 69.38,59.09 69.86,58.61 69.93,58.61 71.12,57.42 72.21,57.42 72.26,57.37 U81.14
N26145534: length 1.6
  TOP w0.147: Q5.1 133.85,82.18 v1(133.75,82.08)
  BOTTOM w0.147: R312.1 133.85,81.99 v1(133.75,82.08)
N26145544: length 2.7
  TOP w0.147: v1(133.1,86.23) 133.14,86.28 LD7.2
  BOTTOM w0.147: R305.1 133.6,86.28 133.55,86.23 v1(133.1,86.23)
N26145600: length 1.6
  TOP w0.147: R20.1 157.75,120.72 157.8,120.77 Q2.1
N26145606: length 2.5
  TOP w0.147: LD2.2 v1(156.46,126)
  BOTTOM w0.14: v1(156.46,126) R211.1
N26145666: length 1.5
  TOP w0.147: Q1.1 126.02,121.46 126.09,121.39 R14.1
N26145672: length 1.4
  TOP w0.147: R15.1 121.94,121.2 121.92,121.22 LD3.2
N26145732: length 1.4
  TOP w0.147: R136.1 10.05,59.03 9.99,59.09 Q7.1
N26145738: length 3.8
  TOP w0.147: LD10.2 v1(9.73,62)
  BOTTOM w0.147: R365.1 8.8,61.95 8.84,62 v1(9.73,62)
N26145798: length 1.6
  TOP w0.147: Q6.1 133.83,64.72 133.78,64.77 R127.1
N26145804: length 2.7
  TOP w0.147: v1(138.81,61.72) LD8.2
  BOTTOM w0.147: R360.1 v1(138.81,61.72)
N26145856: length 1.9
  BOTTOM w0.147: Q11.1 29.27,121.6 29.36,121.51 R217.1
N26145862: length 3.5
  TOP w0.147: LD1.2 32.85,126.25 33.27,125.83 v1(33.27,124.98)
  BOTTOM w0.147: R212.1 v1(33.27,124.98)
N26149805: length 1.9
  BOTTOM w0.147: U90.4 106.17,35.42 106.19,35.4 R454.2
N26149864: length 2.5
  BOTTOM w0.147: R555.2 56.28,11.32 56.13,11.18 J30.2
N26219977: length 2.2
  TOP w0.147: SW3.15 v1(104.22,28.23)
  BOTTOM w0.147: v1(104.22,28.23) R490.1
N26220001: length 2.2
  TOP w0.147: SW3.16 v1(102.95,28.23)
  BOTTOM w0.147: v1(102.95,28.23) R475.1
N26314477: length 4
  BOTTOM w0.147: 109.41,96.55 109.41,96.61 109.4,96.62
  BOTTOM w0.254: C278.1 C279.1 109.41,94.66 C285.1 109.41,96.55 109.4,96.56 R298.2
N26314562: length 4.1
  BOTTOM w0.381: C291.1 C292.1 116.32,80.66 C296.1 116.4,79.37 R307.2
N26442461: length 2.4
  TOP w0.147: U51.5 R185.1
N26454965: length 1.7
  TOP w0.147: R171.1 141.9,44.14 141.85,44.09 U41.4
N26523524: length 2.3
  TOP w0.147: R158.1 101.75,45.86 101.47,45.58 U40.A5
N26648730: length 2.7
  BOTTOM w0.147: U91.19 54.49,36.45 53.09,37.86 TP90.1
N26648748: length 2.6
  BOTTOM w0.147: TP88.1 54.22,37.98 54.22,37.49 54.99,36.71 U91.20
N26648766: length 3.9
  BOTTOM w0.147: U91.21 55.5,37.41 54.38,38.52 54.38,38.63 TP87.1
N26648784: length 2.7
  BOTTOM w0.147: U91.22 56,37.76 TP86.1
N26648802: length 2.2
  BOTTOM w0.147: TP89.1 56.5,37.71 U91.23
N26648820: length 2.1
  BOTTOM w0.147: U91.24 57,36.92 57.17,37.1 57.28,37.1 TP91.1
N26733190: length 4.7
  TOP w0.254: U32.4 17.78,60.08 v1(17.65,59.96)
  BOTTOM w0.254: R361.2 18.67,62.66 18.69,62.64 R364.1 18.69,60.99 v1(17.65,59.96)
N26733205: length 2.8
  TOP w0.254: U32.2 19.21,58.08 18.53,57.4 18.41,57.4
N26733231: length 2.4
  TOP w0.254: v1(21.21,59.58) 21.2,59.58 U32.9
  BOTTOM w0.254: v1(21.21,59.58) 21.72,59.58 21.95,59.34 C402.1
N26735382: length 2.4
  TOP w0.254: U5.9 97.16,117.46 v1(97.16,117.46)
  BOTTOM w0.254: C202.1 96.92,116.72 97.16,116.95 v1(97.16,117.46)
N26735416: length 3.6
  TOP w0.254: v1(97.54,121.02) 97.66,120.89 U5.4
  BOTTOM w0.254: R214.2 97.63,121.11 v1(97.54,121.02) 98.04,121.02 98.31,120.75 R213.1
N26735457: length 2.1
  TOP w0.254: U5.2 95.66,119.46 95.38,119.75
N26735496: length 5.4
  BOTTOM w0.254: 138.56,119.44 138.6,119.39 U65.6
N26735653: length 3.5
  TOP w0.254: U33.2 133.5,57.04 R145.1 132.18,56.51 132.09,56.42 R144.2
N26736579: length 7.7
  TOP w0.254: 130.8,76.1 U25.6 ; 130.8,76.1 129.22,74.52 127.53,74.52 ; 130.8,76.1 130.51,76.1 130.29,75.87 ; 130.8,76.1 130.8,75.8 130.55,75.55
N26736751: length 1.9
  TOP w0.254: R57.2 154.43,103.73 155.11,104.4 U12.1
N26736805: length 2.7
  TOP w0.254: U12.7 155.76,107.26 v1(155.96,107.46)
  BOTTOM w0.147: R49.1 156.65,107.46 v1(155.96,107.46) 155.6,107.46 155.27,107.13 R44.2
N26881621: length 2.9
  TOP w0.147: v1(138.3,30.24) 138.08,30.46 LD21.1
  BOTTOM w0.147: R464.2 137.07,30.89 137.72,30.24 v1(138.3,30.24)
N27030520: length 2.1
  BOTTOM w0.147: U71.3 70.25,105.81 70.23,105.79 R252.1
N27215594: length 3.1
  TOP w0.147: R76.2 30.1,96.83 29.16,96.83 28.56,97.42 J14.14
N27215846: length 1.6
  BOTTOM w0.147: C231.2 24.87,107.09 J14.12
N27215858: length 1.6
  BOTTOM w0.147: C240.2 21.27,106.06 21.28,106.05 J14.6
N27215870: length 1.8
  BOTTOM w0.147: C273.2 J14.1
N27215882: length 1.7
  BOTTOM w0.147: C282.2 24.87,93.79 24.89,93.81 J14.7
N27217693: length 4.2
  BOTTOM w0.147: J21.B9 23.01,72.09 23.1,72.18 FB19.2
N27218087: length 5.1
  BOTTOM w0.147: J21.B12 9.92,74.54 9.07,75.4 7.55,75.4 6.03,76.93 R347.2
N27219244: length 4.4
  BOTTOM w0.147: J21.A9 23.01,78.69 23.03,78.71 24.96,78.71 25.41,78.27 FB14.2
N27219552: length 2.2
  BOTTOM w0.147: J21.A12 7.61,74.85 R336.2
N27838027: length 1.8
  TOP w0.147: R24.1 126.23,118.74 U10.6
N27914276: length 1.7
  TOP w0.254: R577.2 164.17,56.82 U30.40
N27928121: length 2
  TOP w0.147: U30.31 159.68,57.43 158.81,56.56 R578.1
N27928168: length 6.6
  TOP w0.254: R579.1 R602.2 142.01,95.73 142.52,95.22 142.52,94.91 142.95,94.49 145.17,94.49 145.28,94.38 U17.8
N27943339: length 1.3
  BOTTOM w0.254: R580.1 146.42,120.14 U65.1
N27943633: length 1.7
  TOP w0.254: v1(96.52,120.76) 96.66,120.62 U5.6
  BOTTOM w0.147: R581.1 v1(96.52,120.76)
N27943804: length 1.5
  BOTTOM w0.254: R582.1 143.78,102.87 143.24,102.33 U72.3
N27943890: length 2.5
  TOP w0.147: U33.4 137.04,56.39 138.04,55.39 R583.1
N27943939: length 1.5
  TOP w0.254: U25.1 134.83,75.1 135.19,74.74 135.19,74.74 135.27,74.66 R584.1
N27944274: length 1.6
  TOP w0.254: U9.6 34.02,117.48 v1(34.16,117.62)
  BOTTOM w0.254: v1(34.16,117.62) 33.77,117.22 R585.1
N27944496: length 1.2
  BOTTOM w0.254: R586.1 U62.4
N27944776: length 1.7
  TOP w0.254: U32.6 18.05,59.08 v1(17.91,58.94)
  BOTTOM w0.254: R587.1 18.57,58.94 v1(17.91,58.94)
N27944822: length 1.2
  BOTTOM w0.147: R588.1 47.17,94.84 U77.3
N27945052: length 1.2
  BOTTOM w0.254: R589.1 14.14,18.86 U100.3
N27977097: length 4.7
  TOP w0.147: Y1.1 99.38,56.21 99.21,56.38 99.21,58.1 99.32,58.21 99.33,58.21 99.44,58.32 C133.2 99.44,59.2 99.19,59.45 R138.1
N27977103: length 2.4
  TOP w0.147: R139.1 101.75,59.67 C134.2 101.75,58.35 Y1.3
N28035755: length 3.8
  TOP w0.147: v1(89.15,66.04) 89.15,66.67 89.35,66.87 89.35,68.51 89.46,68.62 U23.N21
  BOTTOM w0.147: R591.2 v1(89.15,66.04)
N28118242: length 2.7
  TOP w0.147: LD7.1 136.23,84.5 136.02,84.28 Q5.3
