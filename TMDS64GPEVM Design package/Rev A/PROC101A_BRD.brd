# Allegro board PROC101A_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A4: length 49
  TOP w0.216: U23.D3 v1(97.06,83.9) ; U13.N3 v1(89.61,100.15)
  L03_SIG1 w0.147: v1(89.61,100.15) 89.21,99.75 89.21,98.39 89.44,98.15 89.77,98.15 90.01,97.92 90.01,97.14 92.02,95.13 96.1,95.13 98.5,97.53 98.5,99.61 98.71,99.82 99.79,99.82 100.28,99.33 100.28,99.13 100.17,99.02 99.86,99.02 99.75,98.91 99.75,98.76 99.86,98.65 100.17,98.65 100.28,98.54 100.28,98.39 100.17,98.28 99.86,98.28 99.75,98.17 99.75,98.02 99.86,97.91 100.17,97.91 100.28,97.81 100.28,97.65 100.17,97.55 99.86,97.55 99.75,97.44 99.75,97.29 99.86,97.18 100.17,97.18 100.28,97.07 100.28,96.92 100.17,96.81 99.86,96.81 99.75,96.7 99.75,96.55 99.86,96.44 100.17,96.44 100.28,96.33 100.28,95.3 98.72,93.75 98.23,93.75 97.75,93.27 97.75,88.04 96.37,86.67 96.37,86.19 96.09,85.9 95.29,85.9 95.06,85.67 95.06,83.74 95.29,83.5 96.42,83.5 96.54,83.62 96.77,83.62 v1(97.06,83.9)
  BOTTOM w0.114: R290.1 87.43,96.08 87.88,96.54 88.12,96.54 88.77,97.19 88.77,99.32 v1(89.61,100.15)
DDR_A5: length 47.8
  TOP w0.216: U13.P8 v1(93.6,99.35) ; U23.F2 v1(95.46,84.7)
  L03_SIG1 w0.147: v1(95.46,84.7) 95.86,84.3 97.22,84.3 97.46,84.54 97.46,85.67 98.14,86.35 99.13,86.35 99.93,87.15 99.93,93.39 101.43,94.89 101.43,99.74 100.89,100.28 100.89,100.66 100.89,100.66 100.89,101.88 100.74,102.03 97.13,102.03 96.55,101.45 96.55,97.85 95.36,96.66 92.33,96.66 91.19,97.8 91.19,100.37 91.37,100.55 92.4,100.55 v1(93.6,99.35)
  BOTTOM w0.114: R287.1 93.74,95.5 92.96,96.28 92.96,98.71 v1(93.6,99.35)
DDR_A6: length 47.1
  TOP w0.216: U13.P2 v1(88.01,99.35) ; U23.J2 v1(93.06,84.7)
  L03_SIG1 w0.147: v1(93.06,84.7) 92.66,85.1 92.09,85.1 91.86,85.34 91.86,85.48 91.29,86.05 91.29,86.97 91.4,87.07 92.15,87.07 92.26,87.18 92.26,87.34 92.15,87.44 91.4,87.44 91.29,87.55 91.29,87.7 91.4,87.81 92.15,87.81 92.26,87.92 92.26,88.07 92.15,88.18 91.4,88.18 91.29,88.29 91.29,88.44 91.4,88.55 92.16,88.55 92.27,88.65 92.27,88.81 92.16,88.91 91.4,88.91 91.29,89.02 91.29,89.29 91.4,89.4 91.87,89.4 91.98,89.5 91.98,89.66 91.87,89.77 91.4,89.77 91.29,89.87 91.29,90.18 91.14,90.33 90.99,90.33 90.88,90.22 90.88,89.17 90.78,89.06 90.62,89.06 90.51,89.17 90.51,90.22 90.41,90.33 90.25,90.33 90.15,90.22 90.15,89.17 90.04,89.06 89.89,89.06 89.78,89.17 89.78,90.22 89.67,90.33 89.36,90.33 89.21,90.48 89.21,90.75 89,90.96 88.16,90.96 88.04,91.07 88.04,91.24 88.16,91.36 89,91.36 89.12,91.48 89.12,91.64 89,91.76 88.16,91.76 88.04,91.88 88.04,92.04 88.16,92.16 89,92.16 89.12,92.28 89.12,92.55 88.49,93.17 88.34,93.17 87.96,92.79 87.81,92.79 87.7,92.9 87.7,93.06 88.08,93.43 88.08,93.59 87.97,93.69 87.82,93.69 87.44,93.32 87.29,93.32 87.18,93.42 87.18,93.58 87.56,93.96 87.56,94.11 87.45,94.22 87.3,94.22 86.92,93.84 86.77,93.84 86.66,93.94 86.66,94.1 87.04,94.48 87.04,94.63 86.82,94.85 86.82,95 87.14,95.33 87.14,95.48 87.04,95.59 86.88,95.59 86.56,95.26 86.4,95.26 86.25,95.42 86.25,96.01 86.35,96.12 86.57,96.12 86.68,96.23 86.68,96.38 86.57,96.49 86.35,96.49 86.25,96.59 86.25,96.75 86.35,96.86 86.57,96.86 86.68,96.96 86.68,97.12 86.57,97.22 86.35,97.22 86.25,97.33 86.25,97.48 86.35,97.59 86.57,97.59 86.68,97.7 86.68,97.85 86.57,97.96 86.35,97.96 86.25,98.07 86.25,98.22 86.35,98.33 86.57,98.33 86.68,98.44 86.68,98.59 86.57,98.7 86.35,98.7 86.25,98.8 86.25,99.07 86.53,99.35 v1(88.01,99.35)
  BOTTOM w0.114: v1(88.01,99.35) 87.85,99.2 87.63,99.2 87.48,99.06 87.47,99.06 87.37,98.96 86.62,98.96 86.23,98.57 R275.1
DDR_A7: length 48.5
  TOP w0.114: 95.78,96.81 95.49,97.1 93.61,97.1 92.8,97.9 92.8,98.55 U13.R8
  TOP w0.216: U23.L5 v1(91.46,82.3) ; U13.R8 v1(93.6,98.55)
  TOP w0.23: 95.78,96.81 96.16,96.43 R77.1
  L08_SIG2 w0.147: v1(91.46,82.3) 91.86,81.9 94.02,81.9 94.26,82.14 94.26,82.47 94.49,82.7 94.82,82.7 94.83,82.7 94.88,82.7 95.06,82.88 95.06,82.94 95.06,83.27 95.29,83.5 95.62,83.5 95.86,83.74 95.86,84.88 95.63,85.1 95.29,85.1 95.06,85.34 95.06,85.67 95.06,85.67 95.06,86.85 94.91,87 94.49,87 94,87.48 94,91.33 93.9,91.44 93.75,91.44 93.65,91.55 93.65,91.7 93.75,91.81 93.9,91.81 94,91.91 94,92.07 93.9,92.18 93.75,92.18 93.65,92.28 93.65,92.44 93.75,92.54 93.9,92.54 94,92.65 94,92.89 93.9,93 93.48,93 93.37,93.1 93.37,93.26 93.48,93.36 93.9,93.36 94,93.47 94,93.62 93.9,93.73 93.48,93.73 93.37,93.84 93.37,93.99 93.48,94.1 93.9,94.1 94,94.21 94,94.76 94.12,94.87 94.61,94.87 94.71,94.97 94.71,97.47 94.81,97.57 94.95,97.57 95.05,97.47 95.05,94.97 95.14,94.87 95.31,94.87 95.42,94.99 95.42,97.79 95.32,97.89 94.89,97.89 94.79,97.99 94.79,98.13 94.89,98.22 95.32,98.22 95.42,98.32 95.42,98.46 95.32,98.56 94.89,98.56 94.79,98.66 94.79,98.8 94.89,98.89 95.32,98.89 95.42,98.99 95.42,99.33 95.31,99.44 94.91,99.44 94.8,99.54 94.8,99.7 94.91,99.81 95.31,99.81 95.42,99.91 95.42,100.07 95.31,100.17 94.91,100.17 94.8,100.28 94.8,100.43 94.91,100.54 95.31,100.54 95.42,100.65 95.42,101.22 95.3,101.34 94.58,101.34 94.57,101.35 94.24,101.35 94,101.12 94,98.95 v1(93.6,98.55)
DDR_A8: length 48
  TOP w0.114: 88.11,97.2 88.81,97.9 88.81,98.55 U13.R2
  TOP w0.216: U23.J3 v1(93.06,83.9) ; U13.R2 v1(88.01,98.55)
  TOP w0.23: 88.11,97.2 87.82,96.92 86.98,96.92 86.16,96.1 R84.1
  L03_SIG1 w0.147: v1(88.01,98.55) 88.41,98.15 88.41,96.17 88.55,96.02 88.55,95.86 88.45,95.76 88.45,95.6 88.55,95.5 88.71,95.5 88.81,95.6 88.97,95.6 89.07,95.5 89.07,95.34 88.97,95.24 88.97,95.08 89.07,94.97 89.23,94.97 89.34,95.08 89.49,95.08 89.6,94.98 89.6,94.82 89.49,94.71 89.49,94.56 89.59,94.45 89.75,94.45 89.86,94.56 90.01,94.56 90.12,94.45 90.12,94.3 90.01,94.19 90.01,94.04 90.12,93.93 90.27,93.93 90.38,94.04 90.53,94.04 90.64,93.93 90.64,93.78 90.53,93.67 90.53,93.52 90.64,93.41 90.79,93.41 90.9,93.52 91.05,93.52 91.25,93.32 91.25,93.03 91.36,92.92 91.51,92.92 91.62,93.03 91.62,93.38 91.73,93.49 91.88,93.49 91.99,93.38 91.99,93.03 92.09,92.92 92.25,92.92 92.35,93.03 92.35,93.38 92.46,93.49 92.61,93.49 92.72,93.38 92.72,93.03 92.83,92.92 92.98,92.92 93.09,93.03 93.09,93.38 93.2,93.49 93.35,93.49 93.46,93.38 93.46,93.03 93.57,92.92 93.72,92.92 93.83,93.03 93.83,93.38 93.94,93.49 94.09,93.49 94.2,93.38 94.2,93.03 94.3,92.92 94.46,92.92 94.56,93.03 94.56,93.38 94.67,93.49 95,93.49 95.15,93.34 95.15,92.64 95.04,92.53 93.75,92.53 93.64,92.43 93.64,92.27 93.75,92.17 95.04,92.17 95.15,92.06 95.15,91.9 95.04,91.8 93.75,91.8 93.64,91.69 93.64,91.54 93.75,91.43 95.04,91.43 95.15,91.32 95.15,91.17 95.04,91.06 93.75,91.06 93.64,90.95 93.64,90.8 93.75,90.69 95.04,90.69 95.15,90.58 95.15,90.43 95.04,90.32 93.75,90.32 93.64,90.22 93.64,90.06 93.75,89.96 94.88,89.96 94.99,89.84 94.99,89.68 94.46,89.15 93.9,89.15 93.8,89.04 93.8,88.89 93.9,88.78 94.56,88.78 94.67,88.68 94.67,88.53 94.45,88.31 94.45,88.16 94.56,88.05 94.71,88.05 95.08,88.42 95.36,88.42 95.54,88.24 95.54,87.31 95.23,87 94.42,87 94.33,86.9 94.32,86.9 94.09,86.67 94.09,86.38 93.46,85.75 93.46,84.3 v1(93.06,83.9)
DDR_A9: length 48.2
  TOP w0.114: 93.34,96.53 92.45,97.42 92.11,97.42 91.82,97.71 91.82,98.37 v1(92,98.55)
  TOP w0.216: v1(92,98.55) U13.R7 ; U23.J4 v1(93.06,83.1)
  TOP w0.23: 93.34,96.53 94.61,96.53 95.05,96.09 R91.1
  L08_SIG2 w0.147: v1(93.06,83.1) 93.29,83.1 93.46,83.27 93.69,83.5 94.02,83.5 94.26,83.74 94.26,85.67 93.27,86.66 93.27,88.39 92.94,88.72 92.94,88.91 93.25,89.22 93.25,89.37 93.14,89.48 92.99,89.48 92.68,89.17 92.52,89.17 92.38,89.32 92.38,89.47 93.12,90.22 93.12,90.37 93.02,90.48 92.86,90.48 92.12,89.73 91.96,89.73 91.86,89.84 91.86,89.99 92.6,90.74 92.6,90.89 92.5,91 92.34,91 91.6,90.25 91.44,90.25 91.2,90.49 91.2,91.25 91.31,91.35 92.16,91.35 92.27,91.46 92.27,91.61 92.16,91.72 91.31,91.72 91.2,91.83 91.2,91.98 91.31,92.09 92.16,92.09 92.27,92.2 92.27,92.35 92.16,92.46 91.31,92.46 91.2,92.57 91.2,92.72 91.31,92.83 92.16,92.83 92.27,92.93 92.27,93.09 92.16,93.19 91.31,93.19 91.2,93.3 91.2,93.45 91.31,93.56 92.16,93.56 92.27,93.67 92.27,93.82 92.16,93.93 91.31,93.93 91.2,94.04 91.2,94.19 91.31,94.3 92.16,94.3 92.27,94.41 92.27,94.56 92.16,94.67 91.31,94.67 91.2,94.78 91.2,95.33 91.31,95.43 91.7,95.43 91.81,95.54 91.81,95.7 91.7,95.8 91.31,95.8 91.2,95.91 91.2,96.06 91.31,96.17 91.7,96.17 91.81,96.28 91.81,96.43 91.7,96.54 91.31,96.54 91.2,96.65 91.2,96.8 91.31,96.91 91.7,96.91 91.81,97.02 91.81,97.17 91.7,97.28 91.31,97.28 91.2,97.38 91.2,97.54 91.31,97.64 91.7,97.64 91.81,97.75 91.81,97.9 91.7,98.01 91.31,98.01 91.2,98.12 91.2,98.43 91.09,98.54 91.09,100.96 91.24,101.11 91.44,101.11 91.59,100.96 91.59,98.97 v1(92,98.55)
DDR_A10: length 50.8
  TOP w0.216: U23.K3 v1(92.26,83.9) ; U13.M3 v1(89.61,100.95)
  L03_SIG1 w0.147: v1(92.26,83.9) 91.86,84.3 91.86,84.9 90.7,86.06 90.7,86.64 90.15,87.19 90.15,87.34 90.52,87.71 90.52,87.86 90.42,87.97 90.26,87.97 89.89,87.6 89.74,87.6 89.63,87.71 89.63,87.86 90,88.23 90,88.39 89.9,88.49 89.74,88.49 89.37,88.12 89.22,88.12 89.11,88.23 89.11,88.38 89.48,88.75 89.48,88.91 89.38,89.01 89.22,89.01 88.85,88.64 88.7,88.64 88.59,88.75 88.59,88.9 88.96,89.27 88.96,89.43 88.85,89.53 88.7,89.53 88.33,89.16 88.18,89.16 88.07,89.27 88.07,89.42 88.44,89.8 88.44,89.95 88.33,90.06 88.18,90.06 87.81,89.68 87.66,89.68 87.55,89.79 87.55,89.94 87.92,90.32 87.92,90.47 87.81,90.58 87.66,90.58 87.29,90.2 87.13,90.2 86.83,90.5 86.83,90.95 86.94,91.06 87.24,91.06 87.35,91.17 87.35,91.32 87.24,91.43 86.94,91.43 86.83,91.53 86.83,91.69 86.94,91.8 87.24,91.8 87.35,91.9 87.35,92.06 87.24,92.16 86.94,92.16 86.83,92.27 86.83,92.42 86.94,92.53 87.24,92.53 87.35,92.64 87.35,92.79 87.24,92.9 86.94,92.9 86.83,93.01 86.83,93.18 85.37,94.64 85.37,95.54 85.48,95.65 85.72,95.65 85.83,95.76 85.83,95.91 85.72,96.02 85.48,96.02 85.37,96.13 85.37,96.28 85.48,96.39 85.72,96.39 85.83,96.5 85.83,96.65 85.72,96.76 85.48,96.76 85.37,96.86 85.37,97.02 85.48,97.12 85.72,97.12 85.83,97.23 85.83,97.39 85.72,97.49 85.48,97.49 85.37,97.6 85.37,97.75 85.48,97.86 85.72,97.86 85.83,97.97 85.83,98.12 85.72,98.23 85.48,98.23 85.37,98.34 85.37,98.49 85.48,98.6 85.72,98.6 85.83,98.71 85.83,98.86 85.72,98.97 85.48,98.97 85.37,99.07 85.37,99.23 85.48,99.33 85.72,99.33 85.83,99.44 85.83,99.59 85.72,99.7 85.48,99.7 85.37,99.81 85.37,99.96 85.48,100.07 85.72,100.07 85.83,100.18 85.83,100.33 85.72,100.44 85.48,100.44 85.37,100.55 85.37,100.7 85.48,100.81 85.72,100.81 85.83,100.92 85.83,101.07 85.72,101.18 85.48,101.18 85.37,101.28 85.37,101.5 86.03,102.16 86.67,102.16 86.81,102.02 86.81,101.59 87.04,101.35 90.16,101.35 90.27,101.24 90.27,101.08 90.15,100.95 v1(89.61,100.95)
  BOTTOM w0.114: v1(89.61,100.95) 88.52,99.87 88.52,97.3 88.01,96.79 86.91,96.79 86.16,96.04 R291.1
DDR_A11: length 47.5
  TOP w0.114: v1(88.01,97.75) 87.55,97.3
  TOP w0.216: U23.J1 v1(92.26,85.5) ; U13.T2 v1(88.01,97.75)
  TOP w0.23: R83.1 84.89,96.61 85.58,97.3 87.55,97.3
  L03_SIG1 w0.147: v1(88.01,97.75) 88.01,97.23 87.89,97.11 87.17,97.11 87.06,97 87.06,96.83 87.17,96.71 87.89,96.71 88.01,96.59 88.01,96.43 87.89,96.31 87.17,96.31 87.06,96.19 87.06,96.03 87.17,95.91 87.89,95.91 88.01,95.79 88.01,95.52 88.27,95.26 88.27,95.09 87.77,94.59 87.77,94.42 87.88,94.31 88.05,94.31 88.55,94.81 88.72,94.81 88.83,94.69 88.83,94.52 88.33,94.02 88.33,93.86 88.45,93.74 88.62,93.74 89.12,94.24 89.28,94.24 89.4,94.12 89.4,93.95 88.9,93.45 88.9,93.29 89.68,92.51 89.88,92.51 89.98,92.4 89.98,90.84 90.09,90.73 90.24,90.73 90.35,90.84 90.35,92.4 90.46,92.51 90.61,92.51 90.72,92.4 90.72,90.84 90.83,90.73 90.98,90.73 91.09,90.84 91.09,92.4 91.2,92.51 91.35,92.51 91.46,92.4 91.46,90.84 91.57,90.73 91.72,90.73 91.83,90.84 91.83,92.4 91.93,92.51 92.41,92.51 93.21,91.71 93.21,91.39 93.1,91.28 92.48,91.28 92.37,91.18 92.37,91.02 92.48,90.92 93.1,90.92 93.21,90.81 93.21,90.66 93.1,90.55 92.48,90.55 92.37,90.44 92.37,90.29 92.48,90.18 93.1,90.18 93.21,90.07 93.21,89.92 93.1,89.81 92.48,89.81 92.37,89.7 92.37,89.55 92.48,89.44 93.1,89.44 93.21,89.34 93.21,88.96 93.74,88.43 93.74,88.2 93.63,88.09 92.74,88.09 92.63,87.98 92.63,87.83 92.74,87.72 93.63,87.72 93.74,87.62 93.74,87.46 93.63,87.36 92.74,87.36 92.63,87.25 92.63,87.1 92.74,86.99 93.63,86.99 93.74,86.88 93.74,86.39 92.84,85.5 v1(92.26,85.5)
DDR_A12: length 49.1
  TOP w0.114: 90.68,97.27 90.68,99.63 v1(92,100.95)
  TOP w0.216: v1(92,100.95) U13.M7 ; U23.M5 v1(89.86,82.3)
  TOP w0.23: R88.1 91.2,96.01 90.7,96.51 90.7,96.84 90.68,96.86 90.68,97.27
  L08_SIG2 w0.147: v1(92,100.95) 91.54,101.42 91.54,101.81 91.39,101.96 90.34,101.96 90.12,101.73 90.12,101.47 90.23,101.36 90.66,101.36 90.77,101.25 90.77,101.1 90.66,100.99 90.23,100.99 90.12,100.88 90.12,100.73 90.23,100.62 90.66,100.62 90.77,100.51 90.77,100.36 90.66,100.25 90.23,100.25 90.12,100.15 90.12,99.99 90.23,99.88 90.66,99.88 90.77,99.78 90.77,99.62 90.66,99.52 90.23,99.52 90.12,99.41 90.12,99.26 90.23,99.15 90.66,99.15 90.77,99.04 90.77,98.89 90.66,98.78 90.23,98.78 90.12,98.67 90.12,98.52 90.23,98.41 90.66,98.41 90.77,98.3 90.77,98.15 90.66,98.04 90.23,98.04 90.12,97.94 90.12,97.78 90.23,97.67 90.66,97.67 90.77,97.57 90.77,97.41 90.66,97.31 90.23,97.31 90.12,97.2 90.12,97.05 90.23,96.94 90.66,96.94 90.77,96.83 90.77,96.68 90.66,96.57 90.23,96.57 90.12,96.46 90.12,96.31 90.23,96.2 90.66,96.2 90.77,96.09 90.77,95.94 90.66,95.83 90.23,95.83 90.12,95.73 90.12,95.57 90.23,95.47 90.66,95.47 90.77,95.36 90.77,95.2 90.66,95.1 90.23,95.1 90.12,94.99 90.12,94.84 90.23,94.73 90.66,94.73 90.77,94.62 90.77,94.47 90.66,94.36 90.23,94.36 90.12,94.25 90.12,94.1 90.23,93.99 90.66,93.99 90.77,93.88 90.77,93.73 90.66,93.62 90.23,93.62 90.12,93.52 90.12,93.36 90.23,93.26 90.66,93.26 90.77,93.15 90.77,92.99 90.66,92.89 90.23,92.89 90.12,92.78 90.12,92.63 90.23,92.52 90.66,92.52 90.77,92.41 90.77,92.26 90.66,92.15 90.23,92.15 90.12,92.04 90.12,91.89 90.23,91.78 90.66,91.78 90.77,91.67 90.77,91.52 90.66,91.41 90.23,91.41 90.12,91.31 90.12,90.53 90.48,90.17 90.64,90.17 90.69,90.23 90.85,90.23 90.96,90.12 90.96,89.97 90.9,89.91 90.9,89.75 91,89.65 91.16,89.65 91.22,89.71 91.37,89.71 91.48,89.6 91.48,89.45 91.42,89.39 91.42,89.23 91.52,89.13 91.68,89.13 91.74,89.18 91.89,89.18 92,89.08 92,88.92 91.94,88.87 91.94,88.71 92.9,87.75 92.9,87.37 92.92,87.35 92.92,86.44 93.46,85.9 93.46,83.74 93.22,83.5 92.89,83.5 92.66,83.27 92.66,82.94 92.42,82.7 90.26,82.7 v1(89.86,82.3)
DDR_A13: length 46.2
  TOP w0.114: v1(93.6,97.75) 94.05,97.31 95.32,97.31 95.5,97.49
  TOP w0.216: U13.T8 v1(93.6,97.75) ; U23.K4 v1(92.26,83.1)
  TOP w0.23: 95.5,97.49 95.62,97.61 R71.1
  L03_SIG1 w0.147: v1(92.26,83.1) 92.66,82.7 92.89,82.7 92.89,82.7 97.22,82.7 97.23,82.7 97.29,82.7 97.46,82.87 97.46,82.94 97.46,83.27 97.69,83.5 98.02,83.5 98.26,83.74 98.26,84.07 98.49,84.3 98.82,84.3 99.06,84.54 99.06,84.87 99.29,85.1 99.84,85.1 100.7,85.96 100.7,93.02 102.23,94.54 102.23,103.2 101.63,103.8 98.66,103.8 98.27,103.41 97.07,103.41 95.67,102.01 95.67,98.7 94.8,97.83 94.8,97.59 94.57,97.36 94,97.36 v1(93.6,97.75)
DDR_A14_WEN: length 47.3
  TOP w0.216: U13.L2 v1(88.01,101.75) ; U23.H4 v1(93.86,83.1)
  L03_SIG1 w0.147: v1(93.86,83.1) 93.46,83.5 91.29,83.5 91.06,83.74 90.81,83.99 90.81,85.32 89.69,86.43 89.69,86.6 89.83,86.74 89.83,86.91 89.72,87.03 89.55,87.03 89.41,86.88 89.24,86.88 89.12,87 89.12,87.17 89.27,87.31 89.27,87.48 89.15,87.59 88.98,87.59 88.84,87.45 88.67,87.45 88.56,87.57 88.56,87.74 88.7,87.88 88.7,88.04 88.58,88.16 88.42,88.16 88.27,88.02 88.11,88.02 87.99,88.14 87.99,88.3 88.13,88.45 88.13,88.61 88.01,88.73 87.85,88.73 87.71,88.59 87.54,88.59 87.24,88.88 87.24,89.03 87.42,89.21 87.42,89.36 87.31,89.47 87.16,89.47 86.98,89.29 86.83,89.29 86.72,89.4 86.72,89.55 86.9,89.73 86.9,89.88 86.79,89.99 86.64,89.99 86.46,89.81 86.31,89.81 86.2,89.92 86.2,90.08 86.37,90.25 86.37,90.4 86.27,90.51 86.11,90.51 85.94,90.34 85.79,90.34 85.66,90.47 85.66,91.34 85.77,91.45 86.14,91.45 86.25,91.55 86.25,91.71 86.14,91.81 85.77,91.81 85.66,91.92 85.66,92.08 85.77,92.18 86.14,92.18 86.25,92.29 86.25,92.44 86.14,92.55 85.77,92.55 85.66,92.66 85.66,92.81 85.77,92.92 86.14,92.92 86.25,93.03 86.25,93.18 86.14,93.29 85.77,93.29 85.66,93.4 85.66,93.58 85.01,94.23 85.01,98.15 84.9,98.26 84.54,98.26 84.43,98.36 84.43,98.52 84.54,98.62 84.9,98.62 85.01,98.73 85.01,98.88 84.9,98.99 84.54,98.99 84.43,99.1 84.43,99.25 84.54,99.36 84.9,99.36 85.01,99.47 85.01,99.62 84.9,99.73 84.54,99.73 84.43,99.84 84.43,99.99 84.54,100.1 84.9,100.1 85.01,100.2 85.01,100.36 84.9,100.47 84.54,100.47 84.43,100.57 84.43,100.73 84.54,100.83 84.9,100.83 85.01,100.94 85.01,101.09 84.9,101.2 84.54,101.2 84.43,101.31 84.43,101.46 84.54,101.57 84.9,101.57 86.28,102.95 89.13,102.95 89.34,102.74 89.34,102.23 88.86,101.75 v1(88.01,101.75)
  BOTTOM w0.114: v1(88.01,101.75) 87.61,101.36 87.04,101.36 86.78,101.61 86.11,101.61 85.49,102.23 85.05,102.23 84.91,102.38 R264.1
DDR_A15_CAS: length 48.8
  TOP w0.216: U13.M8 v1(93.6,100.95) ; U23.J5 v1(93.06,82.3)
  L08_SIG2 w0.147: v1(93.06,82.3) 93.46,82.7 94.02,82.7 94.26,82.94 94.26,83.27 94.49,83.5 94.82,83.5 95.06,83.74 95.06,84.87 94.61,85.31 94.61,85.81 93.64,86.79 93.64,90.46 92.69,91.41 92.69,92.66 92.99,92.96 92.99,93.29 92.88,93.4 92.75,93.4 92.64,93.51 92.64,93.66 92.75,93.77 92.88,93.77 92.99,93.88 92.99,94.03 92.88,94.14 92.75,94.14 92.64,94.24 92.64,94.4 92.75,94.5 92.88,94.5 92.99,94.61 92.99,94.77 92.88,94.87 92.55,94.87 92.4,95.02 92.4,95.18 92.51,95.28 94.29,95.28 94.4,95.39 94.4,95.54 94.29,95.65 92.51,95.65 92.4,95.76 92.4,95.91 92.51,96.02 94.29,96.02 94.4,96.13 94.4,96.28 94.29,96.39 92.51,96.39 92.4,96.5 92.4,96.65 92.51,96.76 94.29,96.76 94.4,96.86 94.4,97.02 94.29,97.13 92.51,97.13 92.4,97.23 92.4,97.51 92.55,97.65 93.04,97.65 93.15,97.76 93.15,97.91 93.04,98.02 92.55,98.02 92.44,98.13 92.44,98.28 92.55,98.39 93.04,98.39 93.15,98.5 93.15,98.65 93.04,98.76 92.55,98.76 92.44,98.86 92.44,99.02 92.55,99.12 93.04,99.12 93.15,99.23 93.15,99.38 93.04,99.49 92.55,99.49 92.44,99.6 92.44,99.75 92.55,99.86 93.04,99.86 93.15,99.97 93.15,100.12 93.04,100.23 92.55,100.23 92.44,100.34 92.44,100.49 92.55,100.6 93.04,100.6 93.15,100.71 93.15,100.86 93.04,100.97 92.55,100.97 92.44,101.07 92.44,101.83 92.59,101.98 92.93,101.98 93.13,101.79 93.13,101.43 v1(93.6,100.95)
  BOTTOM w0.114: v1(93.6,100.95) 93.21,101.35 93.21,101.98 93.38,102.15 95.09,102.15 95.58,101.67 95.58,101.47 96.54,100.51 R271.1
DDR_A16_RAS: length 47.7
  TOP w0.216: U23.F6 v1(95.46,81.5) ; U13.L8 v1(93.6,101.75)
  L03_SIG1 w0.147: v1(95.46,81.5) 95.86,81.1 99.06,81.1 100.69,82.74 100.69,83.93 101.91,85.15 101.91,86.03 102.81,86.93 102.81,90.99 101.91,91.89 101.91,92.66 103.33,94.08 103.33,104.69 103.04,104.98 95.59,104.98 95.16,104.55 94.45,104.55 94,104.11 94,102.15 v1(93.6,101.75)
  BOTTOM w0.114: R274.1 96.54,99.78 96.42,99.89 96.15,99.89 94.29,101.75 v1(93.6,101.75)
DDR_ACTN: length 49.5
  TOP w0.114: v1(89.61,101.75) 90.3,101.06 90.3,97.04
  TOP w0.216: U13.L3 v1(89.61,101.75) ; U23.H2 v1(93.86,84.7)
  TOP w0.23: R87.1 89.97,96.72 90.3,97.04
  BOTTOM w0.114: v1(93.86,84.7) 93.71,84.85 93.5,84.85 93.07,85.28 93.07,85.9
  BOTTOM w0.23: 93.07,85.9 93.31,86.15 93.31,87.75 93.08,87.99 92.49,87.99 92.32,87.82 92.32,87.4 92.15,87.24 90.97,87.24 90.74,87.47 90.74,87.93 90.57,88.1 88.25,88.1 88.08,88.27 88.08,88.5 88.25,88.67 90.57,88.67 90.74,88.84 90.74,89.08 90.57,89.25 88.25,89.25 88.08,89.41 88.08,89.65 88.25,89.82 90.57,89.82 90.74,89.99 90.74,90.23 90.57,90.4 88.25,90.4 88.08,90.56 88.08,90.8 88.25,90.97 90.57,90.97 90.74,91.14 90.74,91.38 90.57,91.54 88.25,91.54 88.08,91.71 88.08,91.95 88.25,92.12 90.57,92.12 90.74,92.29 90.74,101.54 90.16,102.12 89.97,102.12 v1(89.61,101.75)
DDR_ALERTN: length 18.4
  TOP w0.14: U23.H1 v1(93.86,85.5) ; U13.P9 v1(94.4,99.35)
  TOP w0.23: v1(94.4,99.35) 94.94,98.82 R69.1
  BOTTOM w0.23: v1(93.86,85.5) 94.35,85.5 95.62,86.77 95.62,90.58 95.5,90.69 95.5,98.26 v1(94.4,99.35)
DDR_BA0: length 47
  TOP w0.216: U13.N2 v1(88.01,100.15) ; U23.G4 v1(94.66,83.1)
  L03_SIG1 w0.147: v1(88.01,100.15) 88.54,100.15 88.69,100.01 88.69,97.31 88.95,97.06 88.95,96.9 88.67,96.63 88.67,96.48 88.78,96.37 88.93,96.37 89.21,96.64 89.36,96.64 89.47,96.54 89.47,96.38 89.19,96.11 89.19,95.96 89.3,95.85 89.45,95.85 89.73,96.12 89.88,96.12 89.99,96.02 89.99,95.86 89.71,95.59 89.71,95.43 89.82,95.33 89.97,95.33 90.25,95.6 90.4,95.6 90.51,95.49 90.51,95.34 90.23,95.07 90.23,94.91 90.34,94.81 90.49,94.81 90.77,95.08 90.92,95.08 91.03,94.97 91.03,94.82 90.75,94.55 90.75,94.39 90.86,94.29 91.01,94.29 91.29,94.56 91.44,94.56 91.75,94.25 92.14,94.25 92.24,94.14 92.24,93.98 92.35,93.87 92.5,93.87 92.61,93.98 92.61,94.14 92.72,94.25 92.87,94.25 92.98,94.14 92.98,93.98 93.09,93.87 93.24,93.87 93.35,93.98 93.35,94.14 93.46,94.25 93.61,94.25 93.72,94.14 93.72,93.98 93.83,93.87 93.98,93.87 94.09,93.98 94.09,94.14 94.19,94.25 96.3,94.25 96.45,94.1 96.45,93.57 96.34,93.47 95.62,93.47 95.52,93.36 95.52,93.21 95.62,93.1 96.34,93.1 96.45,92.99 96.45,92.84 96.34,92.73 95.62,92.73 95.52,92.62 95.52,92.47 95.62,92.36 96.34,92.36 96.45,92.25 96.45,92.1 96.34,91.99 95.62,91.99 95.52,91.89 95.52,91.73 95.62,91.62 96.34,91.62 96.45,91.52 96.45,91.36 96.34,91.26 95.62,91.26 95.52,91.15 95.52,91 95.62,90.89 96.34,90.89 96.45,90.78 96.45,90.63 96.34,90.52 95.62,90.52 95.52,90.41 95.52,90.26 95.62,90.15 96.34,90.15 96.45,90.04 96.45,89.89 96.34,89.78 95.62,89.78 95.52,89.68 95.52,89.52 95.62,89.42 96.34,89.42 96.45,89.31 96.45,89.15 96.34,89.05 95.62,89.05 95.52,88.94 95.52,88.79 95.62,88.68 96.34,88.68 96.45,88.57 96.45,87.85 94.27,85.67 94.26,85.67 94.26,83.5 v1(94.66,83.1)
  BOTTOM w0.114: R273.1 86.96,99.84 87.04,99.76 87.61,99.76 v1(88.01,100.15)
DDR_BA1: length 48.4
  TOP w0.216: U23.G5 v1(94.66,82.3) ; U13.N8 v1(93.6,100.15)
  L03_SIG1 w0.147: v1(93.6,100.15) 94,100.55 94,101.12 94.44,101.56 94.44,103.25 94.65,103.46 94.65,103.61 94.36,103.91 94.36,104.06 94.47,104.17 94.62,104.17 94.91,103.87 95.07,103.87 95.76,104.57 102.81,104.57 102.96,104.42 102.96,94.23 101.54,92.81 101.54,85.3 99.74,83.5 99.29,83.5 99.06,83.27 99.06,82.94 98.82,82.7 98.49,82.7 98.26,82.47 98.26,82.14 98.02,81.9 95.06,81.9 v1(94.66,82.3)
  BOTTOM w0.114: R288.1 92.51,99.06 v1(93.6,100.15)
DDR_BG0: length 47.2
  TOP w0.216: U13.M2 v1(88.01,100.95) ; U23.G2 v1(94.66,84.7)
  L03_SIG1 w0.147: v1(94.66,84.7) 94.66,85.63 95.33,86.31 95.47,86.31 96.82,87.66 96.82,92.86 98.28,94.32 98.68,94.32 99.91,95.55 99.91,95.87 99.38,96.4 99.38,99.27 99.23,99.42 99.01,99.42 98.87,99.27 98.87,97.37 98.51,97.01 98.51,96.86 98.97,96.39 98.97,96.24 98.87,96.13 98.71,96.13 98.25,96.6 98.09,96.6 97.99,96.49 97.99,96.34 98.45,95.87 98.45,95.72 98.35,95.61 98.19,95.61 97.73,96.07 97.57,96.07 97.46,95.97 97.46,95.81 97.93,95.35 97.93,95.19 97.82,95.09 97.67,95.09 97.2,95.55 97.05,95.55 96.94,95.45 96.94,95.29 97.41,94.83 97.41,94.67 97.3,94.57 97.15,94.57 96.68,95.03 96.53,95.03 96.2,94.7 91.93,94.7 88.95,97.68 88.95,100.81 88.8,100.95 v1(88.01,100.95)
  BOTTOM w0.114: R269.1 85.11,101.11 85.66,100.56 87.61,100.56 v1(88.01,100.95)
DDR_CKE: length 50.1
  TOP w0.114: v1(85.16,104.92) 85.09,104.92 R46.1
  TOP w0.216: U13.K2 v1(88.01,102.55) ; U23.F4 v1(95.46,83.1)
  BOTTOM w0.114: 89.05,102.95 88.4,102.95 v1(88.01,102.55) 87.61,102.95 87.61,103.94 87.26,104.28 85.79,104.28 v1(85.16,104.92) 85.47,105.23 R247.1 ; 93.54,85.84 93.46,85.76 93.46,85.34 93.69,85.1 93.89,85.1 93.89,85.1 94.02,85.1 94.26,84.87 94.26,84.73 94.26,84.73 94.26,84.54 94.49,84.3 94.69,84.3 94.69,84.3 94.82,84.3 95.06,84.07 95.06,83.65 95.46,83.24 v1(95.46,83.1)
  BOTTOM w0.23: 93.54,85.84 93.79,86.08 93.79,88.67 93.62,88.84 91.5,88.84 91.34,89.01 91.34,89.25 91.5,89.42 93.62,89.42 93.79,89.59 93.79,89.82 93.62,89.99 91.5,89.99 91.34,90.16 91.34,90.4 91.57,90.63 93.81,90.63 93.97,90.8 93.97,91.19 93.78,91.39 91.56,91.39 91.33,91.62 91.33,91.96 91.5,92.12 92.44,92.12 92.61,92.29 92.61,92.53 92.44,92.7 91.5,92.7 91.33,92.87 91.33,93.1 91.5,93.27 92.44,93.27 92.61,93.44 92.61,93.68 92.44,93.85 91.5,93.85 91.33,94.02 91.33,95.88 91.56,96.1 91.84,96.1 92.01,96.27 92.01,96.51 91.84,96.68 91.5,96.68 91.33,96.85 91.33,97.09 91.5,97.25 91.84,97.25 92.01,97.42 92.01,97.66 91.84,97.83 91.5,97.83 91.33,98 91.33,102.37 90.75,102.95 89.05,102.95
DDR_CLKN: length 47.7
  TOP w0.153: U23.E1 v1(96.26,85.5) ; U13.K8 v1(93.6,102.55)
  L08_SIG2 w0.107: v1(93.6,102.55) 93.6,102.48 93.71,102.37 95.55,102.37 96.3,101.62 97.5,101.62 97.73,101.4 97.73,101.08 97.5,100.86 96.3,100.86 96.21,100.77 96.21,100.63 96.3,100.53 97.5,100.53 97.73,100.31 97.73,100 97.5,99.77 96.3,99.77 96.21,99.68 96.21,99.54 96.3,99.45 97.5,99.45 97.73,99.22 97.73,98.91 97.5,98.69 96.3,98.69 96.21,98.59 96.21,98.46 96.3,98.36 97.5,98.36 97.73,98.14 97.73,97.82 97.5,97.6 96.3,97.6 96.21,97.5 96.21,97.37 96.3,97.27 97.5,97.27 97.73,97.05 97.73,96.74 97.5,96.51 96.3,96.51 96.21,96.42 96.21,96.28 96.3,96.19 97.46,96.19 97.68,95.96 97.68,95.65 97.46,95.43 96.3,95.43 96.21,95.33 96.21,95.19 96.3,95.1 97.47,95.1 97.69,94.88 97.69,94.56 97.47,94.34 96.3,94.34 95.23,93.26 94.76,93.26 94.66,93.16 94.66,93.01 94.76,92.9 95.02,92.9 95.25,92.67 95.25,92.34 95.02,92.11 94.76,92.11 94.66,92 94.66,91.85 94.76,91.75 95.02,91.75 95.25,91.52 95.25,91.19 95.02,90.95 94.76,90.95 94.66,90.85 94.66,90.7 94.76,90.59 95.02,90.59 95.25,90.36 95.25,90.03 95.02,89.8 94.76,89.8 94.61,89.66 94.61,88.67 95.87,87.41 95.87,85.42 95.98,85.32 96.15,85.32 96.26,85.42 v1(96.26,85.5)
  BOTTOM w0.153: v1(93.6,102.55) 93.5,102.55 93.33,102.72 93.33,102.86 93.54,103.08 94.8,103.08 95.6,102.28 96.22,102.28 96.41,102.09 R267.1
DDR_CLKP: length 48
  TOP w0.153: U23.F1 v1(95.46,85.5) ; U13.K7 v1(92.8,102.55)
  L08_SIG2 w0.107: v1(92.8,102.55) 93.21,102.15 95.46,102.15 96.21,101.4 97.41,101.4 97.51,101.31 97.51,101.17 97.41,101.08 96.21,101.08 95.99,100.85 95.99,100.54 96.21,100.32 97.41,100.32 97.51,100.22 97.51,100.09 97.41,99.99 96.21,99.99 95.99,99.77 95.99,99.45 96.21,99.23 97.41,99.23 97.51,99.13 97.51,99 97.41,98.9 96.21,98.9 95.99,98.68 95.99,98.37 96.21,98.14 97.41,98.14 97.51,98.05 97.51,97.91 97.41,97.82 96.21,97.82 95.99,97.59 95.99,97.28 96.21,97.06 97.41,97.06 97.51,96.96 97.51,96.82 97.41,96.73 96.21,96.73 95.99,96.51 95.99,96.19 96.21,95.97 97.37,95.97 97.46,95.87 97.46,95.74 97.37,95.64 96.21,95.64 95.99,95.42 95.99,95.1 96.21,94.88 97.38,94.88 97.47,94.79 97.47,94.65 97.38,94.55 96.21,94.55 95.14,93.48 94.67,93.48 94.44,93.25 94.44,92.92 94.67,92.68 94.93,92.68 95.04,92.58 95.04,92.43 94.93,92.32 94.67,92.32 94.44,92.09 94.44,91.76 94.67,91.53 94.93,91.53 95.04,91.43 95.04,91.28 94.93,91.17 94.67,91.17 94.44,90.94 94.44,90.61 94.67,90.38 94.93,90.38 95.04,90.27 95.04,90.12 94.93,90.02 94.67,90.02 94.4,89.74 94.4,88.58 95.66,87.32 95.66,85.7 v1(95.46,85.5)
  BOTTOM w0.153: R261.1 96.41,102.7 96.26,102.55 95.71,102.55 94.91,103.35 93.43,103.35 93.05,102.98 93.05,102.8 v1(92.8,102.55)
DDR_CSN: length 49.3
  TOP w0.216: U23.E3 v1(96.26,83.9) ; U13.L7 v1(92,101.75)
  BOTTOM w0.114: 95.86,85.79 95.86,84.3 v1(96.26,83.9) ; 95,100.33 94.77,100.56 93.2,100.56 v1(92,101.75) 92,102.56 93.73,104.28 R256.1
  BOTTOM w0.23: 95,100.33 95,99.7 96.01,98.68 96.01,97.79 96.18,97.62 98.74,97.62 98.9,97.45 98.9,97.22 98.74,97.05 96.18,97.05 96.01,96.88 96.01,96.64 96.18,96.47 98.74,96.47 98.9,96.3 98.9,96.07 98.74,95.9 96.18,95.9 96.01,95.73 96.01,95.49 96.18,95.32 98.74,95.32 98.9,95.16 98.9,94.92 98.74,94.75 96.18,94.75 96.01,94.58 96.01,94.19 96.14,94.06 96.14,93.72 96.31,93.55 96.7,93.55 96.86,93.38 96.86,93.14 96.7,92.97 96.31,92.97 96.14,92.81 96.14,92.57 96.31,92.4 96.7,92.4 96.86,92.23 96.86,91.99 96.7,91.82 96.31,91.82 96.14,91.66 96.14,91.42 96.31,91.25 96.7,91.25 96.86,91.08 96.86,90.84 96.7,90.67 96.31,90.67 96.14,90.51 96.14,90.27 96.31,90.1 96.7,90.1 96.86,89.93 96.86,89.69 96.7,89.53 96.31,89.53 96.14,89.36 96.14,89.12 96.31,88.95 96.7,88.95 96.86,88.78 96.86,88.54 96.7,88.38 96.31,88.38 96.14,88.21 96.14,86.07 95.86,85.79
DDR_DQ0: length 43.3
  TOP w0.216: U13.G2 v1(88.81,105.75) ; U23.A3 v1(99.46,83.9)
  L08_SIG2 w0.147: v1(99.46,83.9) 100.56,85 100.56,91.86 100.74,92.04 100.9,92.04 101.2,91.74 101.35,91.74 101.46,91.85 101.46,92 101.16,92.3 101.16,92.46 101.27,92.56 101.42,92.56 101.72,92.26 101.87,92.26 101.98,92.37 101.98,92.52 101.68,92.82 101.68,92.98 101.79,93.08 101.94,93.08 102.24,92.78 102.39,92.78 102.5,92.89 102.5,93.04 102.2,93.34 102.2,93.5 102.87,94.17 102.87,105.64 102.73,105.79 95,105.79 94.57,105.35 92.64,105.35 91.04,106.95 89.69,106.95 89.33,106.59 89.33,105.88 89.21,105.75 v1(88.81,105.75)
DDR_DQ1: length 43.3
  TOP w0.216: U23.A4 v1(99.46,83.1) ; U13.F7 v1(92.8,106.55)
  L08_SIG2 w0.147: v1(99.46,83.1) 99.73,83.1 101.3,84.67 101.3,90.46 103.61,92.78 103.61,106.51 103.17,106.95 102.58,106.95 102.47,107.06 102.47,107.26 102.36,107.37 102.21,107.37 102.1,107.26 102.1,107.06 101.99,106.95 101.84,106.95 101.73,107.06 101.73,107.26 101.63,107.37 101.47,107.37 101.37,107.26 101.37,107.06 101.26,106.95 101.11,106.95 101,107.06 101,107.26 100.89,107.37 100.74,107.37 100.63,107.26 100.63,107.06 100.52,106.95 100.37,106.95 100.26,107.06 100.26,107.26 100.15,107.37 100,107.37 99.89,107.26 99.89,107.06 99.78,106.95 99.63,106.95 99.52,107.06 99.52,107.26 99.42,107.37 99.26,107.37 99.16,107.26 99.16,107.06 99.05,106.95 98.9,106.95 98.79,107.06 98.79,107.26 98.68,107.37 98.53,107.37 98.42,107.26 98.42,107.06 98.31,106.95 98.16,106.95 98.05,107.06 98.05,107.26 97.94,107.37 97.79,107.37 97.68,107.26 97.68,107.06 97.57,106.95 97.42,106.95 97.31,107.06 97.31,107.26 97.21,107.37 97.05,107.37 96.95,107.26 96.95,107.06 96.84,106.95 96.69,106.95 96.58,107.06 96.58,107.26 96.47,107.37 96.32,107.37 96.21,107.26 96.21,107.06 96.1,106.95 95.95,106.95 95.84,107.06 95.84,107.26 95.73,107.37 95.58,107.37 95.47,107.26 95.47,107.06 95.36,106.95 93.2,106.95 v1(92.8,106.55)
DDR_DQ2: length 43.3
  TOP w0.216: U23.B4 v1(98.66,83.1) ; U13.H3 v1(88.81,104.95)
  L08_SIG2 w0.147: v1(88.81,104.95) 88.41,105.35 88.41,105.96 88.95,106.5 88.95,106.6 89.56,107.21 91.55,107.21 92.61,106.15 102.97,106.15 103.24,105.88 103.24,92.93 100.93,90.62 100.93,84.79 99.64,83.5 99.06,83.5 v1(98.66,83.1)
DDR_DQ3: length 43.3
  TOP w0.216: U23.B3 v1(98.66,83.9) ; U13.H7 v1(92.8,104.95)
  L08_SIG2 w0.147: v1(98.66,83.9) 99.06,84.3 99.06,84.54 99.06,84.54 99.06,85.67 99.29,85.9 99.68,85.9 99.82,86.05 99.82,93.08 100.06,93.31 100.21,93.31 100.37,93.15 100.52,93.15 100.63,93.26 100.63,93.41 100.47,93.57 100.47,93.73 100.58,93.83 100.73,93.83 100.89,93.67 101.04,93.67 101.15,93.78 101.15,93.93 100.99,94.09 100.99,94.25 101.41,94.66 102.03,94.66 102.14,94.77 102.14,94.93 102.03,95.03 101.56,95.03 101.45,95.14 101.45,95.29 101.56,95.4 102.03,95.4 102.14,95.51 102.14,95.66 102.03,95.77 101.56,95.77 101.45,95.88 101.45,96.03 101.56,96.14 102.03,96.14 102.14,96.25 102.14,96.4 102.03,96.51 101.56,96.51 101.45,96.61 101.45,96.77 101.56,96.87 102.03,96.87 102.14,96.98 102.14,97.13 102.03,97.24 101.56,97.24 101.45,97.35 101.45,97.5 101.56,97.61 102.03,97.61 102.14,97.72 102.14,97.87 102.03,97.98 101.56,97.98 101.45,98.09 101.45,98.24 101.56,98.35 102.03,98.35 102.14,98.46 102.14,98.61 102.03,98.72 101.56,98.72 101.45,98.82 101.45,98.98 101.56,99.08 102.03,99.08 102.14,99.19 102.14,99.34 102.03,99.45 101.56,99.45 101.45,99.56 101.45,99.84 101.8,100.19 101.8,101.02 101.91,101.13 102.02,101.13 102.13,101.24 102.13,101.39 102.02,101.5 101.91,101.5 101.8,101.61 101.8,101.76 101.91,101.87 102.02,101.87 102.13,101.98 102.13,102.13 102.02,102.24 101.91,102.24 101.8,102.34 101.8,102.5 101.91,102.6 102.02,102.6 102.13,102.71 102.13,102.87 102.02,102.97 101.91,102.97 101.8,103.08 101.8,103.23 101.91,103.34 102.02,103.34 102.13,103.45 102.13,103.6 102.02,103.71 101.91,103.71 101.8,103.82 101.8,104.13 101.65,104.28 93.01,104.28 92.8,104.48 v1(92.8,104.95)
DDR_DQ4: length 43.2
  TOP w0.216: U23.B5 v1(98.66,82.3) ; U13.H2 v1(88.01,104.95)
  L08_SIG2 w0.147: v1(98.66,82.3) 98.43,82.3 98.04,82.69 98.04,82.69 98.02,82.7 96.77,82.7 96.66,82.82 96.66,85.67 96.66,85.73 96.36,86.03 96.36,87.96 96.25,88.07 95.98,88.07 95.87,88.17 95.87,88.33 95.98,88.43 96.25,88.43 96.36,88.54 96.36,88.7 96.25,88.8 95.98,88.8 95.87,88.91 95.87,89.06 95.98,89.17 96.25,89.17 96.36,89.28 96.36,89.55 96.1,89.82 96.1,89.98 95.99,90.08 95.77,90.08 95.67,90.19 95.67,90.34 95.77,90.45 95.99,90.45 96.1,90.56 96.1,90.71 95.99,90.82 95.77,90.82 95.67,90.93 95.67,91.08 95.77,91.19 95.99,91.19 96.1,91.3 96.1,91.45 95.99,91.56 95.77,91.56 95.67,91.67 95.67,91.82 95.77,91.93 95.99,91.93 96.1,92.03 96.1,92.19 95.99,92.29 95.77,92.29 95.67,92.4 95.67,93.07 95.82,93.23 95.98,93.23 96.29,92.92 96.44,92.92 96.55,93.03 96.55,93.18 96.24,93.49 96.24,93.64 96.42,93.82 97.96,93.82 98.44,94.31 98.44,99.98 99.11,100.64 99.11,102.04 98.76,102.38 96.96,102.38 96.38,102.95 92.53,102.95 92.13,102.56 89.36,102.56 88.97,102.95 88.58,102.95 88.41,103.13 U13.H2 v1(88.01,104.95)
DDR_DQ5: length 43.3
  TOP w0.216: U13.H8 v1(93.6,104.95) ; U23.A2 v1(99.46,84.7)
  L08_SIG2 w0.147: v1(93.6,104.95) 93.6,104.7 93.75,104.55 95.54,104.55 95.77,104.79 95.77,105.16 95.99,105.39 96.28,105.39 96.38,105.28 96.38,104.78 96.49,104.67 96.64,104.67 96.75,104.78 96.75,105.28 96.86,105.39 97.01,105.39 97.12,105.28 97.12,104.78 97.23,104.67 97.38,104.67 97.49,104.78 97.49,105.28 97.6,105.39 97.75,105.39 97.86,105.28 97.86,104.78 97.96,104.67 98.12,104.67 98.23,104.78 98.23,105.28 98.33,105.39 98.49,105.39 98.59,105.28 98.59,104.78 98.7,104.67 98.85,104.67 98.96,104.78 98.96,105.28 99.07,105.39 99.22,105.39 99.33,105.28 99.33,104.78 99.44,104.67 99.59,104.67 99.7,104.78 99.7,105.28 99.81,105.39 99.96,105.39 100.07,105.28 100.07,104.78 100.17,104.67 100.33,104.67 100.43,104.78 100.43,105.28 100.54,105.39 100.7,105.39 100.8,105.28 100.8,104.78 100.91,104.67 101.06,104.67 101.17,104.78 101.17,105.28 101.28,105.39 101.43,105.39 101.54,105.28 101.54,104.78 101.65,104.67 101.8,104.67 101.91,104.78 101.91,105.28 102.02,105.39 102.36,105.39 102.51,105.24 102.51,94.32 101.81,93.63 101.58,93.63 101.44,93.49 101.44,93.25 101.29,93.11 101.06,93.11 100.91,92.97 100.91,92.73 100.77,92.59 100.54,92.59 100.39,92.45 100.39,92.21 100.19,92.01 100.19,85.91 100.08,85.8 100.02,85.8 99.91,85.69 99.91,85.54 100.02,85.43 100.1,85.43 100.25,85.28 100.25,85.06 99.89,84.7 v1(99.46,84.7)
DDR_DQ6: length 43.2
  TOP w0.216: U23.C4 v1(97.86,83.1) ; U13.J3 v1(88.81,103.35)
  L08_SIG2 w0.147: v1(97.86,83.1) 97.46,83.5 97.46,83.74 97.46,83.74 97.46,84.87 97.17,85.15 97.17,87.26 96.84,87.6 96.84,89.6 96.47,89.97 96.47,90.34 96.57,90.45 96.87,90.45 96.98,90.56 96.98,90.71 96.87,90.82 96.57,90.82 96.47,90.93 96.47,91.08 96.57,91.19 96.87,91.19 96.98,91.29 96.98,91.45 96.87,91.55 96.57,91.55 96.47,91.66 96.47,91.81 96.57,91.92 96.87,91.92 96.98,92.03 96.98,92.4 97.08,92.5 98.07,92.5 98.18,92.61 98.18,92.77 98.07,92.87 97.08,92.87 96.98,92.98 96.98,93.18 97.25,93.45 98.11,93.45 98.81,94.16 98.81,99.83 99.48,100.49 99.48,102.19 98.92,102.75 97.27,102.75 96.76,103.26 92.14,103.26 91.99,103.41 91.66,103.41 91.2,102.96 91.02,102.96 90.91,103.07 90.91,103.8 90.8,103.91 90.65,103.91 90.54,103.8 90.54,103.07 90.43,102.96 90.28,102.96 90.17,103.07 90.17,103.8 90.06,103.91 89.91,103.91 89.8,103.8 89.8,103.07 89.7,102.96 89.49,102.96 89.32,103.13 89.32,104.26 89.21,104.37 88.95,104.37 88.81,104.22 v1(88.81,103.35)
DDR_DQ7: length 43.3
  TOP w0.216: U13.J7 91.97,103.75 v1(91.82,103.9) ; U23.C2 v1(97.86,84.7)
  L08_SIG2 w0.147: v1(97.86,84.7) 97.86,84.92 97.45,85.33 97.45,86.48 97.55,86.59 97.79,86.59 97.9,86.7 97.9,86.85 97.79,86.96 97.55,86.96 97.45,87.07 97.45,87.22 97.55,87.33 97.79,87.33 97.9,87.44 97.9,87.59 97.79,87.7 97.55,87.7 97.45,87.81 97.45,87.96 97.55,88.07 97.79,88.07 97.9,88.17 97.9,88.33 97.79,88.43 97.55,88.43 97.45,88.54 97.45,88.69 97.55,88.8 97.79,88.8 97.9,88.91 97.9,89.06 97.79,89.17 97.55,89.17 97.45,89.28 97.45,89.43 97.55,89.54 97.79,89.54 97.9,89.65 97.9,89.8 97.79,89.91 97.55,89.91 97.45,90.02 97.45,90.17 97.55,90.28 97.79,90.28 97.9,90.38 97.9,90.54 97.79,90.64 97.55,90.64 97.45,90.75 97.45,90.9 97.55,91.01 97.79,91.01 97.9,91.12 97.9,91.27 97.79,91.38 97.55,91.38 97.38,91.56 97.38,91.96 97.49,92.07 98.28,92.07 98.69,92.48 98.69,93.51 99.18,94 99.18,94.39 99.29,94.5 99.89,94.5 99.99,94.61 99.99,94.76 99.89,94.87 99.29,94.87 99.18,94.98 99.18,95.13 99.29,95.24 99.89,95.24 99.99,95.35 99.99,95.5 99.89,95.61 99.29,95.61 99.18,95.71 99.18,95.87 99.29,95.98 99.89,95.98 99.99,96.08 99.99,96.24 99.89,96.34 99.29,96.34 99.18,96.45 99.18,96.6 99.29,96.71 99.89,96.71 99.99,96.82 99.99,96.97 99.89,97.08 99.29,97.08 99.18,97.19 99.18,97.34 99.29,97.45 99.89,97.45 99.99,97.56 99.99,97.71 99.89,97.82 99.29,97.82 99.18,97.92 99.18,98.08 99.29,98.18 99.89,98.18 99.99,98.29 99.99,98.45 99.89,98.55 99.29,98.55 99.18,98.66 99.18,98.81 99.29,98.92 99.89,98.92 99.99,99.03 99.99,99.18 99.89,99.29 99.29,99.29 99.18,99.4 99.18,99.67 99.84,100.34 99.84,102.34 98.95,103.24 97.76,103.24 97.48,103.52 92.6,103.52 92.22,103.9 v1(91.82,103.9)
DDR_DQ8: length 44.3
  TOP w0.216: U13.A3 89.21,111.14 89.28,111.22 v1(89.28,111.71) ; U23.N5 v1(89.06,82.3)
  L08_SIG2 w0.147: v1(89.28,111.71) 88.83,112.16 85.97,112.16 83.35,109.54 83.2,109.54 83.06,109.68 82.91,109.68 82.8,109.57 82.8,109.42 82.94,109.28 82.94,109.13 82.83,109.02 82.68,109.02 82.54,109.16 82.39,109.16 82.28,109.05 82.28,108.89 82.42,108.76 82.42,108.61 82.31,108.5 82.16,108.5 82.02,108.63 81.87,108.63 81.76,108.53 81.76,108.37 81.9,108.24 81.9,108.09 80.69,106.88 80.69,95.09 80.9,94.88 83.64,92.14 83.64,87.31 84.04,86.9 85.89,86.9 87.86,84.93 87.86,82.94 88.09,82.7 88.66,82.7 v1(89.06,82.3)
DDR_DQ9: length 44.3
  TOP w0.216: U13.B8 v1(92.8,109.75) ; U23.N4 v1(89.06,83.1)
  L08_SIG2 w0.147: v1(89.06,83.1) 88.66,83.5 88.66,83.74 88.66,83.74 88.66,84.07 88.66,84.07 88.66,85.09 84.07,89.68 84.07,92.23 81.05,95.25 81.05,106.6 86.33,111.88 88.54,111.88 89.12,111.31 90.72,111.31 91.06,111.65 92.58,111.65 93.11,111.12 93.11,110.06 v1(92.8,109.75)
DDR_DQ10: length 44.2
  TOP w0.216: U13.C3 v1(88.81,108.95) ; U23.M3 v1(89.86,83.9)
  L08_SIG2 w0.147: v1(88.81,108.95) 88.41,108.55 86.8,108.55 85.74,107.5 85.16,107.5 84.72,107.05 84.72,106.9 84.97,106.64 84.97,106.49 84.86,106.38 84.71,106.38 84.46,106.64 84.3,106.64 84.03,106.36 84.03,106.09 84.14,105.98 84.59,105.98 84.7,105.87 84.7,105.72 84.59,105.61 84.14,105.61 84.03,105.51 84.03,105.35 84.14,105.25 84.59,105.25 84.7,105.14 84.7,104.99 84.59,104.88 84.14,104.88 84.03,104.77 84.03,104.62 84.14,104.51 84.59,104.51 84.7,104.4 84.7,104.25 84.59,104.14 84.14,104.14 84.03,104.03 84.03,103.88 84.14,103.77 84.59,103.77 84.7,103.66 84.7,103.51 84.59,103.4 84.14,103.4 84.03,103.3 84.03,103.14 84.14,103.04 84.59,103.04 84.7,102.93 84.7,102.78 84.59,102.67 84.14,102.67 84.03,102.56 84.03,102.18 85.07,101.14 85.07,96.06 86.83,94.29 86.83,93.86 86.73,93.75 86.61,93.75 86.5,93.65 86.5,93.49 86.61,93.39 86.73,93.39 86.83,93.28 86.83,93.13 86.73,93.02 86.61,93.02 86.5,92.91 86.5,92.76 86.61,92.65 86.73,92.65 86.83,92.54 86.83,92.39 86.73,92.28 86.61,92.28 86.5,92.17 86.5,92.02 86.61,91.91 86.73,91.91 86.83,91.8 86.83,91.65 86.73,91.54 86.61,91.54 86.5,91.44 86.5,91.28 86.61,91.18 86.73,91.18 86.83,91.07 86.83,90.92 86.73,90.81 86.61,90.81 86.5,90.7 86.5,90.55 86.61,90.44 86.73,90.44 86.83,90.33 86.83,89.92 87.03,89.72 87.18,89.72 87.48,90.03 87.64,90.03 87.75,89.92 87.75,89.77 87.44,89.46 87.44,89.31 87.55,89.2 87.7,89.2 88.01,89.51 88.16,89.51 88.27,89.4 88.27,89.25 87.96,88.94 87.96,88.79 88.41,88.33 89.49,88.33 91.03,86.8 91.03,84.64 90.29,83.9 v1(89.86,83.9)
DDR_DQ11: length 44.2
  TOP w0.216: U23.M4 v1(89.86,83.1) ; U13.C7 v1(92.8,108.95)
  L08_SIG2 w0.147: v1(89.86,83.1) 91.06,84.3 91.62,84.3 91.86,84.54 91.86,85.67 92.09,85.9 92.09,87.23 91.5,87.82 91.5,88.09 90.24,89.36 90.08,89.36 89.93,89.21 89.77,89.21 89.66,89.31 89.66,89.47 89.82,89.62 89.82,89.78 89.71,89.88 89.56,89.88 89.4,89.73 89.25,89.73 89.14,89.83 89.14,89.99 89.3,90.14 89.3,90.3 89.19,90.4 89.04,90.4 88.88,90.25 88.73,90.25 88.62,90.36 88.62,90.51 88.78,90.66 88.78,90.82 88.46,91.14 88.46,91.49 88.57,91.6 88.73,91.6 88.84,91.71 88.84,91.86 88.73,91.97 88.57,91.97 88.46,92.08 88.46,92.23 88.57,92.34 88.73,92.34 88.84,92.45 88.84,92.6 88.73,92.71 88.57,92.71 88.46,92.82 88.46,92.97 88.57,93.08 88.73,93.08 88.84,93.18 88.84,93.34 88.73,93.44 88.57,93.44 88.46,93.55 88.46,93.7 88.57,93.81 88.73,93.81 88.84,93.92 88.84,94.07 88.73,94.18 88.57,94.18 88.46,94.29 88.46,94.44 88.57,94.55 88.73,94.55 88.84,94.66 88.84,94.81 88.73,94.92 88.57,94.92 88.46,95.02 88.46,95.37 88.17,95.65 87.01,95.65 86.25,96.41 86.25,106.33 86.87,106.95 88.17,106.95 88.31,107.1 88.72,107.1 89.79,108.17 89.79,109.92 90.04,110.17 90.57,110.17 91.12,109.62 91.12,108.63 91.13,108.63 91.13,108.34 91.27,108.2 92.05,108.2 v1(92.8,108.95)
DDR_DQ12: length 44.2
  TOP w0.216: U13.C2 v1(88.01,108.95) ; U23.N3 v1(89.06,83.9)
  L08_SIG2 w0.147: v1(88.01,108.95) 87.61,109.35 86.21,109.35 85.87,109.02 85.87,108.18 85.64,107.95 84.96,107.95 83.59,106.58 83.59,101.17 83.7,101.06 84.41,101.06 84.51,100.96 84.51,100.8 84.41,100.7 83.7,100.7 83.59,100.59 83.59,100.44 83.7,100.33 84.41,100.33 84.51,100.22 84.51,100.07 84.41,99.96 83.7,99.96 83.59,99.85 83.59,99.7 83.7,99.59 84.41,99.59 84.51,99.48 84.51,99.33 84.41,99.22 83.7,99.22 83.59,99.12 83.59,98.96 83.7,98.85 84.41,98.85 84.51,98.75 84.51,98.59 84.41,98.49 83.7,98.49 83.59,98.38 83.59,98.23 83.7,98.12 84.41,98.12 84.51,98.01 84.51,97.86 84.41,97.75 83.7,97.75 83.59,97.64 83.59,96.39 83.82,96.16 83.97,96.16 84.09,96.28 84.24,96.28 84.35,96.17 84.35,96.02 84.23,95.9 84.23,95.75 84.34,95.64 84.49,95.64 84.61,95.76 84.76,95.76 84.87,95.65 84.87,95.5 84.75,95.38 84.75,95.23 84.86,95.12 85.01,95.12 85.13,95.24 85.28,95.24 85.39,95.13 85.39,94.98 85.27,94.86 85.27,94.71 86.13,93.85 86.13,90.1 88.26,87.97 89.34,87.97 90.77,86.53 90.77,84.95 90.13,84.3 89.46,84.3 v1(89.06,83.9)
DDR_DQ13: length 44.3
  TOP w0.216: U23.N2 v1(89.06,84.7) ; U13.C8 v1(93.6,108.95)
  L08_SIG2 w0.147: v1(89.06,84.7) 89.46,85.1 90.02,85.1 90.26,85.34 90.26,86.01 89.13,87.15 87.98,87.15 85.03,90.1 85.03,92.69 82.65,95.07 82.65,98.26 82.54,98.37 82.13,98.37 82.02,98.47 82.02,98.63 82.13,98.73 82.54,98.73 82.65,98.84 82.65,98.99 82.54,99.1 82.13,99.1 82.02,99.21 82.02,99.36 82.13,99.47 82.54,99.47 82.65,99.58 82.65,99.73 82.54,99.84 82.13,99.84 82.02,99.95 82.02,100.1 82.13,100.21 82.54,100.21 82.65,100.32 82.65,105.83 82.81,106 82.81,106.84 86.97,111.01 88.27,111.01 88.77,110.5 90.6,110.5 91.75,109.35 93.2,109.35 v1(93.6,108.95)
DDR_DQ14: length 44.3
  TOP w0.216: U13.D3 v1(88.81,108.15) ; U23.L2 v1(91.46,84.7)
  L08_SIG2 w0.147: v1(91.46,84.7) 91.46,85.85 91.29,86.01 91.29,86.41 91.37,86.49 91.37,87.43 91.14,87.66 91.14,87.94 90.37,88.7 89.48,88.7 89.41,88.78 89.41,89.02 89.27,89.16 89.03,89.16 88.89,89.3 88.89,89.54 88.75,89.68 88.5,89.68 88.37,89.82 88.37,90.06 88.23,90.2 87.98,90.2 87.98,90.53 87.88,90.63 87.33,90.63 87.22,90.74 87.22,90.89 87.33,91 87.88,91 87.98,91.11 87.98,91.26 87.88,91.37 87.33,91.37 87.22,91.48 87.22,91.63 87.33,91.74 87.88,91.74 87.98,91.85 87.98,92 87.88,92.11 87.33,92.11 87.22,92.22 87.22,92.37 87.33,92.48 87.88,92.48 87.98,92.58 87.98,92.74 87.88,92.84 87.33,92.84 87.22,92.95 87.22,93.1 87.33,93.21 87.88,93.21 87.98,93.32 87.98,93.47 87.88,93.58 87.33,93.58 87.22,93.69 87.22,93.84 87.33,93.95 87.88,93.95 87.98,94.06 87.98,94.21 87.88,94.32 87.33,94.32 87.22,94.43 87.22,94.58 87.33,94.69 87.88,94.69 87.98,94.79 87.98,94.97 87.77,95.19 86.46,95.19 85.55,96.1 85.55,96.49 85.66,96.6 85.85,96.6 85.96,96.71 85.96,96.86 85.85,96.97 85.66,96.97 85.55,97.08 85.55,97.23 85.66,97.34 85.85,97.34 85.96,97.45 85.96,97.6 85.85,97.71 85.66,97.71 85.55,97.82 85.55,97.97 85.66,98.08 85.85,98.08 85.96,98.18 85.96,98.34 85.85,98.44 85.66,98.44 85.55,98.55 85.55,98.7 85.66,98.81 85.85,98.81 85.96,98.92 85.96,99.07 85.85,99.18 85.66,99.18 85.55,99.29 85.55,99.44 85.66,99.55 85.85,99.55 85.96,99.66 85.96,99.81 85.85,99.92 85.66,99.92 85.55,100.02 85.55,100.18 85.66,100.29 85.85,100.29 85.96,100.39 85.96,100.55 85.85,100.65 85.66,100.65 85.55,100.76 85.55,100.91 85.66,101.02 85.85,101.02 85.96,101.13 85.96,101.28 85.85,101.39 85.66,101.39 85.55,101.5 85.55,101.65 85.66,101.76 85.85,101.76 85.96,101.87 85.96,102.02 85.85,102.13 85.66,102.13 85.55,102.23 85.55,102.4 85.69,102.54 85.69,102.79 85.89,102.98 85.89,103.15 85.69,103.35 85.69,103.52 85.89,103.72 85.89,103.89 85.69,104.09 85.69,104.26 85.89,104.46 85.89,104.63 85.69,104.83 85.69,105 85.89,105.19 85.89,105.36 85.69,105.56 85.69,105.73 85.89,105.93 85.89,106.1 85.69,106.3 85.69,106.95 86.5,107.75 88.41,107.75 v1(88.81,108.15)
DDR_DQ15: length 44.2
  TOP w0.216: U23.L4 v1(91.46,83.1) ; U13.D7 v1(92.8,108.15)
  L08_SIG2 w0.147: v1(91.46,83.1) 91.86,83.5 91.86,84.07 92.09,84.3 92.42,84.3 92.66,84.54 92.66,87.18 91.87,87.97 91.87,88.25 89.27,90.85 89.27,95.65 89.16,95.76 88.93,95.76 88.82,95.87 88.82,96.02 88.93,96.13 89.16,96.13 89.27,96.24 89.27,96.39 89.16,96.5 88.93,96.5 88.82,96.61 88.82,96.76 88.93,96.87 89.16,96.87 89.27,96.97 89.27,97.15 89.12,97.29 88.47,97.29 88.36,97.19 88.36,96.29 88.26,96.18 88.1,96.18 88,96.29 88,97.19 87.89,97.29 87.73,97.29 87.63,97.19 87.63,96.29 87.52,96.18 87.37,96.18 87.26,96.29 87.26,97.19 87.15,97.29 86.99,97.29 86.67,97.61 86.67,106.01 86.82,106.16 87.04,106.16 87.04,106.15 88.23,106.15 88.69,106.61 88.69,106.7 90.05,108.06 90.05,109.63 90.2,109.77 90.6,109.77 90.86,109.51 90.86,108.53 90.87,108.52 90.87,108.1 91.25,107.73 92.44,107.73 92.8,108.09 v1(92.8,108.15)
DDR_LDM: length 43.3
  TOP w0.216: U13.E7 v1(92.8,107.35) ; U23.B2 v1(98.66,84.7)
  L08_SIG2 w0.147: v1(92.8,107.35) 93.2,107.75 103.78,107.75 103.98,107.55 103.98,92.59 103.1,91.71 103.1,90.41 102.72,90.03 101.93,90.03 101.78,89.89 101.78,84.54 99.94,82.7 99.63,82.7 99.62,82.7 98.49,82.7 98.26,82.94 98.26,84.07 98.26,84.07 98.26,84.3 v1(98.66,84.7)
DDR_LDQS_N: length 43.2
  TOP w0.153: U23.B1 v1(98.66,85.5)
  TOP w0.216: U13.F3 89.53,106.48 v1(89.79,106.48)
  L08_SIG2 w0.107: v1(89.79,106.48) 89.79,106.37 89.9,106.26 91.25,106.26 91.54,105.97 91.54,105.56 91.31,105.33 90.6,105.33 90.51,105.24 90.51,104.93 90.62,104.82 91.41,104.82 91.67,104.56 92.32,104.56 92.9,103.98 97.83,103.98 98,103.81 100.35,103.81 100.58,103.57 100.58,102.88 100.68,102.78 101.09,102.78 101.32,102.56 101.32,102.24 101.09,102.02 100.68,102.02 100.58,101.92 100.58,101.79 100.68,101.69 101.08,101.69 101.3,101.47 101.3,101.16 101.08,100.93 100.68,100.93 100.58,100.84 100.58,99.94 100.68,99.84 100.86,99.84 101.08,99.62 101.08,99.3 100.86,99.08 100.68,99.08 100.58,98.98 100.58,98.85 100.68,98.75 100.86,98.75 101.08,98.53 101.08,98.22 100.86,97.99 100.68,97.99 100.58,97.9 100.58,97.76 100.68,97.67 100.86,97.67 101.08,97.44 101.08,97.13 100.86,96.91 100.68,96.91 100.58,96.81 100.58,96.67 100.68,96.58 100.86,96.58 101.08,96.36 101.08,96.04 100.86,95.82 100.68,95.82 100.58,95.72 100.58,94.36 99.47,93.26 99.47,90.01 99.25,89.78 98.56,89.78 98.46,89.69 98.46,89.55 98.56,89.46 99.25,89.46 99.47,89.23 99.47,88.92 99.25,88.7 98.56,88.7 98.46,88.6 98.46,88.47 98.56,88.37 99.25,88.37 99.47,88.15 99.47,87.65 99.25,87.42 99.01,87.42 98.92,87.33 98.92,87.19 99.01,87.1 99.03,87.1 99.25,86.87 99.25,86.33 99.02,86.1 98.76,86.1 98.66,86 v1(98.66,85.5)
DDR_LDQS_P: length 43.3
  TOP w0.153: U23.C1 v1(97.86,85.5)
  TOP w0.216: v1(89.79,105.68) 89.53,105.68 U13.G3
  L08_SIG2 w0.107: v1(97.86,85.5) 98.67,86.31 98.93,86.31 99.03,86.42 99.03,86.79 98.94,86.88 98.93,86.88 98.7,87.1 98.7,87.42 98.93,87.64 99.16,87.64 99.26,87.74 99.26,88.06 99.16,88.15 98.47,88.15 98.24,88.38 98.24,88.69 98.47,88.91 99.16,88.91 99.26,89.01 99.26,89.15 99.16,89.24 98.47,89.24 98.24,89.46 98.24,89.78 98.47,90 99.16,90 99.26,90.1 99.26,93.35 100.37,94.45 100.37,95.81 100.59,96.04 100.77,96.04 100.87,96.13 100.87,96.27 100.77,96.36 100.59,96.36 100.37,96.59 100.37,96.9 100.59,97.12 100.77,97.12 100.87,97.22 100.87,97.35 100.77,97.45 100.59,97.45 100.37,97.67 100.37,97.99 100.59,98.21 100.77,98.21 100.87,98.31 100.87,98.44 100.77,98.54 100.59,98.54 100.37,98.76 100.37,99.07 100.59,99.3 100.77,99.3 100.87,99.39 100.87,99.53 100.77,99.62 100.59,99.62 100.37,99.85 100.37,100.93 100.59,101.15 100.99,101.15 101.09,101.25 101.09,101.38 100.99,101.48 100.59,101.48 100.37,101.7 100.37,102.01 100.59,102.24 101,102.24 101.1,102.33 101.1,102.47 101,102.56 100.59,102.56 100.37,102.79 100.37,103.48 100.26,103.59 97.91,103.59 97.74,103.77 92.81,103.77 92.23,104.34 91.58,104.34 91.32,104.61 90.53,104.61 90.29,104.84 90.29,105.33 90.52,105.55 91.23,105.55 91.32,105.65 91.32,105.88 91.16,106.04 89.89,106.04 89.79,105.94 v1(89.79,105.68)
DDR_ODT: length 36.4
  TOP w0.216: U23.E5 v1(96.26,82.3) ; U13.K3 v1(88.81,102.55)
  BOTTOM w0.114: v1(96.26,82.3) 95.86,82.7 95.29,82.7 95.06,82.94 95.06,83.14 95.06,83.14 95.06,83.27 94.82,83.5 94.69,83.5 94.49,83.5 94.26,83.74 94.26,83.94 94.26,83.94 94.26,84.09 94.04,84.3 92.89,84.3 92.66,84.54 92.66,85.14 ; R258.1 85.22,103.65 86.71,102.16 88.41,102.16 v1(88.81,102.55) 88.81,101.58 89.03,101.36 89.71,101.36 89.71,101.35 89.77,101.35 90.21,100.92 90.21,100.31
  BOTTOM w0.23: 92.66,85.14 92.66,85.26 92.72,85.31 92.72,85.69 92.62,85.79 92.62,86.39 92.17,86.84 88.74,86.84 87.54,88.03 87.54,92.21 88.14,92.81 89.82,92.81 90.21,93.2 90.21,100.31
DDR_PARITY: length 46.2
  TOP w0.114: 89.27,97.42 v1(89.61,97.75)
  TOP w0.216: v1(89.61,97.75) U13.T3 ; U23.K5 v1(92.26,82.3)
  TOP w0.23: R85.1 87.47,96.01 88.89,97.42 89.27,97.42
  BOTTOM w0.114: 91.29,85.43 91.86,84.87 91.86,82.7 v1(92.26,82.3)
  BOTTOM w0.23: v1(89.61,97.75) 89.61,94.11 88.92,93.43 88.11,93.43 87.6,92.92 84.88,92.92 84.71,92.75 84.71,92.51 84.88,92.35 86.86,92.35 87.03,92.18 87.03,91.94 86.86,91.77 84.88,91.77 84.71,91.6 84.71,91.37 84.88,91.2 86.86,91.2 87.03,91.03 87.03,90.79 86.86,90.62 84.88,90.62 84.71,90.45 84.71,90.22 84.88,90.05 86.86,90.05 87.03,89.88 87.03,89.64 86.86,89.47 84.88,89.47 84.71,89.3 84.71,89.07 84.88,88.9 86.86,88.9 87.03,88.73 87.03,88.49 86.86,88.32 84.88,88.32 84.71,88.16 84.71,87.92 84.88,87.75 86.86,87.75 87.03,87.58 87.03,87.29 87.9,86.42 90.31,86.42 91.29,85.43
DDR_RESET#: length 56.8
  TOP w0.147: U23.D5 v1(97.06,82.3)
  TOP w0.23: U13.P1 87.21,99.35 R67.1 R66.2 83.95,101.36 v1(85.22,102.63)
  L03_SIG1 w0.091: v1(85.22,102.63) 87.15,104.57 93.94,104.57 94.76,105.39 103.13,105.39 103.73,104.79 103.73,95.88 v1(104.62,94.98)
  BOTTOM w0.114: v1(97.06,82.3) 97.46,82.7 97.46,85.06
  BOTTOM w0.147: 97.46,85.06 97.28,85.23 97.28,91.96 97.79,92.47 102.11,92.47 v1(104.62,94.98)
