# Allegro board PROC101A_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_TEN: length 3.9
  TOP w0.216: U13.N9 94.4,100.15
  TOP w0.23: 94.4,100.15 96.35,100.15 R62.2 R63.1
DDR_UDM: length 44.2
  TOP w0.216: U23.M2 v1(89.86,84.7) ; U13.E2 v1(88.01,107.35)
  L08_SIG2 w0.147: v1(88.01,107.35) 88.61,107.35 89.53,108.28 89.53,109.62 89,110.15 88.97,110.15 87.04,110.15 87.04,110.15 86.64,110.15 83.18,106.69 83.18,105.85 83.01,105.68 83.01,105.22 83.23,105.01 83.23,104.85 83.01,104.64 83.01,104.48 83.23,104.27 83.23,104.11 83.01,103.9 83.01,103.74 83.23,103.53 83.23,103.38 83.01,103.16 83.01,103.01 83.23,102.8 83.23,102.64 83.01,102.43 83.01,102.27 83.23,102.06 83.23,101.9 83.01,101.69 83.01,101.53 83.23,101.32 83.23,101.17 83.01,100.95 83.01,100.8 83.23,100.59 83.23,100.43 83.01,100.22 83.01,100.06 83.23,99.85 83.23,99.69 83.01,99.48 83.01,99.32 83.23,99.11 83.23,98.96 83.01,98.74 83.01,98.59 83.23,98.38 83.23,98.22 83.01,98.01 83.01,97.85 83.23,97.64 83.23,97.48 83.01,97.27 83.01,97.11 83.23,96.9 83.23,96.75 83.01,96.53 83.01,95.24 83.21,95.05 83.36,95.05 83.81,95.5 83.96,95.5 84.07,95.39 84.07,95.24 83.62,94.79 83.62,94.64 83.73,94.53 83.88,94.53 84.33,94.98 84.48,94.98 84.59,94.87 84.59,94.72 84.14,94.27 84.14,94.12 84.37,93.88 85.35,93.88 85.62,93.62 85.62,90.06 88.11,87.56 89.23,87.56 90.52,86.27 90.52,85.07 90.15,84.7 v1(89.86,84.7)
DDR_UDQS_N: length 44.2
  TOP w0.153: U13.A7 v1(92,110.55) ; U23.M1 v1(89.86,85.5)
  L08_SIG2 w0.107: v1(92,110.55) 91.75,110.55 91.68,110.48 91.68,110.32 91.79,110.21 92.36,110.21 92.58,110.43 92.58,110.7 92.23,111.06 91.48,111.06 91.19,110.76 88.9,110.76 88.36,111.3 86.69,111.3 81.62,106.23 81.62,106.01 81.71,105.92 81.88,105.92 82.1,105.69 82.1,105.38 81.88,105.16 81.71,105.16 81.62,105.06 81.62,104.93 81.71,104.83 81.88,104.83 82.1,104.61 82.1,104.29 81.88,104.07 81.71,104.07 81.62,103.97 81.62,103.84 81.71,103.74 81.88,103.74 82.1,103.52 82.1,103.21 81.88,102.98 81.71,102.98 81.62,102.89 81.62,102.75 81.71,102.66 81.88,102.66 82.1,102.43 82.1,102.12 81.88,101.9 81.71,101.9 81.62,101.8 81.62,101.66 81.71,101.57 81.88,101.57 82.1,101.35 82.1,101.03 81.88,100.81 81.71,100.81 81.62,100.71 81.62,95.48 84.64,92.46 84.64,90 87.83,86.81 88.68,86.81 89.44,86.05 89.44,85.67 89.6,85.5 v1(89.86,85.5)
DDR_UDQS_P: length 44.3
  TOP w0.153: U13.B7 v1(92,109.75) ; U23.N1 v1(89.06,85.5)
  L08_SIG2 w0.107: v1(89.06,85.5) 89.22,85.66 89.22,85.96 88.59,86.59 87.74,86.59 84.42,89.91 84.42,92.37 81.4,95.39 81.4,100.8 81.62,101.02 81.79,101.02 81.88,101.12 81.88,101.26 81.79,101.35 81.62,101.35 81.4,101.57 81.4,101.89 81.62,102.11 81.79,102.11 81.88,102.21 81.88,102.34 81.79,102.44 81.62,102.44 81.4,102.66 81.4,102.98 81.62,103.2 81.79,103.2 81.88,103.29 81.88,103.43 81.79,103.53 81.62,103.53 81.4,103.75 81.4,104.06 81.62,104.29 81.79,104.29 81.88,104.38 81.88,104.52 81.79,104.61 81.62,104.61 81.4,104.84 81.4,105.15 81.62,105.37 81.79,105.37 81.88,105.47 81.88,105.6 81.79,105.7 81.62,105.7 81.4,105.92 81.4,106.32 86.6,111.51 88.45,111.51 88.99,110.97 91.1,110.97 91.39,111.27 92.32,111.27 92.8,110.79 92.8,110.34 92.45,109.99 92.24,109.99 v1(92,109.75)
DDR_VPP: length 27.9
  TOP w0.381: U13.B1 v1(87.21,109.75) ; U13.R9 v1(94.4,98.55)
  L06_PWR2 w0.381: v1(87.21,109.75) 86.8,109.35 86.8,109.3 86.4,108.9 86.4,97.53 87.31,96.62 94.8,96.62 95.18,97.01 95.18,98.12 94.97,98.33 94.63,98.33 v1(94.4,98.55)
  BOTTOM w0.254: v1(94.4,98.55) 95.08,97.88 95.08,97.32 94.68,96.92 C270.2 ; v1(87.21,109.75) 86.6,109.75 C227.2
DDR_VREFCA: length 19.7
  TOP w0.254: C42.2 85.98,100.85 86.09,100.95 87.21,100.95 U13.M1
  TOP w0.381: C42.2 85.09,101.42 85.98,102.31 85.98,106.06 83.06,108.98 83.06,110.25 80.14,113.17 v1(79.12,113.17)
  BOTTOM w0.203: U68.6 78.14,114.53 78.36,114.31
DDR_VTT_EN: length 92.5
  TOP w0.147: U10.5 v1(126.73,116.61) ; U23.L18 v1(91.46,71.1)
  L08_SIG2 w0.091: v1(91.46,71.1) 91.83,70.73 91.83,69.46 93.2,68.09 95.69,68.09 99.78,64 99.78,62.74 102.68,59.83 106.17,59.83 107.31,58.69 109.86,58.69 112.9,61.74 112.9,65.29 115.87,68.26 117.79,68.26 120.74,71.21 120.74,107.53 123.94,110.73 123.94,112.59 123.95,112.6 123.95,112.9 126.73,115.68 v1(126.73,116.61)
DDR_VTT_EN_3V3: length 63.4
  TOP w0.147: U10.8 v1(125.23,116.61)
  TOP w0.203: TP7.1 77.98,112.19 78.34,112.55 R29.1 78.34,113.8 77.95,114.19 v1(77.47,114.19)
  L03_SIG1 w0.091: v1(125.23,116.61) 123.57,114.95 123.57,110.22 121.73,108.38 120.81,108.38 115.58,113.61 78.05,113.61 v1(77.47,114.19)
  BOTTOM w0.203: U68.7 77.74,114.46 v1(77.47,114.19) 77.22,114.19 76.94,114.46 U68.9
DEBOUNCE_GPIO_SOC/MCU: length 35.6
  TOP w0.147: v1(130.36,24.53) 131.49,25.66 131.49,27.27 130.84,27.92 128.12,27.92 127.97,28.08 U50.3 ; SW5.1 122.03,10.59 122.45,11.01 122.45,17.39 122.03,17.81 SW5.2 122.03,19.08 v1(121.97,19.14)
  BOTTOM w0.147: v1(121.97,19.14) 121.92,19.09 D8.2 122.5,18.26 122.54,18.3 122.56,18.3 122.79,18.54 C465.2 R534.1 126.68,18.54 128.07,19.93 130.53,19.93 131.57,20.97 131.57,23.26 131.34,23.49 Q17.2 v1(130.36,24.53)
DEBOUNCE_MCU_RESETZ: length 26.3
  TOP w0.147: SW6.1 129.33,10.59 129.74,11.01 129.74,16.84 129.33,17.26 SW6.2 129.33,19.1 v1(129.31,19.12) 127.13,21.3 127.13,24.27 128.15,25.3 128.15,25.31 128.26,25.41 Q8.2 127.68,27.22 127.54,27.08 U50.1
  BOTTOM w0.147: C466.2 R536.1 130.31,18.39 130.03,18.12 D9.2 129.29,18.64 129.31,18.66 v1(129.31,19.12)
DEBOUNCE_WARM_RST: length 29.7
  TOP w0.147: v1(114.68,19.17) 114.68,17.97 SW4.2 114.74,16.84 115.14,16.44 115.14,10.99 114.74,10.59 SW4.1 ; v1(124.27,22.37) Q10.2 124.27,27.11 123.3,28.08 U50.6
  BOTTOM w0.147: v1(114.68,19.17) 114.68,18.71 114.63,18.66 D11.2 115.12,17.95 115.52,18.35 C467.2 R537.1 120.26,18.35 v1(124.27,22.37)
DIR: length 21.6
  L08_SIG2 w0.091: v1(77.29,52.85) 77.72,53.28 77.72,55.89 73.66,59.96 73.66,65.84 v1(72.52,66.98)
  BOTTOM w0.147: v1(77.29,52.85) 77.18,52.96 U81.2 ; U79.2 69.81,68 70.36,67.45 R356.2 R355.1 72.32,67.18 v1(72.52,66.98)
DISPLAY_VDDB3V3_ON: length 3.3
  BOTTOM w0.147: R538.2 27.73,18.19 27.66,18.12 U99.4
EEPROM_A1: length 3.7
  TOP w0.147: R27.2 R26.2 112.39,118.88 U7.2
EEPROM_A2: length 3.4
  TOP w0.147: R18.2 R17.2 112.26,119.73 112.05,119.53 U7.3
EEPROM_WP: length 2.3
  TOP w0.147: R25.2 103.34,119.06 103.52,118.88 U7.7
EMMC_RSTN: length 11.9
  TOP w0.147: U54.4 117.41,28.08 117.37,28.13 R193.2 v1(117.37,29.59) ; U44.K5 117.37,35.85 117.11,36.11 v1(117.11,36.14)
  BOTTOM w0.147: v1(117.11,36.14) 116.27,36.14 115.57,35.45 115.57,31.38 v1(117.37,29.59)
EXP_BRD_DET_INTN: length 2.1
  BOTTOM w0.147: R226.1 103.55,118.79 103.64,118.88 U66.13
FSI_FET_ENN: length 1.6
  TOP w0.147: U8.17 60.69,118.87 R21.1
FSI_FET_SEL: length 126.6
  TOP w0.147: v1(44.2,112.41) 50.8,112.41 51.18,112.03 55.5,112.03 56.9,113.43 59.18,113.43 v1(59.69,113.93) 58.53,115.09 U8.11 ; U8.21 v1(58.03,121.04)
  L03_SIG1 w0.091: v1(59.69,113.93) 58.34,115.29 58.34,120.74 v1(58.03,121.04) ; v1(44.2,112.41) 44.2,103 42.8,101.6 42.8,97.13 43.41,96.52 43.41,95.42 46.55,92.29 46.55,90.78 47.7,89.63 47.7,86.59 46.56,85.45 46.56,73.49 49.39,70.66 49.39,67.21 46.81,64.63 46.81,62.05 40.92,56.16 40.92,50.37 45.11,46.18 47.24,46.18 50.34,43.08 50.34,36.17 51.33,35.18 51.33,34.77 51.69,34.42 52.04,34.42 52.37,34.09 52.37,32.05 53.47,30.96 v1(53.47,29.73)
  BOTTOM w0.147: U91.8 53.49,29.76 v1(53.47,29.73) ; v1(58.03,121.04) U8.21
FSI_RX0_CLK: length 61.6
  TOP w0.147: U8.8 57.04,114.81 v1(56.54,114.31)
  L08_SIG2 w0.091: J7.1 4.89,122 6.5,122 7.71,120.79 55.12,120.79 55.9,120.01 55.9,114.95 v1(56.54,114.31)
FSI_RX0_D0: length 63.7
  TOP w0.147: U8.10 58.03,114.57 v1(58.67,113.93)
  L08_SIG2 w0.091: v1(58.67,113.93) 57.52,113.93 55.84,112.25 46.19,112.25 43.75,114.7 32.51,114.7 31.88,115.33 29.27,115.33 26.09,112.16 11.51,112.16 8.61,115.05 8.61,115.74 7.25,117.09 4.71,117.09 J7.5
FSI_RX0_D1: length 62.7
  TOP w0.147: v1(59.69,114.95) 59.03,115.6 U8.12
  L08_SIG2 w0.091: v1(59.69,114.95) 59.11,114.37 59.11,113.75 58.85,113.5 57.4,113.5 55.93,112.03 46.1,112.03 43.74,114.39 28.67,114.39 26.18,111.9 9.36,111.9 6.86,114.4 4.87,114.4 J7.7
FSI_TX0_CLK: length 59.2
  TOP w0.147: U8.13 v1(59.83,116.35)
  L08_SIG2 w0.091: v1(59.83,116.35) 56.52,116.35 56.13,116.73 56.13,120.16 55.28,121.01 10.29,121.01 7.98,123.33 J7.2
FSI_TX0_D0: length 72.6
  TOP w0.147: v1(60.83,117.11) 60.57,117.37 U8.14
  L08_SIG2 w0.091: v1(60.83,117.11) 60.2,117.11 59.36,117.94 59.36,119.46 59.05,119.78 57.14,119.78 55.68,121.23 10.84,121.23 7.09,124.98 3.49,124.98 2.18,123.67 2.18,120.35 2.87,119.66 4.69,119.66 J7.6
FSI_TX0_D1: length 75.4
  TOP w0.147: U8.15 v1(60.58,117.87)
  L08_SIG2 w0.091: v1(60.58,117.87) 59.69,118.76 59.69,119.39 59.13,119.96 57.27,119.96 55.77,121.45 12.93,121.45 8.74,125.64 2.84,125.64 1.52,124.32 1.52,118.57 3.25,116.84 4.97,116.84 J7.8
FT4232_DO: length 3.7
  TOP w0.147: R191.1 R192.2 133.62,28.38 133.45,28.2 v1(132.85,28.2)
  BOTTOM w0.147: v1(132.85,28.2) 133.03,28.38 U92.4
FT4232_EECLK: length 10.4
  TOP w0.147: R186.1 135.13,30.24 v1(135.38,29.99)
  BOTTOM w0.147: U87.62 137.97,34.48 136.02,32.53 136.02,30.62 v1(135.38,29.99) 135.38,29.82 135.24,29.68 U92.2
FT4232_EECS: length 8.6
  BOTTOM w0.147: U92.1 134.13,31.52 134.09,31.56 R463.1 135,32.15 137.47,34.61 U87.63
FT4232_EEDATA: length 12
  TOP w0.147: R192.1 v1(135.76,28.97)
  BOTTOM w0.147: U92.3 135.26,29.03 135.31,28.97 v1(135.76,28.97) 136.4,29.61 136.4,32.4 138.47,34.47 U87.61
FT4232_MCU_UART0_CTS_3V3: length 6.2
  TOP w0.147: v1(142.47,49.52) 143.48,49.52 144.02,50.05 v1(144.02,52.47)
  BOTTOM w0.147: v1(144.02,52.47) 143.86,52.63 U82.12 ; U87.28 v1(142.47,49.52)
FT4232_MCU_UART0_RTS_3V3: length 3.8
  BOTTOM w0.147: U87.29 142.97,49.73 142.57,50.13 142.57,52.03
FT4232_MCU_UART0_RX_3V3: length 4.8
  TOP w0.147: v1(143.13,51.2) 142.75,50.81 141.99,50.81 141.47,50.29 v1(141.47,49.52)
  BOTTOM w0.147: v1(143.13,51.2) 142.97,51.36 U82.13 ; U87.26 v1(141.47,49.52)
FT4232_MCU_UART0_TX_3V3: length 3.7
  BOTTOM w0.147: U87.27 141.97,49.78 142.17,49.98 U82.15
FT4232_REF: length 2.8
  TOP w0.147: R175.2 v1(136.38,41.65)
  BOTTOM w0.147: v1(136.38,41.65) 136.16,41.44 U87.6
FT4232_RESET: length 8.4
  BOTTOM w0.254: U87.14 133.9,45.44 133.73,45.61 133.73,46.24 133.48,46.5 C416.2 133.08,47.24 132.93,47.39 130.18,47.39 129.54,46.75 R417.1
FT4232_UART0_CTS_3V3: length 3.9
  TOP w0.147: v1(137.47,49.52) 137.47,50.76 v1(137.03,51.2)
  BOTTOM w0.147: v1(137.03,51.2) 136.87,51.36 U84.12 ; U87.18 v1(137.47,49.52)
FT4232_UART0_RTS_3V3: length 4.5
  BOTTOM w0.147: U87.19 137.97,49.75 137.67,50.05 135.73,50.05 135.58,50.2 U84.14
FT4232_UART0_RX_3V3: length 5.4
  TOP w0.147: v1(135,47.26) 135,49.06 v1(136.53,50.58)
  BOTTOM w0.147: U87.16 135,46.45 v1(135,47.26) ; v1(136.53,50.58) 136.29,50.81 136.04,50.81 U84.13
FT4232_UART0_TX_3V3: length 3.7
  BOTTOM w0.147: U87.17 136.97,49.41 136.7,49.67 135.64,49.67 135.18,50.13 U84.15
FT4232_UART1_RX_3V3: length 6.8
  BOTTOM w0.147: U87.38 147.64,43.94 147.65,43.93 148.51,43.93 148.52,43.94 149.5,43.94 151.5,41.93 151.5,41.72 151.8,41.42 U89.13
FT4232_UART1_TX_3V3: length 7.9
  TOP w0.147: v1(147.56,43.44) 151.78,43.44 v1(152.53,42.69)
  BOTTOM w0.147: v1(152.53,42.69) 152.53,42.26 152.6,42.18 U89.15 ; U87.39 v1(147.56,43.44)
FT4232_UART3_RX_3V3: length 5.9
  BOTTOM w0.147: U89.12 150.21,40.62 148.52,38.94 U87.48
FT4232_UART3_TX_3V3: length 12.9
  TOP w0.147: v1(152.02,42.18) 151.56,42.18 150.17,40.78 147.7,40.78 145.49,38.57 v1(143.38,38.57)
  BOTTOM w0.147: v1(143.38,38.57) 142.97,38.16 U87.52 ; v1(152.02,42.18) 152.2,42 U89.14
FT4232_USB_DM: length 52.6
  TOP w0.107: U42.5 170.95,40.53 171.06,40.42 171.22,40.42 171.39,40.59 171.39,40.85 171.7,41.16 171.89,41.16 v1(172.25,41.52) 172.55,41.21 172.83,41.21 173.05,41.43 J26.2
  L03_SIG1 w0.094: v1(137.43,41.78) 137.22,41.99 136.89,41.99 136.49,42.39 136.49,43.32 136.76,43.59 137.84,43.59 138.64,42.79 138.64,39.42 140.11,37.95 147.57,37.95 149.61,35.91 151.21,35.91 151.76,35.36 154.86,35.36 158.11,38.6 168.51,38.6 171.23,41.32 172.05,41.32 v1(172.25,41.52)
  BOTTOM w0.107: v1(137.43,41.78) 137.11,42.09 136.15,42.09 135.99,41.94 U87.7
FT4232_USB_DP: length 52.5
  TOP w0.107: J26.3 173.04,40.78 172.83,40.99 172.54,40.99 v1(172.25,40.7) 172,40.94 171.79,40.94 171.61,40.76 171.61,40.5 171.31,40.2 171.06,40.2 170.89,40.03 U42.4
  L03_SIG1 w0.094: v1(137.43,42.6) 137.43,42.34 137.32,42.23 137,42.23 136.74,42.49 136.74,43.22 136.86,43.34 137.74,43.34 138.39,42.68 138.39,39.32 140.01,37.7 147.47,37.7 149.51,35.67 151.11,35.67 151.66,35.11 154.97,35.11 158.21,38.35 168.61,38.35 171.33,41.08 172.37,41.08 172.47,40.98 172.47,40.8 172.37,40.7 v1(172.25,40.7)
  BOTTOM w0.107: U87.8 135.99,42.44 136.12,42.31 137.14,42.31 v1(137.43,42.6)
FT4232_USB_VBUS: length 4.5
  TOP w0.254: U43.4 v1(166.38,39.37) ; v1(170.63,41.54) 170.5,41.42 U42.6 ; U43.6 v1(165.09,39.37) ; J26.1 172.5,42.08 172.15,42.43 C154.2
  vias: v1(171.51,45.99) v1(172.02,44.97)
FT_PWREN#: length 6.6
  BOTTOM w0.147: U87.60 138.97,32.64 138.2,31.87 R464.1
GPIO1_43_INTN: length 70.4
  TOP w0.147: U23.C13 v1(97.86,75.1)
  L03_SIG1 w0.091: v1(97.86,75.1) 98.3,75.1 99.09,74.31 101.61,74.31 101.8,74.12 102.78,74.12 103.06,74.4 110.07,74.4 110.63,73.85 110.63,72.05 112.84,69.84 112.84,66.47 114.27,65.04 114.27,57.94 115.87,56.34 120,56.34 v1(120.78,57.11)
  L08_SIG2 w0.091: v1(124.08,28.84) 120.78,32.15 120.78,46.79 121.08,47.09 121.08,49.12 122,50.04 122,55.7 121.04,56.66 121.04,56.85 v1(120.78,57.11)
  BOTTOM w0.147: v1(124.08,28.84) 123.96,28.73 R471.2
GPIO_CPSW1_RST: length 102.8
  L03_SIG1 w0.091: v1(56,28.86) 56,30.03 52.63,33.4 52.63,34.77 50.65,36.75 50.65,43.03 47.27,46.41 45.68,46.41 41.96,50.12 41.96,56.54 46.99,61.57 46.99,61.97 47,61.98 47,64.56 49.57,67.13 49.57,70.82 46.79,73.6 46.79,85.27 48.08,86.56 48.08,90.03 46.77,91.34 46.77,92.38 43.63,95.52 43.63,96.65 43.11,97.17 43.11,101.53 44.83,103.25 v1(44.83,106.57)
  BOTTOM w0.147: U91.3 v1(56,28.86) ; U69.1 47.86,108.34 47.88,108.36 R242.1 R241.1 49.78,107.8 49.63,107.65 47.52,107.65 46.45,106.57 v1(44.83,106.57)
GPIO_EMMC_RSTN: length 70.8
  TOP w0.147: v1(115.46,21.24) R196.1 115.46,22.7 115.51,22.75 U54.1
  L08_SIG2 w0.091: v1(57,28.86) 58.4,28.86 65.98,21.28 78.87,21.28 81.75,18.4 91.64,18.4 94.05,20.8 99.34,20.8 102.08,18.06 111.64,18.06 113.28,19.7 113.92,19.7 v1(115.46,21.24)
  BOTTOM w0.147: U91.1 v1(57,28.86)
GPIO_OLED_RESETN: length 62.2
  L08_SIG2 w0.091: v1(8.64,19.7) 10.27,21.34 48.64,21.34 51.31,24 51.31,28 51.5,28.19 51.5,31.59 51.39,31.7 51.39,32.12 51.5,32.23 51.5,32.59 51.39,32.7 51.39,33.12 51.5,33.23 51.5,33.59 51.39,33.7 51.39,33.97 v1(50.95,34.41)
  BOTTOM w0.147: U91.15 v1(50.95,34.41) ; J36.6 5.7,18.31 5.96,18.06 5.96,18.05 6.04,17.97 6.04,17.95 6.31,17.69 7.66,17.69 7.93,17.95 7.93,17.98 8.04,18.08 8.04,18.33 8.04,18.34 8.04,18.34 R531.2 v1(8.64,19.7)
GPIO_OSPI_RSTN: length 43.5
  TOP w0.147: U23.K17 v1(92.26,71.9)
  L08_SIG2 w0.091: v1(92.26,71.9) 91.89,72.28 91.3,72.28 91.09,72.06 91.09,69.82 93.2,67.71 95.2,67.71 99.48,63.43 99.48,51.66 107.64,43.5 107.64,42.13 v1(107.99,41.79)
  BOTTOM w0.147: U85.1 R429.1 108.26,42.05 v1(107.99,41.79)
GPIO_PCIE_RST_OUT: length 30.3
  L03_SIG1 w0.091: v1(54.47,29.73) 54.47,28.7 54.1,28.34 52.5,28.34 49.7,31.13 49.7,32.22 43.19,38.73 41.03,38.73 39.02,40.74 36.55,40.74 v1(36.14,41.15)
  BOTTOM w0.147: U88.1 36.6,42.82 36.23,43.19 R424.2 R430.1 36.14,41.45 v1(36.14,41.15) ; v1(54.47,29.73) 54.49,29.76 U91.6
GPIO_RGMII1_RST: length 91.7
  TOP w0.147: U19.1 v1(25.4,90.06)
  L03_SIG1 w0.091: v1(25.4,90.06) 24.97,89.63 24.97,88.72 29.12,84.57 29.12,64.42 27.76,63.05 27.76,58.36 27.51,58.11 27.51,45.16 28.65,44.02 29.84,44.02 30.54,43.32 30.54,42.91 35.23,38.23 38.34,38.23 39.24,37.32 43.7,37.32 47.62,33.39 47.62,32.17 47.46,32 47.46,31.65 47.71,31.4 48.52,31.4 52.37,27.55 v1(56.01,27.55)
  BOTTOM w0.147: v1(25.4,90.06) 25.44,90.1 R300.1 26.5,89.51 26.48,89.48 R301.1 ; v1(56.01,27.55) 55.5,28.06 U91.4
GPIO_RGMII2_RST: length 50.4
  TOP w0.147: U31.1 30.61,58.56 v1(30.97,58.2)
  L03_SIG1 w0.091: v1(30.97,58.2) 30.97,50.75 30.98,50.74 30.98,50.38 30.86,50.26 30.86,44.37 33.91,41.33 35,41.33 35.81,40.51 37.07,40.51 39.08,38.51 43.1,38.51 49.48,32.12 49.48,31.04 52.44,28.08 54.21,28.08 v1(54.99,28.86)
  BOTTOM w0.147: U91.5 v1(54.99,28.86) ; R371.1 R380.1 v1(30.97,58.2)
GPIO_SOC/MCU: length 3.4
  TOP w0.147: v1(121.41,28.84) 121.68,28.58 U50.5
  BOTTOM w0.147: v1(121.41,28.84) 121.53,28.73 R471.1 122.41,29.34 122.4,29.35 R470.1
GPMC0_AD0: length 60.3
  TOP w0.147: v1(67.82,80.15) 67.8,80.15 67.79,80.14 RA1.9 ; J2.E14 v1(58.04,132.35)
  L03_SIG1 w0.091: v1(58.04,132.35) 58.65,131.73 58.65,125.95 65.22,119.38 65.22,112.31 65.35,112.19 66.13,111.4 66.13,107.07 67.56,105.64 67.56,99.2 70.68,96.08 70.68,91.27 67.82,88.41 v1(67.82,80.15)
GPMC0_AD1: length 59.1
  TOP w0.147: RA1.10 v1(67.2,80) ; J2.D14 v1(58.04,131.08)
  L03_SIG1 w0.091: v1(58.04,131.08) 58.47,130.65 58.47,125.87 65,119.35 65,112.22 65.26,111.96 65.91,111.31 65.91,106.98 67.34,105.55 67.34,99.11 70.46,95.99 70.46,91.36 67.2,88.1 v1(67.2,80)
GPMC0_AD2: length 57.9
  TOP w0.147: J2.C14 v1(58.04,129.81) ; v1(66.67,80.79) 66.67,80.16 66.7,80.14 RA1.11
  L03_SIG1 w0.091: v1(58.04,129.81) 58.04,126 64.78,119.26 64.78,107.8 67.12,105.46 67.12,99.01 70.23,95.9 70.23,91.45 66.67,87.89 v1(66.67,80.79)
GPMC0_AD3: length 59.2
  TOP w0.147: RA1.12 v1(66.2,80) ; J2.E15 v1(56.77,132.35)
  L03_SIG1 w0.091: v1(66.2,80) 66.2,80.6 66.21,80.61 66.21,80.97 66.2,80.97 66.2,87.73 67.94,89.47 67.94,97.28 66.9,98.33 66.9,105.37 64.56,107.71 64.56,119.13 57.38,126.3 57.38,131.74 v1(56.77,132.35)
GPMC0_AD4: length 58
  TOP w0.147: J2.D15 v1(56.77,131.08) ; RA1.13 65.7,80.14 65.77,80.21 v1(65.77,80.79)
  L03_SIG1 w0.091: v1(56.77,131.08) 57.2,130.65 57.2,126.18 64.33,119.04 64.33,107.62 65.61,106.34 65.61,99.3 67.72,97.19 67.72,89.56 65.77,87.61 v1(65.77,80.79)
GPMC0_AD5: length 56.7
  TOP w0.147: RA1.14 v1(65.2,80) ; J2.C15 v1(56.77,129.81)
  L03_SIG1 w0.091: v1(56.77,129.81) 56.77,126.3 64.11,118.96 64.11,107.53 65.39,106.25 65.39,99.21 67.46,97.13 67.46,89.62 65.21,87.36 65.21,80.61 65.2,80.6 v1(65.2,80)
GPMC0_AD6: length 62.7
  TOP w0.147: RA1.15 64.7,80.14 64.77,80.21 v1(64.77,80.79) ; J2.E17 v1(54.23,132.35)
  L03_SIG1 w0.091: v1(54.23,132.35) 54.66,131.92 54.66,124.05 55.99,122.71 60.07,122.71 63.93,118.85 63.93,107.45 63.98,107.4 63.98,107.35 65.17,106.16 65.17,99.12 67.24,97.04 67.24,89.71 64.77,87.23 v1(64.77,80.79)
GPMC0_AD7: length 61.8
  TOP w0.147: J2.D17 v1(54.23,131.08) ; RA1.16 v1(64.11,80)
  L03_SIG1 w0.091: v1(54.23,131.08) 53.67,130.52 53.67,123.92 55.06,122.53 58.88,122.53 63.67,117.73 63.67,107.34 64.95,106.07 64.95,99.02 67.02,96.95 67.02,89.8 64.11,86.89 v1(64.11,80)
GPMC0_AD8: length 14
  TOP w0.147: U8.23 57.04,120.81 56.57,121.27 50.57,121.27 47.24,124.6 J2.A22
GPMC0_AD8/FSI_RX0_CLK: length 76.3
  TOP w0.147: v1(75.17,64.53) 75.15,64.52 RA3.9 ; U8.1 v1(54.99,119.37)
  L03_SIG1 w0.091: v1(75.17,64.53) 75.17,64.08 73.87,62.78 70.71,62.78 69.18,64.31 69.18,65.74 69.41,65.97 69.41,68.02 67.13,70.3 67.13,70.94 66.48,71.59 61.19,71.59 54.98,77.8 54.98,95.7 55.72,96.44 55.72,99.93 55.21,100.44 55.21,112.34 52.83,114.72 52.83,118.17 54.04,119.37 v1(54.99,119.37)
GPMC0_AD9: length 13.3
  TOP w0.147: J2.A21 48.51,124.82 51.77,121.57 57.11,121.57 57.54,121.14 U8.22
GPMC0_AD9/FSI_RX0_D0: length 79
  TOP w0.147: RA3.10 74.57,64.29 74.62,64.34 74.62,65 v1(75.17,65.55) ; U8.3 v1(55,118.37)
  L03_SIG1 w0.091: v1(75.17,65.55) 74.6,64.98 74.6,63.95 73.65,63 70.8,63 69.4,64.4 69.4,65.65 69.63,65.87 69.63,68.69 68.14,70.17 68.14,71.44 67.78,71.81 61.32,71.81 56.74,76.38 56.74,86.91 57.79,87.95 57.79,91.45 57.02,92.22 57.02,97.04 57.66,97.68 57.66,100.81 56.55,101.92 56.55,107.16 55.63,108.09 55.63,112.23 53.05,114.81 53.05,118.07 53.79,118.82 54.55,118.82 v1(55,118.37)
GPMC0_AD10: length 15.2
  TOP w0.147: U8.20 58.53,121.24 57.91,121.86 52.22,121.86 49.12,124.96 49.12,127.29 J2.B21
GPMC0_AD10/FSI_RX0_D1: length 74.3
  TOP w0.147: v1(74.17,64.53) 74.07,64.43 RA3.11 ; U8.4 54.48,117.87 v1(53.98,118.38)
  L03_SIG1 w0.091: v1(53.98,118.38) 53.98,116.53 53.7,116.26 53.7,114.47 56.77,111.4 56.77,102.01 58.01,100.77 58.01,87.86 56.96,86.81 56.96,76.47 61.41,72.03 68.48,72.03 69.09,71.42 69.09,70.37 69.85,69.61 69.85,65.78 69.62,65.56 69.62,64.76 71.16,63.22 73.3,63.22 74.17,64.09 v1(74.17,64.53)
GPMC0_AD11: length 94.5
  TOP w0.147: J2.E21 v1(49.15,132.35) ; RA3.12 73.57,64.3 73.61,64.34 73.61,64.99 v1(74.17,65.55)
  L03_SIG1 w0.091: v1(49.15,132.35) 48.34,131.54 48.34,124.68 52.31,120.7 52.31,114.92 54.99,112.24 54.99,100.53 54.99,100.35 55.5,99.84 55.5,96.53 54.76,95.8 54.76,77.71 61.1,71.37 65.51,71.37 65.97,70.91 65.97,70.44 68.33,68.09 68.33,66.44 68.96,65.8 68.96,64.13 70.08,63.01 70.08,62.99 70.51,62.56 73.97,62.56 75.6,64.19 75.6,65.73 75.35,65.98 74.6,65.98 v1(74.17,65.55)
GPMC0_AD12: length 88.4
  TOP w0.147: RA3.13 73.07,64.44 v1(73.15,64.53) ; J2.C21 v1(49.15,129.81)
  L03_SIG1 w0.091: v1(49.15,129.81) 49.15,124.47 52.17,121.46 54.15,121.46 56.01,119.6 56.01,117.74 54.81,116.55 54.81,113.99 57.22,111.58 57.22,102.19 58.71,100.7 58.71,99.24 60.96,96.98 60.96,96.8 60.96,90.18 57.41,86.63 57.41,76.81 61.72,72.49 68.66,72.49 70.31,70.83 70.31,66.69 70.96,66.04 70.96,64.36 71.66,63.66 72.72,63.66 73.15,64.09 v1(73.15,64.53)
GPMC0_AD13: length 94.2
  TOP w0.147: J2.D21 v1(49.15,131.08) ; v1(73.15,65.55) 72.58,64.97 72.58,64.3 72.57,64.29 RA3.14
  L03_SIG1 w0.091: v1(49.15,131.08) 48.52,130.45 48.52,124.83 52.07,121.27 54.08,121.27 55.5,119.85 55.5,117.74 53.92,116.16 53.92,114.57 57,111.49 57,102.1 58.49,100.61 58.49,99.15 60.74,96.89 60.74,90.28 57.19,86.72 57.19,76.56 61.5,72.25 68.59,72.25 70.07,70.77 70.07,66.56 70.69,65.94 70.69,64.07 71.32,63.44 73.2,63.44 73.59,63.83 73.59,65.11 v1(73.15,65.55)
GPMC0_AD14: length 15.8
  TOP w0.147: J2.B20 50.47,127.22 50.47,125.12 53.14,122.45 58.44,122.45 59.83,121.05 U8.18
GPMC0_AD14/FSI_TX0_D0: length 67.7
  TOP w0.147: v1(55.24,115.97) 55.74,116.46 U8.6 ; RA3.15 72.07,64.33 72.12,64.39 v1(72.12,64.41)
  L03_SIG1 w0.091: v1(55.24,115.97) 56.52,115.97 56.97,115.51 56.97,114.13 56.97,114.13 56.97,112.48 57.66,111.79 57.66,102.38 60.02,100.02 60.02,98.75 61.4,97.36 61.4,97.17 61.4,90 57.85,86.45 57.85,78.06 58.58,77.33 62.48,73.42 68.34,73.42 70.69,71.07 70.69,67.37 72.43,65.63 72.43,64.72 v1(72.12,64.41)
GPMC0_AD15: length 19.1
  TOP w0.147: U8.16 61.89,118.37 62.47,118.95 62.47,120.4 60.12,122.75 53.57,122.75 51.05,125.26 J2.A19
GPMC0_AD15/FSI_TX0_D1: length 65.4
  TOP w0.147: RA3.16 71.48,64.29 71.63,64.44 v1(71.63,65.04) ; U8.7 v1(56.54,115.33)
  L03_SIG1 w0.091: v1(71.63,65.04) 71.19,65.48 71.19,66.17 70.51,66.85 70.51,70.97 68.28,73.2 62.39,73.2 57.63,77.97 57.63,86.54 61.18,90.09 61.18,96.71 61.18,96.71 61.18,97.08 61.18,97.27 59.79,98.66 59.79,99.93 57.44,102.29 57.44,111.7 56.1,113.04 56.1,114.89 v1(56.54,115.33)
GPMC0_ADVN_ALE: length 56.8
  TOP w0.147: U23.P16 v1(88.26,72.7)
  L08_SIG2 w0.091: v1(88.26,72.7) 87.86,72.31 87.86,69.37 87.73,69.24 87.55,69.24 87.46,69.15 87.46,68.95 87.55,68.86 88.38,68.86 88.47,68.76 88.47,68.6 88.38,68.51 87.04,68.51 86.95,68.42 86.95,68.26 87.04,68.17 88.38,68.17 88.47,68.07 88.47,67.91 88.38,67.82 87.92,67.82 87.83,67.73 87.83,66.92 87.73,66.83 87.57,66.83 87.48,66.92 87.48,67.73 87.39,67.82 87.04,67.82 86.95,67.73 86.95,67.2 86.86,67.11 85.6,67.11 85.51,67.02 85.51,66.86 85.6,66.76 86.86,66.76 86.95,66.67 86.95,66.51 86.86,66.42 85.6,66.42 85.51,66.33 85.51,66.16 85.6,66.07 86.86,66.07 86.95,65.98 86.95,65.76 87.04,65.67 87.27,65.67 87.35,65.75 87.35,66.21 87.43,66.29 87.54,66.29 87.62,66.21 87.62,65.75 87.7,65.67 88.24,65.67 88.33,65.58 88.33,65.34 88.24,65.25 86.94,65.25 86.85,65.16 86.85,65 86.94,64.91 88.24,64.91 88.36,64.78 88.36,64.29 87.8,63.73 87.8,63.22 87.59,63.02 85.22,63.02 85.13,62.92 85.13,62.76 85.22,62.67 87.59,62.67 87.69,62.58 87.69,62.42 87.59,62.33 85.22,62.33 85.13,62.23 85.13,62.07 85.22,61.98 87.59,61.98 87.69,61.89 87.69,61.73 87.59,61.63 85.22,61.63 85.13,61.54 85.13,61.38 85.22,61.29 87.59,61.29 87.69,61.2 87.69,61.1 87.54,60.95 86.12,60.95 85.48,60.31 84.68,60.31 84.22,59.85 84.22,58.64 83.83,58.25 82.65,58.25 82.23,58.66 82.23,59.45 82.49,59.7 v1(83.31,59.7)
  BOTTOM w0.147: RA5.7 83.31,61.47 v1(83.31,59.7) 83.31,59.18 RA6.2
GPMC0_BE0N_CLE: length 56.9
  TOP w0.147: U23.P17 v1(88.26,71.9)
  L08_SIG2 w0.091: v1(84.86,59.88) 84.78,59.88 84.49,59.59 84.49,58.13 84.58,58.04 84.89,58.04 84.98,58.13 84.98,58.99 85.07,59.09 85.24,59.09 85.33,58.99 85.33,58.13 85.42,58.04 86.12,58.04 86.21,58.13 86.21,58.52 86.01,58.72 85.89,58.72 85.79,58.62 85.66,58.62 85.55,58.74 85.55,58.87 85.64,58.96 85.64,59.09 85.42,59.31 85.42,59.86 85.43,59.87 85.43,59.89 86.17,60.64 87.51,60.64 87.64,60.52 87.64,60.37 87.55,60.28 87.29,60.28 87.2,60.19 87.2,60.03 87.29,59.93 87.55,59.93 87.78,59.7 88.61,59.7 88.7,59.79 88.7,60.96 88.61,61.05 88.07,61.05 87.98,61.14 87.98,61.29 88.07,61.38 88.46,61.38 88.56,61.49 88.56,61.86 88.66,61.95 88.77,61.95 88.86,61.86 88.86,61.43 88.96,61.34 89.12,61.34 89.21,61.43 89.21,61.86 89.3,61.95 89.46,61.95 89.55,61.86 89.55,61.43 89.65,61.34 89.81,61.34 89.9,61.43 89.9,61.86 89.99,61.95 90.42,61.95 90.51,62.04 90.51,62.2 90.42,62.29 88.27,62.29 88.18,62.39 88.18,62.55 88.27,62.64 90.67,62.64 90.76,62.73 90.76,62.89 90.67,62.98 88.27,62.98 88.18,63.08 88.18,63.24 88.27,63.33 91.18,63.33 91.29,63.44 91.29,63.57 91.18,63.68 90.16,63.68 90.07,63.77 90.07,65.23 89.97,65.32 89.81,65.32 89.72,65.23 89.72,63.77 89.63,63.68 88.66,63.68 88.56,63.77 88.56,65.11 88.66,65.2 89.35,65.2 89.44,65.29 89.44,65.46 89.35,65.55 88.66,65.55 88.56,65.64 88.56,66.47 88.73,66.63 88.73,67.14 88.82,67.23 89.42,67.23 89.51,67.32 89.51,67.45 89.39,67.57 88.82,67.57 88.73,67.66 88.73,67.88 88.82,67.97 89.32,67.97 89.41,68.07 89.41,68.23 89.32,68.32 88.76,68.32 88.67,68.41 88.67,68.56 88.76,68.65 89.59,68.65 89.68,68.74 89.68,68.9 89.59,68.99 88.78,68.99 88.67,69.1 88.67,69.25 88.76,69.34 89.59,69.34 89.68,69.43 89.68,69.59 89.59,69.68 88.78,69.68 88.67,69.79 88.67,71.49 v1(88.26,71.9)
  BOTTOM w0.147: RA5.4 84.83,60.96 84.83,60.96 84.83,60.37 84.86,60.34 v1(84.86,59.88) 84.83,59.85 84.83,59.16 RA6.5
GPMC0_BE1N: length 56.9
  TOP w0.147: U23.T19 v1(86.66,70.3)
  L08_SIG2 w0.091: v1(85.34,60.85) 85.04,60.54 84.61,60.54 84.07,60.01 83.64,60.01 83.36,60.29 83.36,60.92 83.27,61.02 82.63,61.02 82.38,60.77 82.38,60.52 81.76,59.9 81.76,58.62 82.74,57.64 89.29,57.64 90.36,58.71 90.36,59.58 90.72,59.94 91.48,59.94 91.57,59.85 91.57,59.69 91.66,59.6 91.82,59.6 91.91,59.69 91.91,59.85 92,59.94 93.35,59.94 93.66,59.63 93.66,56.34 93.18,55.87 89.78,55.87 88.63,54.71 84.52,54.71 80.43,58.8 80.43,63.23 86.66,69.46 v1(86.66,70.3)
  BOTTOM w0.147: RA5.3 85.34,61.48 v1(85.34,60.85) 85.34,59.17 RA6.6
GPMC0_CLK: length 56.8
  TOP w0.147: U23.R17 v1(87.46,71.9)
  L08_SIG2 w0.091: v1(87.46,71.9) 87.46,71.63 87.03,71.2 87.03,70.96 86.99,70.92 86.99,70.86 86.81,70.68 86.5,70.68 86.23,70.4 86.23,70.15 86.05,69.97 86.05,69.17 80.25,63.36 80.25,58.72 84.44,54.53 88.71,54.53 89.87,55.69 93.62,55.69 94.28,56.35 94.28,60.02 93.15,61.15 93.02,61.15 91.99,60.12 90.64,60.12 90.18,59.66 90.18,58.8 89.22,57.84 82.79,57.84 81.94,58.7 81.94,59.73 v1(82.8,60.59)
  BOTTOM w0.147: RA5.8 82.78,61.46 82.78,60.62 v1(82.8,60.59) 82.8,60.14 82.75,60.08 RA6.1
GPMC0_CSN0: length 54.5
  TOP w0.147: U23.R19 v1(87.46,70.3)
  L08_SIG2 w0.091: v1(92.08,58.55) 91.44,59.18 91.06,59.18 90.81,58.93 90.81,57.83 88.73,55.75 87.79,55.75 87.41,56.13 87.41,56.94 87.33,57.02 87.22,57.02 87.14,56.94 87.14,56.04 87.06,55.96 85.65,55.96 85.45,55.75 83.99,55.75 83.9,55.84 83.9,55.96 84.21,56.26 84.21,56.38 84.13,56.46 84.02,56.46 83.71,56.15 83.59,56.15 83.51,56.23 83.51,56.34 83.82,56.65 83.82,56.77 83.74,56.85 83.63,56.85 83.32,56.54 83.21,56.54 83.13,56.62 83.13,56.73 83.43,57.04 83.43,57.15 83.35,57.23 83.24,57.23 82.93,56.93 82.82,56.93 81.39,58.35 81.39,60.8 81.47,60.88 81.47,61.23 80.8,61.9 80.8,63.02 80.94,63.16 81.05,63.16 81.95,62.26 82.07,62.26 82.15,62.34 82.15,62.45 81.24,63.36 81.24,63.47 81.32,63.55 81.44,63.55 82.34,62.64 82.46,62.64 82.54,62.72 82.54,62.84 81.63,63.74 81.63,63.86 81.71,63.94 81.82,63.94 82.73,63.03 82.84,63.03 82.92,63.11 82.92,63.23 82.02,64.13 82.02,64.25 83.07,65.3 83.18,65.3 83.77,64.71 83.89,64.71 83.97,64.79 83.97,64.9 83.38,65.49 83.38,65.61 83.46,65.69 83.57,65.69 84.16,65.1 84.27,65.1 84.36,65.18 84.36,65.29 83.77,65.88 83.77,65.99 83.85,66.07 83.96,66.07 84.55,65.49 84.66,65.49 84.74,65.57 84.74,65.68 84.17,66.25 84.17,66.37 84.39,66.59 84.51,66.59 85.02,66.08 85.13,66.08 85.21,66.16 85.21,66.28 84.7,66.79 84.7,66.9 85.61,67.81 85.72,67.81 86.17,67.36 86.29,67.36 86.37,67.44 86.37,67.56 85.92,68.01 85.92,68.12 86,68.2 86.11,68.2 86.56,67.75 86.67,67.75 86.75,67.83 86.75,67.95 86.31,68.39 86.31,68.51 87.46,69.66 v1(87.46,70.3)
  BOTTOM w0.147: R391.1 R390.1 91.94,58.41 v1(92.08,58.55)
GPMC0_CSN1: length 103.4
  TOP w0.147: v1(86.42,65.19) 86.42,65.99 88.26,67.83 88.26,69.5 U23.R20 ; J2.E19 v1(51.69,132.35)
  L03_SIG1 w0.091: v1(51.69,132.35) 52.15,131.89 52.15,124.2 54.46,121.89 58.7,121.89 63.01,117.58 63.01,107.07 64.28,105.79 64.28,88 61.54,85.25 61.54,76.16 63.2,74.5 71.27,74.5 72.85,72.92 72.85,69.44 74.09,68.2 75.19,68.2 76.48,66.91 85.36,66.91 86.42,65.85 v1(86.42,65.19)
GPMC0_CSN2: length 98.4
  TOP w0.147: U23.P19 v1(88.26,70.3) ; J2.D18 v1(52.96,131.08)
  L03_SIG1 w0.091: v1(52.96,131.08) 52.33,130.45 52.33,124.28 54.44,122.16 58.72,122.16 63.23,117.66 63.23,107.16 64.51,105.89 64.51,87.91 62.59,85.99 62.59,75.56 63.43,74.72 72.34,74.72 73.74,73.33 73.74,71.71 73.9,71.54 73.9,69.56 75.08,68.38 75.27,68.38 76.52,67.13 85.53,67.13 88.26,69.87 v1(88.26,70.3)
GPMC0_CSN3: length 101.5
  TOP w0.147: v1(85.33,65.42) 87.86,67.95 U23.R21 ; J2.D19 v1(51.69,131.08)
  L03_SIG1 w0.091: v1(85.33,65.42) 84.06,66.69 76.44,66.69 75.12,68.01 73.26,68.01 72.62,68.65 72.62,72.46 70.8,74.28 63.11,74.28 61.32,76.07 61.32,85.35 64.06,88.09 64.06,105.7 61.98,107.79 61.98,118.35 58.62,121.71 53.11,121.71 50.85,123.97 50.85,130.24 v1(51.69,131.08)
GPMC0_DIR: length 100.5
  TOP w0.147: J2.E18 v1(52.96,132.35) ; U23.N17 v1(89.06,71.9)
  L03_SIG1 w0.091: v1(89.06,71.9) 88.66,71.5 88.09,71.5 87.86,71.27 87.86,70.14 85.07,67.36 76.55,67.36 75.34,68.56 75.26,68.56 74.08,69.74 74.08,71.62 73.94,71.76 73.94,73.51 72.5,74.94 63.52,74.94 62.81,75.65 62.81,85.9 64.73,87.82 64.73,105.98 63.45,107.25 63.45,117.7 58.8,122.35 54.91,122.35 53.42,123.84 53.42,131.89 v1(52.96,132.35)
GPMC0_OEN_REN: length 56.9
  TOP w0.147: U23.R18 v1(87.46,71.1)
  L08_SIG2 w0.091: v1(87.46,71.1) 87.2,70.84 87.2,70.75 87.09,70.64 87.09,69.57 80.61,63.1 80.61,58.87 84.56,54.92 86.67,54.92 86.76,55.02 86.76,55.49 86.85,55.58 87.01,55.58 87.11,55.49 87.11,55.02 87.2,54.92 87.36,54.92 87.45,55.02 87.45,55.49 87.54,55.58 87.7,55.58 87.8,55.49 87.8,55.02 87.89,54.92 88.58,54.92 91.13,57.47 92.65,57.47 92.74,57.56 92.74,59.18 92.51,59.42 91.04,59.42 90.54,58.92 90.54,58.28 89.69,57.43 82.69,57.43 81.57,58.54 81.57,60.36 82.23,61.02 82.23,62.04 82.68,62.48 83.36,62.48 83.82,62.03 v1(83.82,60.47)
  BOTTOM w0.147: RA6.3 83.82,59.17 v1(83.82,60.47) 83.82,61.48 RA5.6
GPMC0_WAIT0: length 56.9
  TOP w0.147: U23.W19 v1(84.26,70.3)
  L08_SIG2 w0.091: v1(85.85,59.72) 85.85,59.14 86.34,58.64 89.61,58.64 89.95,58.99 89.95,60.66 90.36,61.07 92.35,61.07 92.99,61.71 94.03,61.71 94.97,60.77 94.97,59.98 95.22,59.73 96.02,59.73 97.07,58.67 97.07,57.54 93.88,54.35 92.62,54.35 92.53,54.44 92.53,54.58 92.44,54.68 92.28,54.68 92.19,54.58 92.19,54.44 92.1,54.35 91.93,54.35 91.84,54.44 91.84,54.58 91.75,54.68 91.59,54.68 91.5,54.58 91.5,54.44 91.4,54.35 91.24,54.35 91.15,54.44 91.15,54.58 91.06,54.68 90.9,54.68 90.8,54.58 90.8,54.44 90.71,54.35 84.36,54.35 80.04,58.67 80.04,64.62 81.2,65.78 82.29,65.78 85.47,68.96 85.47,69.72 85.26,69.93 84.63,69.93 v1(84.26,70.3)
  BOTTOM w0.147: RA6.7 85.85,59.18 v1(85.85,59.72) 85.85,61.47 RA5.2
GPMC0_WAIT1: length 56.7
  TOP w0.147: U23.Y18 v1(83.46,71.1)
  L08_SIG2 w0.091: v1(83.46,71.1) 83.89,70.68 83.89,70.15 84.31,69.73 84.7,69.73 84.96,69.47 84.96,68.96 81.99,65.98 81.14,65.98 79.86,64.69 79.86,58.59 84.29,54.16 93.96,54.16 97.52,57.72 97.52,58.68 94.31,61.89 92.92,61.89 92.31,61.29 90.31,61.29 89.77,60.75 89.77,59.07 89.53,58.83 86.78,58.83 86.49,59.12 v1(86.49,60.21)
  BOTTOM w0.147: RA6.8 86.42,59.64 86.49,59.7 v1(86.49,60.21) 86.49,60.9 86.42,60.96 RA5.1
GPMC0_WEN: length 56.6
  TOP w0.147: U23.T21 87.06,68.02 83.92,64.89 80.14,64.89 79.27,64.03 79.27,59.82 78.59,59.14 78.59,53.52 79.68,52.42 83.41,52.42 84.33,53.34 84.33,54.08 84.21,54.2 82.74,54.2 82.62,54.32 82.62,54.48 82.74,54.6 84.21,54.6 84.33,54.72 84.33,54.88 84.21,55 82.74,55 82.62,55.12 82.62,55.28 82.74,55.4 84.21,55.4 84.33,55.52 84.33,55.69 84.21,55.8 82.74,55.8 82.62,55.92 82.62,56.09 82.74,56.2 84.21,56.2 84.33,56.32 84.33,56.49 84.21,56.61 82.74,56.61 82.62,56.72 82.62,56.89 82.74,57.01 84.21,57.01 84.33,57.12 84.33,57.29 84.21,57.41 82.74,57.41 82.62,57.53 82.62,57.69 82.74,57.81 84.21,57.81 84.33,57.93 84.33,58.09 84.21,58.21 82.74,58.21 82.62,58.33 82.62,58.49 82.74,58.61 84.18,58.61 84.33,58.76 v1(84.33,60.9)
  BOTTOM w0.147: RA6.4 84.33,60.39 84.33,60.39 v1(84.33,60.9) 84.33,60.9 84.33,61.49 RA5.5
GPMC0_WPN: length 54.4
  TOP w0.147: U23.N16 v1(89.06,72.7)
  L08_SIG2 w0.091: v1(89.06,72.7) 89.46,72.31 89.46,70.15 89.47,70.15 90.69,68.93 90.69,68.82 89.67,67.8 89.67,67.69 89.75,67.61 89.86,67.61 90.88,68.63 90.99,68.63 91.22,68.4 91.22,68.28 90.84,67.9 90.84,67.78 90.92,67.7 91.03,67.7 91.42,68.09 91.53,68.09 91.61,68.01 91.61,67.89 91.23,67.51 91.23,67.4 91.31,67.32 91.42,67.32 91.81,67.7 91.92,67.7 92.07,67.55 92.07,67.44 91.05,66.42 91.05,66.3 91.13,66.22 91.24,66.22 92.26,67.24 92.38,67.24 93.05,66.57 93.05,66.13 93.3,65.88 93.65,65.88 94.06,66.29 94.62,66.29 95.12,65.79 95.12,64.96 95.03,64.87 94.9,64.87 94.82,64.95 94.82,65.58 94.74,65.66 94.63,65.66 94.55,65.58 94.55,64.95 94.47,64.87 94.35,64.87 94.27,64.95 94.27,65.58 94.19,65.66 94.08,65.66 94,65.58 94,64.95 93.92,64.87 93.07,64.87 92.99,64.95 92.99,65.71 92.91,65.79 92.8,65.79 92.72,65.71 92.72,64.95 92.64,64.87 92.33,64.87 92.27,64.8 92.27,64.67 92.36,64.58 94.94,64.58 95.12,64.39 95.12,62.72 95.03,62.63 94.47,62.63 94.39,62.71 94.39,64.18 94.31,64.26 94.2,64.26 94.12,64.18 94.12,62.71 94.04,62.63 93.84,62.63 93.76,62.71 93.76,63.67 93.68,63.75 93.56,63.75 93.48,63.67 93.48,62.71 93.4,62.63 93.14,62.63 93.06,62.71 93.06,63.8 92.98,63.88 92.86,63.88 92.78,63.8 92.78,62.71 92.7,62.63 92.59,62.63 92.51,62.71 92.51,63.8 92.43,63.88 92.31,63.88 92.23,63.8 92.23,62.71 92.15,62.63 91.4,62.63 89.79,61.02 89.16,61.02 88.91,60.77 88.91,59.35 88.81,59.25 v1(88.11,59.25)
  BOTTOM w0.147: v1(88.11,59.25) R393.1 R392.1
HSE_DETECT: length 55.8
  TOP w0.147: J2.E4 v1(70.74,132.35)
  L03_SIG1 w0.091: v1(115.13,118.81) 94,118.81 88.64,124.16 85.67,124.16 83.22,126.61 79.74,126.61 77.06,129.28 77.06,129.94 75.48,131.52 71.57,131.52 v1(70.74,132.35)
  BOTTOM w0.147: U66.4 112.08,118.88 112.26,118.7 R224.1 115.02,118.7 v1(115.13,118.81)
HSE_GPIO0_31: length 93.8
  TOP w0.147: J2.B22 v1(47.88,128.54)
  L03_SIG1 w0.091: v1(47.88,128.54) 47.88,124.87 52.08,120.67 52.08,114.84 54.54,112.38 54.54,76.37 65.07,65.84 65.43,65.84 67.68,63.59 67.68,63.11 69.34,61.45 79.38,61.45 81.15,63.22 82.11,63.22 v1(83.27,64.38)
  BOTTOM w0.147: RA5.9 82.74,63.86 v1(83.27,64.38)
HSE_GPIO0_32: length 94.5
  TOP w0.147: J2.C22 v1(47.88,129.81)
  L03_SIG1 w0.091: v1(47.88,129.81) 47.4,129.33 47.4,125.09 51.87,120.62 51.87,114.74 54.32,112.29 54.32,76.7 54.36,76.66 54.36,76.3 65,65.65 65.36,65.65 67.5,63.51 67.5,62.94 69.21,61.23 79.47,61.23 81.24,63 82.82,63 v1(83.33,63.51)
  BOTTOM w0.147: RA5.10 v1(83.33,63.51)
HSE_GPIO0_33: length 100.4
  TOP w0.147: J2.D22 v1(47.88,131.08)
  L03_SIG1 w0.091: v1(47.88,131.08) 47.22,130.42 47.22,125.02 51.69,120.55 51.69,114.61 54.1,112.2 54.1,76.3 66.6,63.79 66.6,62.19 68.59,60.21 78.76,60.21 81.34,62.78 83.49,62.78 83.9,63.19 83.9,63.92 v1(84.36,64.38)
  BOTTOM w0.147: v1(84.36,64.38) 83.83,63.86 RA5.11
HSE_GPIO0_34: length 98.6
  TOP w0.147: J2.C23 v1(46.61,129.81)
  L03_SIG1 w0.091: v1(46.61,129.81) 47.04,129.38 47.04,124.94 47.13,124.85 51.51,120.47 51.51,114.53 52.83,113.21 52.83,103.52 53.88,102.48 53.88,76.26 65.53,64.6 65.53,61.63 67.17,59.99 78.85,59.99 81.43,62.56 83.81,62.56 84.33,63.08 v1(84.33,63.51)
  BOTTOM w0.147: v1(84.33,63.51) RA5.12
HSE_GPIO0_35: length 102
  TOP w0.147: J2.B24 v1(45.34,128.54)
  L03_SIG1 w0.091: v1(45.34,128.54) 45.77,128.11 45.77,124.75 49.66,120.87 49.66,115.21 51.76,113.11 51.76,102.33 52.02,102.06 52.76,102.06 53.65,101.17 53.65,76.22 64.39,65.49 64.39,61.99 66.61,59.77 78.95,59.77 81.52,62.34 84.79,62.34 84.9,62.45 84.9,63.92 v1(85.36,64.38)
  BOTTOM w0.147: RA5.13 84.83,63.86 v1(85.36,64.38)
HSE_GPIO0_36: length 13.3
  TOP w0.147: J2.A20 49.78,125.28 52.91,122.16 58.12,122.16 59.03,121.24 U8.19
HSE_GPIO0_36/FSI_TX0_CLK: length 91
  TOP w0.147: U8.9 57.54,115.22 57.55,115.2 57.55,114.75 57.53,114.73 57.53,114.57 55.45,112.49 51.55,112.49 v1(51.23,112.81)
  L03_SIG1 w0.091: v1(85.33,63.51) 85.33,62.36 84.96,61.99 83.27,61.99 80.83,59.54 64.91,59.54 63.04,61.42 63.04,66.58 53.43,76.18 53.43,100 52.26,101.17 52.26,101.42 51.23,102.46 v1(51.23,112.81)
  BOTTOM w0.147: RA5.14 v1(85.33,63.51)
HSE_GPIO0_37: length 106.1
  TOP w0.147: J2.C24 v1(45.34,129.81)
  L03_SIG1 w0.091: v1(45.34,129.81) 44.91,129.38 44.91,125.26 49.4,120.77 49.4,113.78 51.01,112.18 51.01,101.85 53.21,99.64 53.21,76.15 62.85,66.5 62.85,61.29 64.82,59.32 80.92,59.32 83.3,61.7 85.41,61.7 85.98,62.28 85.98,64.01 v1(86.36,64.38)
  BOTTOM w0.147: RA5.15 85.83,63.86 v1(86.36,64.38)
HSE_GPIO0_38: length 110.2
  TOP w0.147: J2.E26 v1(42.8,132.35)
  L03_SIG1 w0.091: v1(42.8,132.35) 43.41,131.74 43.41,124.58 47.06,120.93 47.06,116.78 48.51,115.33 48.51,114.36 50.79,112.09 50.79,101.76 50.95,101.59 52.99,99.55 52.99,76.11 62.67,66.43 62.67,61.16 64.76,59.07 86.23,59.07 86.92,59.76 86.92,62 86.42,62.5 v1(86.42,63.51)
  BOTTOM w0.147: RA5.16 v1(86.42,63.51)
HSE_GPIO0_39: length 106.5
  TOP w0.147: J2.C26 v1(42.8,129.81)
  L03_SIG1 w0.091: v1(42.8,129.81) 42.34,129.35 42.34,123.64 42.9,123.08 44.32,123.08 46.61,120.8 46.61,115.58 50.34,111.85 50.34,101.09 51.77,99.67 51.77,87.91 52.48,87.19 52.48,76.01 62.23,66.27 62.23,60.98 64.58,58.63 86.45,58.63 v1(88.11,56.97)
HSE_GPIO0_41: length 110.2
  TOP w0.147: J2.D26 v1(42.8,131.08)
  L03_SIG1 w0.091: v1(91.94,56.97) 91.35,57.55 87.84,57.55 86.54,58.85 64.67,58.85 62.45,61.07 62.45,66.35 52.67,76.14 52.67,87.46 51.99,88.15 51.99,99.76 50.56,101.18 50.56,111.94 46.84,115.66 46.84,120.89 43.23,124.51 43.23,130.65 v1(42.8,131.08)
HSE_MCAN0_RX/UART4_TXD: length 17.3
  TOP w0.147: J2.E24 v1(45.34,132.35)
  L03_SIG1 w0.091: v1(45.34,132.35) 44.5,131.51 44.5,123.85 47.74,120.6 v1(47.74,118.91)
  BOTTOM w0.147: U67.3 47.83,119 v1(47.74,118.91)
HSE_MCAN0_TX/UART4_RXD: length 18.1
  TOP w0.147: J2.D24 v1(45.34,131.08)
  L03_SIG1 w0.091: v1(45.34,131.08) 44.68,130.42 44.68,124.04 48.17,120.55 48.17,117.44 v1(47.74,117.01)
  BOTTOM w0.147: v1(47.74,117.01) 47.78,117.05 U67.6
HSE_MCAN1_RX/I2C3_SDA: length 17
  TOP w0.147: J2.C29 v1(38.99,129.81)
  L03_SIG1 w0.091: v1(41.66,116.6) 41.66,118.2 38.53,121.33 38.53,129.35 v1(38.99,129.81)
  BOTTOM w0.147: v1(41.66,116.6) 41.86,116.4 U67.10
HSE_MCAN1_TX/I2C3_SCL: length 18.3
  TOP w0.147: J2.D29 v1(38.99,131.08)
  L03_SIG1 w0.091: v1(38.99,131.08) 38.18,130.27 38.18,121.1 40.5,118.77 v1(40.5,117.7)
  BOTTOM w0.147: U67.13 41.15,118.35 v1(40.5,117.7)
HSE_PRG0_PRU0_GPO9: length 42.3
  TOP w0.147: J2.D28 v1(40.26,131.08)
  L03_SIG1 w0.091: v1(49.02,98.06) 48.95,97.99 47.28,97.99 46.74,98.53 46.74,113.9 45.34,115.29 45.34,120.33 44.49,121.18 44.48,121.17 42.17,121.17 41.13,122.21 41.13,124.69 39.83,125.98 39.83,130.65 v1(40.26,131.08)
  BOTTOM w0.147: v1(49.02,98.06) 49.39,98.06 49.92,97.53 U75.33
HSE_PRG0_PRU0_GPO10: length 40.8
  TOP w0.147: J2.B29 v1(38.99,128.54)
  L03_SIG1 w0.091: v1(38.99,128.54) 38.99,126.15 40.03,125.11 40.03,122.54 41.61,120.97 44.44,120.97 45.12,120.29 45.12,115.2 46.55,113.77 46.55,98.46 47.97,97.04 v1(49.02,97.04)
  BOTTOM w0.147: U75.31 49.54,96.53 v1(49.02,97.04)
HSE_PRG0_PRU1_GPO7: length 34.6
  TOP w0.147: J2.D23 v1(46.61,131.08)
  L03_SIG1 w0.091: v1(46.61,131.08) 46.14,130.61 46.14,125.58 51.32,120.4 51.32,114.46 52.42,113.36 52.42,103.28 v1(53.2,102.5)
  BOTTOM w0.147: U75.42 v1(53.2,102.5)
HSE_PRG0_PRU1_GPO9: length 35.6
  TOP w0.147: J2.E23 v1(46.61,132.35)
  L03_SIG1 w0.091: v1(46.61,132.35) 45.95,131.69 45.95,124.98 49.91,121.02 49.91,115.26 52.2,112.97 v1(52.2,102.5)
  BOTTOM w0.147: 52.2,100.48 v1(52.2,102.5)
HSE_PRG0_PRU1_GPO10: length 40.1
  TOP w0.147: J2.E27 v1(41.53,132.35)
  L03_SIG1 w0.091: v1(49.04,100.09) 49.04,101.85 47.16,103.73 47.16,114.1 45.79,115.46 45.79,120.44 44.53,121.71 42.16,121.71 41.5,122.37 41.5,124.83 40.87,125.46 40.87,131.69 v1(41.53,132.35)
  BOTTOM w0.147: v1(49.04,100.09) 49.58,99.55 50.04,99.55 50.06,99.53 U75.37
HSE_PRG0_PRU1_GPO17: length 39.1
  TOP w0.147: J2.C28 v1(40.26,129.81)
  L03_SIG1 w0.091: v1(40.26,129.81) 40.69,129.38 40.69,125.39 41.31,124.76 41.31,122.29 42.17,121.43 44.5,121.43 45.57,120.36 45.57,115.37 46.98,113.97 46.98,103.28 47.9,102.36 47.9,99.37 48.19,99.07 v1(49.02,99.07)
  BOTTOM w0.147: U75.35 49.81,98.53 49.26,99.07 v1(49.02,99.07)
IFORCE: length 5.3
  TOP w0.147: U23.H16 v1(93.86,72.7)
  BOTTOM w0.114: v1(93.86,72.7) 94.26,72.3 94.26,70.14 95.26,69.14 TP71.1
IN_SEL0: length 2.6
  TOP w0.147: R40.2 v1(55.88,106.95)
  BOTTOM w0.147: U70.30 56.45,107.06 56.33,106.95 v1(55.88,106.95) R40.2
IN_SEL1: length 3.2
  TOP w0.147: R45.1 v1(55.88,105.68)
  BOTTOM w0.147: R45.1 v1(55.88,105.68) 55.88,106.13 56.31,106.56 U70.29
INA_ALERT: length 142.2
  TOP w0.147: R122.2 v1(137.56,74.55) ; 142.95,115.64 143.89,116.58 149.5,116.58 149.97,116.11 R28.2 ; 142.95,115.64 142.95,108.73 143,108.73 v1(143.79,107.94) 142.95,107.1 142.95,106.51 142.37,105.93 137.72,105.93 137.41,105.63 R48.2 R47.1 134.51,105.15 132.63,107.04 125.73,107.04 125.62,106.93 R43.2 ; 142.95,115.64 136.78,121.81 J4.4 ; R1.2 v1(86.36,132.22)
  L03_SIG1 w0.091: v1(143.79,107.94) 143.79,107.48 144.12,107.15 144.12,96.5 138.3,90.68 138.3,75.29 v1(137.56,74.55) ; v1(86.36,132.22) 86.79,132.22 86.85,132.28 89.61,132.28 90.17,131.71 91.36,131.71 96.24,126.84 134.67,126.84 J4.4
  BOTTOM w0.147: v1(143.79,107.94) 144.24,107.94 144.4,108.09 R244.2
IO_EXP_INTN_SDIO: length 72.2
  TOP w0.147: v1(59.45,29.75) 59.98,29.22 60.83,29.22 62.36,30.75 62.36,32.91 63.25,33.8 78.11,33.8 91.44,47.13 92.46,47.13 93.8,48.47 93.8,49.36 93.47,49.68 93.47,51.12 93.6,51.25 v1(93.6,51.7) ; U23.C20 97.06,69.5 97.06,65.41 98.3,64.18 v1(98.3,63.26)
  L08_SIG2 w0.091: v1(98.3,63.26) 99.06,62.5 99.06,56.39 94.38,51.7 v1(93.6,51.7)
  BOTTOM w0.147: U91.32 58.54,31.41 58.74,31.21 58.74,30.53 58.9,30.37 R465.1 v1(59.45,29.75)
JTAG_CTI_RTCK: length 33.8
  TOP w0.147: J25.9 70.61,49.67 v1(70.1,50.18)
  L08_SIG2 w0.091: v1(70.1,50.18) 70.48,49.8 70.48,46.17 77.64,39.02 77.64,34.82 81.05,31.41 v1(81.05,27.83)
  BOTTOM w0.147: R636.1 R637.1 R491.1 v1(81.05,27.83)
JTAG_CTI_TCK: length 34.6
  TOP w0.147: v1(70,49.04) 69.68,48.72 69.56,48.72 69.34,48.5 J25.11 ; U53.2 R190.1 R188.1 v1(76.16,29.48)
  L03_SIG1 w0.091: v1(76.16,29.48) 72.64,29.48 70.48,31.64 70.48,46.12 69.98,46.62 69.98,48.58 70,48.6 v1(70,49.04)
  BOTTOM w0.147: v1(76.16,29.48) 77.59,29.48 78.26,28.82 U53.2
JTAG_DIR: length 3.2
  TOP w0.147: U37.2 88.19,51.46 88.16,51.49 R148.2 87.69,51.62 U37.3
JTAG_EMU0: length 53.6
  TOP w0.147: v1(96.63,34.7) 96.37,34.44 U45.8 ; v1(96.63,31.15) 96.37,30.89 U48.8 ; J25.13 68.07,48.53 68.58,49.04 v1(69.09,49.04)
  L03_SIG1 w0.091: v1(96.63,34.7) 95.78,34.7 93.47,32.4 92.66,32.4 91.13,30.88 80.75,30.88 77.7,33.92 75.75,33.92 72.7,36.98 72.7,47.08 70.29,49.48 69.53,49.48 v1(69.09,49.04)
  BOTTOM w0.147: v1(96.63,34.7) 96.17,34.7 96.11,34.76 R455.2 95.41,32.36 v1(96.63,31.15)
JTAG_EMU1: length 45.1
  TOP w0.147: v1(72.26,37.1) 69.33,37.1 68.18,38.26 68.18,39.57 68.07,39.68 J25.14 ; U45.1 98.31,34.44 98.2,34.56 v1(97.79,34.56) ; U48.1 98.2,30.89 v1(97.94,31.15)
  L03_SIG1 w0.091: v1(72.26,37.1) 75.89,33.48 77.84,33.48 80.79,30.52 93.75,30.52 v1(97.79,34.56)
  BOTTOM w0.147: v1(97.94,31.15) 99.06,32.27 99.06,34.32 R458.2 98.32,34.48 98.24,34.56 v1(97.79,34.56)
JTAG_EMU_RSTN: length 141
  TOP w0.147: v1(65.53,35.64) 62.68,38.5 62.68,48.97 63.89,50.18 66.06,50.18 66.66,49.58 R150.2 66.66,48.95 66.8,48.81 J25.15 ; U41.6 139.56,45.03 137.97,46.62 134.75,46.62 134.11,47.26 130.68,47.26 125.6,42.18 125.6,33.3 123.7,31.39 116.6,31.39 113.64,28.44 v1(113.64,27.6)
  L03_SIG1 w0.091: v1(65.53,35.64) 67.61,33.57 67.61,17.9 69.11,16.4 79.36,16.4 79.61,16.14 89.92,16.14 94.23,11.83 102.87,11.83 108.76,17.72 108.76,22.72 v1(113.64,27.6)
  BOTTOM w0.147: R449.1 v1(65.53,35.64)
JTAG_MIPI_EMU0: length 35
  TOP w0.147: U48.5 96.37,32.39 v1(96.63,32.13)
  L03_SIG1 w0.091: v1(72.14,38.24) 71.83,37.93 71.83,36.27 74.84,33.26 77.75,33.26 80.7,30.3 94.8,30.3 v1(96.63,32.13)
  BOTTOM w0.147: R461.2 v1(96.63,32.13) ; J33.38 71.72,39.58 71.71,39.57 71.71,39.2 71.72,39.19 71.72,38.66 v1(72.14,38.24)
JTAG_MIPI_EMU1: length 37.1
  TOP w0.147: U48.4 98.2,32.39 v1(97.94,32.13)
  L03_SIG1 w0.091: v1(72.17,39.38) 71.61,38.82 71.61,36.17 74.74,33.03 77.66,33.03 80.61,30.08 96.49,30.08 97.5,31.1 97.5,31.69 v1(97.94,32.13)
  BOTTOM w0.147: v1(72.17,39.38) 72.26,39.48 72.26,41.17 J33.40 ; R460.2 v1(97.94,32.13)
JTAG_MIPI_RTCK: length 40.9
  L08_SIG2 w0.091: v1(64.14,48.78) 64.14,36.72 63.63,36.21 63.63,34.3 63.25,33.92 63.25,31.54 64.8,29.99 71.25,29.99 75.46,25.77 v1(75.46,23.98)
  BOTTOM w0.147: R638.1 R639.1 v1(75.46,23.98) R492.1 ; J33.7 64.22,48.7 v1(64.14,48.78)
JTAG_MIPI_TCK: length 35.8
  TOP w0.147: U52.2 R189.1 R187.1 v1(70.58,29.48)
  L08_SIG2 w0.091: v1(63.14,48.78) 63.14,37.37 62.48,36.72 62.48,31.64 64.64,29.48 v1(70.58,29.48)
  BOTTOM w0.147: v1(63.14,48.78) 63.22,48.7 J33.3 ; U52.2 72.67,28.62 71.8,29.48 v1(70.58,29.48)
JTAG_MUX_SEL: length 15.4
  TOP w0.147: U60.1 v1(98.2,14.08)
  BOTTOM w0.147: v1(98.2,14.08) 100.06,12.21 J29.2
JTAG_TCK: length 54.3
  TOP w0.147: v1(97.18,12.78) 97.83,12.13 U60.4 ; U37.12 v1(86.69,46.28)
  L03_SIG1 w0.091: v1(86.69,46.28) 87.16,46.75 88.14,46.75 90.08,44.81 90.08,41.08 95.36,35.8 97.44,35.8 97.88,35.36 100.04,35.36 102.42,32.98 102.42,31.95 102.68,31.69 103.2,31.69 103.38,31.51 103.38,25.47 101.78,23.87 101.78,15.31 98.81,12.34 97.62,12.34 v1(97.18,12.78)
  BOTTOM w0.147: v1(86.69,46.28) 86.69,45.83 86.75,45.76 R640.2
JTAG_TDI: length 30
  TOP w0.147: J25.3 74.42,48.53 75.06,49.16 ; 75.06,49.16 75.06,50.05 74.17,50.94 64.26,50.94 v1(63.37,51.83) 62.82,51.28 R642.2 ; 75.06,49.16 81.66,49.16 84.33,46.5 85.34,46.5 85.69,46.84 U37.10
  BOTTOM w0.147: R410.2 v1(63.37,51.83)
JTAG_TDIS: length 2.9
  TOP w0.147: J25.4 R177.2
JTAG_TDO: length 58.5
  TOP w0.147: J25.7 v1(71.88,49.29) ; U46.7 90.48,36.39 90.72,36.63 91.36,36.63 91.82,37.09 91.82,38.11 91.44,38.5 v1(83.82,38.5)
  L03_SIG1 w0.091: v1(64.26,35.64) 64.83,36.21 68.6,36.21 69.6,37.2 69.6,39.89 68.55,40.94 68.55,49.1 69.19,49.74 71.43,49.74 v1(71.88,49.29)
  BOTTOM w0.147: v1(83.82,38.5) 81.62,36.29 71.2,36.29 69.88,34.98 64.93,34.98 v1(64.26,35.64) R450.1
JTAG_TMS: length 53.3
  TOP w0.147: J25.1 83.15,46.66 84.54,45.26 v1(85.69,45.26) 85.69,45.32 86.19,45.82 U37.11 ; R641.2 v1(62.99,35.64)
  L03_SIG1 w0.091: v1(85.69,45.26) 80.23,50.73 69.87,50.73 68.33,49.18 68.33,40.91 68.36,40.87 68.36,40.87 69.38,39.85 69.38,37.64 68.2,36.46 63.81,36.46 v1(62.99,35.64)
  BOTTOM w0.147: R641.2 v1(62.99,35.64)
JTAG_TRST#: length 30.4
  TOP w0.147: v1(66.8,35.64) 67.26,35.19 75.51,35.19 78.16,37.84 C529.2 R685.2 78.16,42.22 78.54,42.6 85.65,42.6 86.75,43.7 R643.2 86.75,44.89 87.19,45.33 U37.13
  BOTTOM w0.147: R448.1 v1(66.8,35.64)
LED1: length 34.1
  TOP w0.147: U34.3 41.78,49.23 41.68,49.33 41.68,51.79 34.37,59.11 34.37,60.08 29.84,64.6 29.84,68.36 31.54,70.05 34.26,70.05 36.35,72.14 LD16.1
LED2: length 32.5
  TOP w0.147: LD17.1 34.32,72.15 32.55,70.38 30.79,70.38 29.55,69.14 29.55,64.48 34.07,59.95 34.07,58.98 40.28,52.77 40.28,49.28 40.51,49.05 U34.4
LED3: length 30.5
  TOP w0.147: U34.5 39.24,52.15 34.79,56.6 34.79,57.85 33.78,58.86 33.78,59.83 29.25,64.36 29.25,69.43 31.09,71.27 31.43,71.27 32.28,72.13 LD18.1
LED4: length 29.1
  TOP w0.147: U34.6 37.97,52.96 34.49,56.44 34.49,57.73 33.48,58.74 33.48,59.71 28.96,64.24 28.96,69.8 30.25,71.09 LD19.1
LED5: length 54.9
  TOP w0.147: LD14.1 v1(51.15,68.59) ; U34.11 37.97,43.74 39.8,45.57 42.72,45.57 43.26,45.03 45.73,45.03 46.1,44.66 50.11,44.66 50.66,44.11 53.01,44.11 54.01,45.11 56.03,45.11 56.34,45.42 57.33,45.42 58.75,46.84 60.15,46.84 v1(60.48,46.51)
  L03_SIG1 w0.091: v1(51.15,68.59) 53.71,68.59 58.55,63.75 58.55,60.6 60.59,58.57 60.59,52.63 60.48,52.52 v1(60.48,46.51)
LED6: length 52.1
  TOP w0.147: v1(50.55,67.69) 50.52,67.67 50.24,67.67 50.09,67.81 LD13.1 ; U34.12 39.24,43.02 39.88,43.65 39.88,44.63 40.21,44.96 42.33,44.96 42.55,44.73 45.61,44.73 45.98,44.36 49.99,44.36 50.54,43.82 53.13,43.82 54.13,44.82 56.15,44.82 56.46,45.12 57.45,45.12 58.3,45.97 v1(59.05,45.97)
  L03_SIG1 w0.091: v1(59.05,45.97) 59.73,46.65 59.73,58.53 57.63,60.63 57.63,63.32 57.61,63.34 57.61,63.69 57.63,63.71 57.63,63.8 53.75,67.69 v1(50.55,67.69)
LED7: length 89.8
  TOP w0.147: v1(58.72,44.78) 57.47,43.53 50.41,43.53 49.87,44.07 45.86,44.07 45.49,44.44 43.11,44.44 42.59,43.92 41.41,43.92 40.51,43.02 U34.13 ; LD12.1 23.53,87.23 v1(23.77,87.48)
  L03_SIG1 w0.091: v1(55.37,60.78) 55.68,60.47 55.7,60.47 55.95,60.22 55.95,59.87 55.85,59.77 55.85,57.56 56.62,56.79 56.62,54.13 57.71,53.04 57.71,48.77 58.17,48.3 58.17,45.33 v1(58.72,44.78)
  BOTTOM w0.147: v1(23.77,87.48) 25.53,87.48 26.51,86.49 35.25,86.49 36.62,85.12 41.28,85.12 42.07,84.33 42.07,77.41 46.66,72.82 46.66,68.17 47.12,67.71 47.12,66.04 48.26,64.9 50.32,64.9 51.92,63.3 51.92,62.59 53.72,60.78 v1(55.37,60.78)
LED8: length 94.6
  TOP w0.147: v1(59.21,44.12) 58.12,43.03 46.48,43.03 45.36,44.15 43.23,44.15 42.71,43.62 42.39,43.62 41.78,43.02 U34.14 ; LD11.1 v1(19.42,87.23)
  L03_SIG1 w0.091: v1(59.21,44.12) 58.84,44.12 58.81,44.15 58.47,44.15 57.99,44.63 57.99,48.23 57.35,48.86 57.35,53.04 56.32,54.07 56.32,56.8 55.52,57.6 v1(55.52,60.05)
  BOTTOM w0.147: v1(55.52,60.05) 52.25,60.05 50.24,62.05 50.24,63.81 49.45,64.6 48.14,64.6 46.83,65.91 46.83,67.59 46.54,67.88 46.37,68.05 46.37,72.68 41.77,77.28 41.77,84.21 41.16,84.83 36.49,84.83 35.12,86.2 26.1,86.2 25.32,86.97 20.14,86.97 19.88,87.23 v1(19.42,87.23)
