# Allegro board PROC101A_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BOOTMODE1: length 62
  TOP w0.147: RA1.7 67.2,77.58 67.44,77.34 68.39,77.34 69.14,76.6 v1(69.6,76.6) 69.6,76.14 68.78,75.33 67.35,75.33 67.2,75.18 RA2.2 ; v1(67.07,63.34) 67.31,63.57 67.31,64.11 67.46,64.26 67.67,64.26 67.82,64.11 67.82,62.89 67.97,62.74 68.45,62.74 70.74,65.03 70.74,65.93 71.29,66.48 76.67,66.48 77.17,65.98 83.58,65.98 86.26,68.66 U23.U21
  BOTTOM w0.147: R326.1 v1(69.6,76.6) 69.06,77.13 68.88,77.13 68.67,76.93 68.49,76.93 68.36,77.06 68.36,77.24 68.57,77.44 68.57,77.63 68.21,77.98 67.97,77.98 67.84,77.85 67.84,77.47 67.71,77.34 67.53,77.34 67.4,77.47 67.4,77.85 67.27,77.98 61.78,77.98 59.86,76.05 59.86,69.61 66.13,63.34 v1(67.07,63.34)
BOOTMODE2: length 60.8
  TOP w0.147: U23.T18 v1(86.66,71.1) ; RA1.6 66.7,77.47 67.32,76.85 67.49,76.85 67.87,76.47 v1(68.33,76.47) 68.33,76.01 68.02,75.71 66.94,75.71 66.7,75.47 RA2.3
  L03_SIG1 w0.091: v1(86.66,71.1) 87.06,70.71 87.06,69.65 84.98,67.58 80.78,67.58 80.7,67.66 80.7,68.86 80.61,68.94 80.5,68.94 80.42,68.86 80.42,67.66 80.34,67.58 80.23,67.58 80.15,67.66 80.15,68.86 80.07,68.94 79.95,68.94 79.87,68.86 79.87,67.66 79.79,67.58 79.68,67.58 79.6,67.66 79.6,68.86 79.52,68.94 79.4,68.94 79.32,68.86 79.32,67.66 79.24,67.58 78.3,67.58 77.65,68.23 77.65,68.34 78.08,68.77 78.08,68.89 78,68.97 77.88,68.97 77.45,68.54 77.34,68.54 77.26,68.62 77.26,68.73 77.69,69.16 77.69,69.27 77.61,69.35 77.5,69.35 77.07,68.92 76.95,68.92 76.87,69 76.87,69.12 77.3,69.55 77.3,69.66 77.22,69.74 77.11,69.74 76.68,69.31 76.21,69.31 74.26,71.25 74.26,71.69 74.17,71.79 74.17,74.47 72.82,75.82 71.93,75.82 71.28,75.17 68.65,75.17 68.56,75.26 68.56,75.58 68.47,75.67 68.31,75.67 68.21,75.58 68.21,75.26 68.12,75.17 67.96,75.17 67.87,75.26 67.87,75.58 67.78,75.67 67.61,75.67 67.52,75.58 67.52,75.26 67.43,75.17 67.27,75.17 67.18,75.26 67.18,75.58 67.09,75.67 66.92,75.67 66.83,75.58 66.83,75.26 66.74,75.17 66.58,75.17 66.49,75.26 66.49,75.58 66.4,75.67 66.23,75.67 66.14,75.58 66.14,75.26 66.05,75.17 65.89,75.17 65.8,75.26 65.8,75.58 65.7,75.67 65.54,75.67 65.45,75.58 65.45,75.26 65.36,75.17 65.2,75.17 65.11,75.26 65.11,75.58 65.01,75.67 64.85,75.67 64.76,75.58 64.76,75.26 64.67,75.17 63.66,75.17 63.31,75.52 63.31,75.82 63.4,75.92 67.77,75.92 v1(68.33,76.47)
  BOTTOM w0.147: R327.1 v1(68.33,76.47)
BOOTMODE3: length 59.2
  TOP w0.147: RA1.5 66.2,76.87 66.6,76.47 v1(67.06,76.47) 66.73,76.15 66.73,76.01 66.2,75.47 RA2.4 ; U23.U20 85.86,69.5 85.86,68.67 83.46,66.28 77.29,66.28 76.64,66.93 73.21,66.93 72.71,67.44 71.46,67.44 69.76,65.74 69.76,64.7 v1(68.45,63.39)
  BOTTOM w0.147: v1(68.45,63.39) 67.94,63.9 65.98,63.9 61.72,68.16 61.72,68.32 61.89,68.5 61.89,68.66 61.78,68.78 61.61,68.78 61.44,68.61 61.27,68.61 61.16,68.73 61.16,68.89 61.34,69.08 61.34,69.24 61.22,69.36 61.06,69.36 60.87,69.18 60.71,69.18 60.15,69.73 60.15,70.7 60.27,70.82 60.6,70.82 60.72,70.93 60.72,71.1 60.6,71.22 60.27,71.22 60.15,71.33 60.15,71.5 60.27,71.62 60.6,71.62 60.72,71.74 60.72,71.9 60.6,72.02 60.27,72.02 60.15,72.14 60.15,72.3 60.27,72.42 60.6,72.42 60.72,72.54 60.72,72.71 60.6,72.82 60.27,72.82 60.15,72.94 60.15,73.11 60.27,73.22 60.6,73.22 60.72,73.34 60.72,73.51 60.6,73.63 60.27,73.63 60.15,73.74 60.15,73.91 60.27,74.03 60.6,74.03 60.72,74.14 60.72,74.31 60.6,74.43 60.27,74.43 60.15,74.55 60.15,74.71 60.27,74.83 60.6,74.83 60.72,74.95 60.72,75.11 60.6,75.23 60.27,75.23 60.15,75.35 60.15,75.9 61.85,77.6 65.93,77.6 v1(67.06,76.47) R328.1
BOOTMODE4: length 58.2
  TOP w0.147: RA1.4 65.7,77.14 65.79,77.05 v1(65.79,76.47) 65.79,75.83 65.7,75.75 RA2.5 ; U23.U18 v1(85.86,71.1)
  L03_SIG1 w0.091: v1(65.79,76.47) 65.41,76.47 65.05,76.83 64.75,76.83 64.69,76.9 64.34,76.9 64.28,76.83 64.04,76.83 64.01,76.86 63.82,76.86 63.44,77.24 63.44,77.81 63.74,78.11 63.96,78.11 64.05,78.02 64.05,77.18 64.14,77.09 64.31,77.09 64.4,77.18 64.4,78.02 64.49,78.11 64.65,78.11 64.74,78.02 64.74,77.18 64.84,77.09 65,77.09 65.09,77.18 65.09,78.02 65.18,78.11 65.34,78.11 65.43,78.02 65.43,77.18 65.53,77.09 65.69,77.09 65.78,77.18 65.78,78.02 65.87,78.11 66.03,78.11 66.13,78.02 66.13,77.04 66.22,76.94 66.38,76.94 66.47,77.04 66.47,78.02 66.56,78.11 66.73,78.11 66.82,78.02 66.82,77.03 66.91,76.93 67.07,76.93 67.16,77.03 67.16,78.02 67.25,78.11 67.42,78.11 67.51,78.02 67.51,77.03 67.61,76.93 67.76,76.93 67.85,77.03 67.85,78.02 67.94,78.11 68.11,78.11 68.2,78.02 68.2,77.18 68.29,77.09 68.45,77.09 68.54,77.18 68.54,78.02 68.64,78.11 68.99,78.11 69.17,77.93 69.17,77.71 69.26,77.62 69.74,77.62 69.83,77.53 69.83,77.36 69.74,77.27 69.26,77.27 69.17,77.18 69.17,75.99 69.49,75.67 71.37,75.67 71.75,76.05 72.85,76.05 74.39,74.51 74.39,71.95 74.4,71.94 74.4,71.82 74.45,71.77 74.45,71.33 75.42,70.36 79.62,70.36 79.7,70.28 79.7,69.6 79.78,69.52 79.89,69.52 79.97,69.6 79.97,70.28 80.05,70.36 81.03,70.36 81.89,69.49 81.89,68.15 82.25,67.8 84.89,67.8 86.26,69.16 86.26,70.71 v1(85.86,71.1)
  BOTTOM w0.147: R329.1 v1(65.79,76.47)
BOOTMODE5: length 59
  TOP w0.147: RA2.6 65.2,75.33 64.52,76.01 v1(64.52,76.47) 64.97,76.47 65.2,76.7 RA1.3 ; U23.U19 v1(85.86,70.3)
  L03_SIG1 w0.091: v1(85.86,70.3) 85.86,69.4 85.55,69.09 82.33,69.09 82.09,69.33 82.09,70.03 81.51,70.61 75.42,70.61 74.63,71.4 74.63,71.97 74.57,72.03 74.57,74.58 72.58,76.58 71.96,76.58 71.25,75.87 70.45,75.87 70.1,76.21 70.1,76.96 70.88,77.74 70.88,78.94 70.26,79.57 69.25,79.57 69.16,79.48 69.16,78.54 69.06,78.44 68.9,78.44 68.81,78.54 68.81,79.48 68.72,79.57 68.56,79.57 68.46,79.48 68.46,78.54 68.37,78.44 68.21,78.44 68.12,78.54 68.12,79.48 68.03,79.57 67.86,79.57 67.77,79.48 67.77,78.54 67.68,78.44 67.52,78.44 67.43,78.54 67.43,79.48 67.34,79.57 67.17,79.57 67.08,79.48 67.08,78.54 66.99,78.44 66.83,78.44 66.74,78.54 66.74,79.48 66.65,79.57 66.48,79.57 66.39,79.48 66.39,78.54 66.3,78.44 66.14,78.44 66.05,78.54 66.05,79.48 65.95,79.57 65.79,79.57 65.7,79.48 65.7,78.54 65.61,78.44 65.45,78.44 65.36,78.54 65.36,79.48 65.26,79.57 65.1,79.57 65.01,79.48 65.01,78.54 64.92,78.44 64.76,78.44 64.66,78.54 64.66,79.48 64.57,79.57 64.41,79.57 64.32,79.48 64.32,78.54 64.23,78.44 64.07,78.44 63.97,78.54 63.97,79.48 63.88,79.57 63.62,79.57 63.24,79.19 63.24,77.18 63.74,76.68 63.93,76.68 64.14,76.47 v1(64.52,76.47)
  BOTTOM w0.147: R330.1 v1(64.52,76.47)
BOOTMODE6: length 60.3
  TOP w0.147: v1(68.45,65.17) 69.17,65.89 69.17,66.02 71.2,68.04 73.34,68.04 73.47,67.91 73.47,67.69 73.6,67.56 73.78,67.56 73.91,67.69 73.91,67.91 74.04,68.04 74.23,68.04 74.36,67.91 74.36,67.69 74.48,67.56 74.67,67.56 74.8,67.69 74.8,67.91 74.93,68.04 75.11,68.04 75.24,67.91 75.24,67.69 75.37,67.56 75.55,67.56 75.68,67.69 75.68,67.91 75.81,68.04 76.36,68.04 77.53,66.87 83.2,66.87 83.44,67.11 83.45,67.11 85.06,68.72 85.06,69.5 U23.V20 ; RA2.7 64.7,75.27 64.01,75.96 63.75,75.96 v1(63.25,76.47) 63.7,76.47 64.08,76.85 64.26,76.85 64.7,77.29 RA1.2
  BOTTOM w0.147: R331.1 v1(63.25,76.47) 63.57,76.79 63.57,77.09 63.35,77.3 61.98,77.3 61.01,76.33 61.01,70.24 62.9,68.35 62.9,68.17 62.67,67.94 62.67,67.76 62.8,67.63 62.98,67.63 63.21,67.86 63.39,67.86 63.52,67.73 63.52,67.55 63.29,67.32 63.29,67.13 63.42,67 63.61,67 63.84,67.23 64.02,67.23 64.15,67.1 64.15,66.92 63.92,66.69 63.92,66.51 64.05,66.38 64.23,66.38 64.46,66.61 64.64,66.61 64.77,66.48 64.77,66.3 64.55,66.07 64.55,65.88 64.67,65.75 64.86,65.75 65.09,65.98 65.27,65.98 65.4,65.85 65.4,65.67 65.17,65.44 65.17,65.26 65.3,65.13 65.48,65.13 65.71,65.36 65.89,65.36 66.02,65.23 66.02,65.05 65.8,64.82 65.8,64.63 65.92,64.5 66.11,64.5 66.34,64.73 66.52,64.73 66.92,64.34 69.1,64.34 69.25,64.48 69.25,65.04 69.69,65.48 69.69,66.07 69.5,66.26 67.91,66.26 67.49,65.84 67.49,65.63 67.82,65.3 67.82,64.92 67.97,64.77 68.31,64.77 68.45,64.92 v1(68.45,65.17)
BOOTMODE7: length 61.6
  TOP w0.147: v1(67.31,65.17) 67.82,64.66 68.83,64.66 69.47,65.29 69.47,65.87 71.34,67.73 72.83,67.73 73.34,67.22 76.76,67.22 77.41,66.57 83.32,66.57 85.46,68.71 U23.V21 ; RA2.8 64.11,75.18 63.72,75.58 62.54,75.58 61.98,76.14 v1(61.98,76.6) 62.43,76.6 63.07,77.23 63.99,77.23 64.11,77.35 RA1.1
  BOTTOM w0.147: R332.1 v1(61.98,76.6) 61.72,76.34 61.49,76.34 61.35,76.19 61.35,73.65 61.49,73.51 62.63,73.51 62.95,73.18 62.95,72.87 63.07,72.75 63.64,72.75 63.75,72.63 63.75,71.82 63.64,71.7 63.47,71.7 63.35,71.82 63.35,72.23 63.24,72.35 63.07,72.35 62.95,72.23 62.95,71.13 62.83,71.01 62.67,71.01 62.55,71.13 62.55,72.6 62.43,72.72 62.27,72.72 62.15,72.6 62.15,71.13 62.03,71.01 61.87,71.01 61.75,71.13 61.75,72.6 61.63,72.72 61.46,72.72 61.35,72.6 61.35,70.33 61.8,69.88 61.96,69.88 62.37,70.28 62.53,70.28 62.73,70.09 62.89,70.09 63.43,70.63 63.6,70.63 63.72,70.51 63.72,70.34 63.18,69.81 63.18,69.65 63.74,69.09 63.74,68.93 63.62,68.81 63.45,68.81 62.55,69.71 62.37,69.71 62.25,69.6 62.25,69.43 66.51,65.17 v1(67.31,65.17)
BOOTMODE8: length 63.3
  TOP w0.147: RA3.8 75.15,62.22 75.9,61.47 77.94,61.47 78.23,61.18 v1(78.23,60.72) 78.23,60.09 77.18,59.03 RA4.1 ; U23.V19 v1(85.06,70.3)
  BOTTOM w0.147: R372.1 v1(78.23,60.72) 77.6,61.36 76.33,61.36 75.31,62.37 75.31,64.02 76.03,64.74 76.03,64.91 75.73,65.21 75.73,65.37 75.84,65.49 76.01,65.49 76.31,65.19 76.48,65.19 76.59,65.31 76.59,65.47 76.29,65.77 76.29,65.94 76.41,66.06 76.58,66.06 76.88,65.76 79.08,65.76 79.22,65.61 79.22,64.71 79.34,64.59 79.53,64.59 79.65,64.47 79.65,64.31 79.53,64.19 79.34,64.19 79.22,64.07 79.22,63.91 79.34,63.79 79.53,63.79 79.65,63.67 79.65,63.51 79.53,63.39 79.34,63.39 79.22,63.27 79.22,62.66 79.83,62.06 79.83,60.65 79.94,60.53 81.71,60.53 81.83,60.41 81.83,60.25 81.71,60.13 81.05,60.13 80.93,60.01 80.93,59.34 80.81,59.22 80.65,59.22 80.53,59.34 80.53,60.01 80.41,60.13 79.94,60.13 79.83,60.01 79.83,58.72 79.97,58.58 82.06,58.58 82.26,58.79 82.26,59.22 82.15,59.34 81.54,59.34 81.42,59.45 81.42,59.62 81.54,59.74 82.15,59.74 82.26,59.85 82.26,64.66 82.55,64.95 84.52,64.95 84.83,65.25 84.83,66.19 85.19,66.55 86.54,66.55 86.66,66.67 86.66,66.83 86.54,66.95 85.46,66.95 85.34,67.07 85.34,67.24 85.46,67.35 86.54,67.35 86.66,67.47 86.66,67.64 86.54,67.76 85.46,67.76 85.34,67.87 85.34,68.04 85.48,68.17 86.58,68.17 86.7,68.29 86.7,68.46 86.58,68.57 85.58,68.57 85.43,68.72 85.43,68.93 85.58,69.08 86.84,69.08 86.96,69.19 86.96,69.36 86.84,69.48 85.18,69.48 85.06,69.6 v1(85.06,70.3)
BOOTMODE9: length 62
  TOP w0.147: U23.T17 v1(86.66,71.9) ; RA3.7 74.57,61.72 74.76,61.52 75.31,61.52 75.65,61.18 76.51,61.18 v1(76.96,60.72) 76.07,59.83 74.65,59.83 74.53,59.71 74.53,59.07 RA4.2
  BOTTOM w0.114: 84.66,70.14 84.66,70.47 84.89,70.7 84.91,70.7 84.91,70.7 86.02,70.7 86.03,70.71 86.06,70.71 86.26,70.91 86.26,71.27 86.66,71.67 v1(86.66,71.9)
  BOTTOM w0.147: R373.1 v1(76.96,60.72) 76.51,60.72 74.68,62.55 74.68,65.93 75.61,66.87 77.4,66.87 77.52,66.75 77.52,66.17 77.63,66.05 77.8,66.05 77.92,66.17 77.92,66.75 78.03,66.87 78.2,66.87 78.32,66.75 78.32,66.17 78.44,66.05 78.6,66.05 78.72,66.17 78.72,66.75 78.84,66.87 79.97,66.87 80.17,66.66 80.17,66.55 80.3,66.42 81.4,66.42 81.53,66.29 81.53,66.1 81.4,65.97 80.3,65.97 80.17,65.85 80.17,65.66 80.3,65.53 81.4,65.53 81.53,65.4 81.53,65.22 81.4,65.09 80.3,65.09 80.17,64.96 80.17,63.64 80.29,63.52 81.44,63.52 81.56,63.41 81.56,63.24 81.44,63.12 81.23,63.12 81.12,63 81.12,62.59 81,62.47 80.83,62.47 80.71,62.59 80.71,63 80.6,63.12 80.29,63.12 80.17,63 80.17,62.5 80.63,62.04 81.71,62.04 81.97,62.3 81.97,64.27 81.85,64.38 81.48,64.38 81.37,64.5 81.37,64.67 81.48,64.78 81.85,64.78 81.97,64.9 81.97,65.48 82.09,65.6 82.51,65.6 82.63,65.48 82.63,65.36 82.75,65.24 82.92,65.24 83.03,65.36 83.03,65.48 83.15,65.6 83.32,65.6 83.43,65.48 83.43,65.36 83.55,65.24 83.72,65.24 83.84,65.36 83.84,65.48 83.95,65.6 84.24,65.6 84.36,65.71 84.36,65.88 84.24,66 83.89,66 83.77,66.11 83.77,66.25 83.65,66.37 83.49,66.37 83.37,66.25 83.37,66.11 83.25,66 83.08,66 82.97,66.11 82.97,66.25 82.85,66.37 82.68,66.37 82.57,66.25 82.57,66.11 82.45,66 82.09,66 81.97,66.11 81.97,66.39 82.39,66.81 84.44,66.81 84.66,67.03 84.66,67.94 84.53,68.07 83.77,68.07 83.64,68.2 83.64,68.39 83.77,68.51 84.53,68.51 84.66,68.64 84.66,68.83 84.53,68.96 83.77,68.96 83.64,69.09 83.64,69.27 83.77,69.4 84.53,69.4 84.66,69.53 84.66,70.14
BOOTMODE10: length 60.4
  TOP w0.147: U23.R16 v1(87.46,72.7) ; RA4.3 74.03,59.07 74.03,59.97 74.28,60.21 75.18,60.21 v1(75.69,60.72) 75.18,61.23 74.55,61.23 74.07,61.71 RA3.6
  BOTTOM w0.114: 83.84,70.1 83.86,70.12 83.86,71.27 84.09,71.5 86.02,71.5 86.26,71.74 86.26,72.09 86.47,72.3 87.06,72.3 v1(87.46,72.7)
  BOTTOM w0.147: 83.84,70.1 83.29,69.54 83.29,68.17 82.3,67.19 81.5,67.19 81.37,67.31 81.37,67.89 81.24,68.02 81.06,68.02 80.93,67.89 80.93,67.31 80.8,67.19 80.62,67.19 80.49,67.31 80.49,67.89 80.36,68.02 80.17,68.02 80.05,67.89 80.05,67.31 79.92,67.19 79.74,67.19 79.61,67.31 79.61,67.89 79.48,68.02 79.3,68.02 79.17,67.89 79.17,67.31 79.04,67.19 78.1,67.19 77.98,67.3 77.98,68.44 77.86,68.55 77.7,68.55 77.58,68.44 77.58,67.3 77.46,67.19 77.3,67.19 77.18,67.3 77.18,68.44 77.06,68.55 76.9,68.55 76.78,68.44 76.78,67.3 76.66,67.19 76.48,67.19 76.35,67.31 76.35,67.76 76.22,67.89 76.04,67.89 75.91,67.76 75.91,67.31 75.78,67.19 75.47,67.19 75.17,67.48 75.17,68.08 75.3,68.21 76.27,68.21 76.4,68.34 76.4,68.52 76.27,68.65 75.3,68.65 75.17,68.78 75.17,68.96 75.3,69.09 76.27,69.09 76.4,69.22 76.4,69.4 76.27,69.53 75.3,69.53 75.17,69.66 75.17,70.04 74.76,70.45 74.3,70.45 73.74,69.89 73.74,69.43 73.85,69.31 74.63,69.31 74.75,69.19 74.75,69.03 74.63,68.91 73.78,68.91 73.66,68.79 73.66,68.63 73.78,68.51 74.63,68.51 74.75,68.39 74.75,68.22 74.63,68.11 73.78,68.11 73.66,67.99 73.66,67.82 73.78,67.71 74.63,67.71 74.75,67.59 74.75,67.42 74.63,67.3 73.78,67.3 73.66,67.19 73.66,67.01 73.79,66.88 74.5,66.88 74.63,66.75 74.63,66.56 74.5,66.44 73.79,66.44 73.66,66.31 73.66,63.98 73.79,63.85 74.24,63.85 74.37,63.72 74.37,63.53 74.24,63.41 73.79,63.41 73.66,63.28 73.66,62.75 v1(75.69,60.72) R374.1
BOOTMODE11: length 59.2
  TOP w0.147: RA3.5 73.57,61.58 v1(74.42,60.72) 74.3,60.59 74.04,60.59 73.53,60.08 73.53,59.07 RA4.4 ; v1(65.97,62.37) 65.97,61.34 65.74,61.1 65,61.1 64.52,61.58 64.52,64.15 66.42,66.05 67.79,66.05 68.27,66.53 68.27,67.06 68.61,67.41 69,67.41 69.27,67.67 69.27,68.45 69.52,68.7 70.34,68.7 70.51,68.87 70.51,70.5 70.64,70.63 70.82,70.63 70.95,70.5 70.95,68.91 71.17,68.7 76.53,68.7 77.78,67.45 82.98,67.45 84.26,68.73 84.26,69.5 U23.W20
  BOTTOM w0.147: v1(65.97,62.37) 66.63,61.71 67.6,61.71 67.71,61.83 67.71,62.76 67.83,62.88 68,62.88 68.11,62.76 68.11,61.83 68.23,61.71 68.65,61.71 68.91,61.97 68.91,62.8 69.03,62.92 69.32,62.92 69.44,63.03 69.44,63.2 69.32,63.32 69.03,63.32 68.91,63.43 68.91,63.71 69.15,63.95 69.42,63.95 69.54,64.07 69.54,64.92 69.66,65.03 69.83,65.03 69.94,64.92 69.94,64.07 70.06,63.95 70.23,63.95 70.35,64.07 70.35,64.92 70.46,65.03 70.63,65.03 70.75,64.92 70.75,64.07 70.86,63.95 72.31,63.95 72.81,63.45 72.81,63.05 73.16,62.7 73.16,62.54 72.97,62.34 72.97,62.17 73.09,62.06 73.25,62.06 73.45,62.25 73.61,62.25 73.73,62.13 73.73,61.97 73.54,61.77 73.54,61.61 73.65,61.49 73.82,61.49 74.01,61.68 74.18,61.68 74.42,61.44 v1(74.42,60.72) R375.1
BOOTMODE12: length 58.2
  TOP w0.147: U23.W21 84.66,68.72 83.09,67.16 77.65,67.16 76.41,68.4 71.14,68.4 69,66.26 68.42,66.26 67.92,65.76 66.89,65.76 66.23,65.1 66.23,64.94 66.99,64.17 66.99,64.01 66.87,63.89 66.71,63.89 65.95,64.65 65.78,64.65 65.66,64.53 65.66,64.37 66.42,63.61 66.42,63.44 66.31,63.32 66.14,63.32 65.38,64.08 65.21,64.08 65.02,63.89 v1(65.02,62.5) ; RA4.5 73.03,59.07 73.03,60.6 v1(73.15,60.72) 73.15,61.23 73.07,61.32 RA3.4
  BOTTOM w0.147: v1(65.02,62.5) 65.02,63.57 64.76,63.83 64.16,63.83 64.02,63.68 64.02,62.71 65.31,61.42 68.77,61.42 69.34,61.99 69.62,61.99 69.73,62.11 69.73,63.53 69.85,63.65 70.02,63.65 70.14,63.53 70.14,62.11 70.25,61.99 70.42,61.99 70.54,62.11 70.54,63.53 70.65,63.65 70.82,63.65 70.94,63.53 70.94,63.26 71.06,63.14 71.33,63.14 71.45,63.26 71.45,63.54 71.56,63.66 71.73,63.66 71.85,63.54 71.85,63.26 71.97,63.14 72.35,63.14 72.47,63.02 72.47,62.85 72.35,62.74 71.99,62.74 71.87,62.62 71.87,62.38 71.76,62.27 71.59,62.27 71.47,62.38 71.47,62.62 71.35,62.74 71.06,62.74 70.94,62.62 70.94,62.11 71.28,61.76 71.47,61.76 71.6,61.63 71.6,61.33 71.73,61.2 71.91,61.2 72.04,61.33 72.04,61.63 72.17,61.76 72.62,61.76 73.15,61.23 v1(73.15,60.72) R376.1
BOOTMODE13: length 58.7
  TOP w0.147: RA4.6 72.53,59.07 72.53,60.07 v1(71.88,60.72) 72.57,61.4 RA3.3 ; U23.V18 v1(85.06,71.1)
  L08_SIG2 w0.091: v1(71.88,60.72) 70.87,61.74 70.87,62.56 70.96,62.65 71.3,62.65 71.39,62.56 71.39,61.8 71.48,61.71 71.64,61.71 71.74,61.8 71.74,62.56 71.83,62.65 71.99,62.65 72.08,62.56 72.08,61.8 72.17,61.71 72.33,61.71 72.43,61.8 72.43,62.56 72.52,62.65 73.28,62.65 73.37,62.74 73.37,62.91 73.28,63 70.96,63 70.87,63.09 70.87,63.25 70.96,63.34 73.28,63.34 73.37,63.44 73.37,63.6 73.28,63.69 73.09,63.69 72.99,63.78 72.99,63.88 72.9,63.97 72.74,63.97 72.65,63.88 72.65,63.78 72.56,63.69 72.4,63.69 72.3,63.78 72.3,63.88 72.21,63.97 72.05,63.97 71.96,63.88 71.96,63.78 71.87,63.69 71.7,63.69 71.61,63.78 71.61,63.88 71.52,63.97 71.36,63.97 71.27,63.88 71.27,63.78 71.18,63.69 70.96,63.69 70.87,63.78 70.87,64.96 70.96,65.06 71.11,65.06 71.2,65.15 71.2,65.31 71.11,65.4 70.96,65.4 70.87,65.49 70.87,66.24 70.96,66.33 72.16,66.33 72.25,66.43 72.25,66.59 72.16,66.68 70.96,66.68 70.87,66.77 70.87,67.42 71.11,67.66 73.26,67.66 73.35,67.57 73.35,66.64 73.45,66.55 73.61,66.55 73.7,66.64 73.7,67.57 73.79,67.66 73.95,67.66 74.04,67.57 74.04,66.64 74.14,66.55 74.3,66.55 74.39,66.64 74.39,67.57 74.48,67.66 74.72,67.66 75.2,67.18 75.2,66.38 75.38,66.2 75.9,66.2 76.01,66.09 76.01,65.23 76.1,65.13 76.26,65.13 76.35,65.23 76.35,66.09 76.45,66.18 76.61,66.18 76.7,66.09 76.7,65.23 76.79,65.13 76.95,65.13 77.05,65.23 77.05,66.09 77.14,66.18 77.3,66.18 77.39,66.09 77.39,65.23 77.48,65.13 77.64,65.13 77.74,65.23 77.74,66.09 77.83,66.18 81.66,66.18 83.06,67.58 83.06,71.01 83.06,71.01 83.06,71.27 83.29,71.5 84.66,71.5 v1(85.06,71.1)
  BOTTOM w0.147: R377.1 v1(71.88,60.72)
BOOTMODE14: length 59.9
  TOP w0.147: RA4.7 72.03,59.07 72.03,59.97 71.91,60.09 71.25,60.09 v1(70.61,60.72) 71.12,61.23 71.63,61.23 72.07,61.67 RA3.2 ; U23.Y21 83.86,68.75 82.86,67.75 80.71,67.75 80.58,67.88 80.58,68.83 80.45,68.96 80.27,68.96 80.14,68.83 80.14,67.88 80.01,67.75 79.82,67.75 79.69,67.88 79.69,68.83 79.57,68.96 79.38,68.96 79.25,68.83 79.25,67.88 79.12,67.75 77.9,67.75 76.66,68.99 72.87,68.99 71.83,70.03 71.83,70.99 71.48,71.35 69.89,71.35 69.75,71.2 69.75,70.99 70.05,70.69 70.05,69.81 68.27,68.03 68.27,67.67 68,67.41 66.76,67.41 66.27,66.92 66.27,66.53 66,66.26 65.6,66.26 65.49,66.15 65.49,65.92 65.37,65.8 65.2,65.8 65.08,65.92 65.08,66.15 64.97,66.26 64.69,66.26 64.13,65.7 64.13,65.53 64.68,64.98 64.68,64.81 64.56,64.69 64.4,64.69 63.84,65.25 63.68,65.25 63.43,65 63.43,64.6 63.55,64.49 63.98,64.49 64.1,64.37 64.1,64.2 63.98,64.08 63.58,64.08 63.43,63.94 63.43,63.11 63.72,62.82 v1(63.72,62.37)
  BOTTOM w0.147: R378.1 v1(70.61,60.72) 69.98,61.36 69.12,61.36 68.89,61.12 67.6,61.12 67.48,61.01 67.48,60.52 67.36,60.4 67.2,60.4 67.08,60.52 67.08,61.01 66.96,61.12 66.79,61.12 66.68,61.01 66.68,60.52 66.56,60.4 66.39,60.4 66.28,60.52 66.28,61.01 66.16,61.12 65.99,61.12 65.87,61.01 65.87,60.52 65.76,60.4 65.59,60.4 65.47,60.52 65.47,61.01 65.36,61.12 64.96,61.12 64.42,61.67 63.43,61.67 63.12,61.98 63.12,63.99 63.27,64.14 63.58,64.14 63.72,63.99 v1(63.72,62.37)
BOOTMODE15: length 61.2
  TOP w0.147: RA3.1 71.48,61.73 71.36,61.61 70.23,61.61 v1(69.34,60.72) 69.34,60.21 69.92,59.63 71.08,59.63 71.48,59.24 RA4.8 ; U23.Y20 83.46,69.5 83.46,68.75 82.79,68.09 81.94,68.09 81.79,68.23 81.79,69.14 81.59,69.34 72.94,69.34 72.57,69.71 72.57,72.57 72.44,72.7 70.13,72.7 70,72.83 70,73.01 70.13,73.14 72.18,73.14 72.31,73.27 72.31,73.68 72.17,73.83 71.4,73.83 71.19,74.04 71.19,74.73 71.07,74.85 70.9,74.85 70.78,74.73 70.78,74.04 70.67,73.92 70.5,73.92 70.38,74.04 70.38,74.73 70.27,74.85 70.1,74.85 69.98,74.73 69.98,74.18 69.86,74.07 69.35,74.07 69.02,73.73 69.02,73.25 68.87,73.1 68.43,73.1 68.31,72.98 68.31,72.82 68.43,72.7 68.9,72.7 69.02,72.58 69.02,72.42 68.9,72.3 68.43,72.3 68.31,72.18 68.31,72.01 68.43,71.9 68.9,71.9 69.03,71.76 69.03,69.94 67.41,68.32 66.63,68.32 66.27,67.96 66.27,67.67 66,67.41 65.36,67.41 63.14,65.18 63.14,61.49 63.41,61.22 v1(64.23,61.22)
  BOTTOM w0.147: R379.1 v1(69.34,60.72) 69.26,60.8 68.71,60.8 68.02,60.11 64.38,60.11 64.23,60.25 v1(64.23,61.22)
BOOTMODE_I2C_SCL: length 44
  TOP w0.147: v1(65.01,16.41) 64.25,16.41 64.14,16.29 TP43.1
  L08_SIG2 w0.091: v1(96.9,19.86) 96.34,19.3 96.34,18.68 92.19,14.53 79.68,14.53 74.48,19.74 67.73,19.74 65.66,17.67 65.66,17.06 v1(65.01,16.41)
  BOTTOM w0.147: v1(65.01,16.41) 65.13,16.29 R550.2 65.66,15.86 65.41,15.62 J38.37 ; U96.29 v1(96.9,19.86)
BOOTMODE_I2C_SDA: length 44.9
  TOP w0.147: v1(95.9,18.86) 96.36,18.4 96.65,18.4 TP42.1
  L08_SIG2 w0.091: v1(95.9,18.86) 91.75,14.72 79.76,14.72 74.56,19.92 66.51,19.92 63.56,16.96 v1(63.56,16.36)
  BOTTOM w0.147: v1(63.56,16.36) 64.26,16.36 R551.2 64.26,15.71 64.41,15.56 J38.39 ; v1(95.9,18.86) 96.4,19.36 U96.30
BOOTMODEON: length 74.7
  L03_SIG1 w0.091: v1(71.02,71.81) 71.02,68.86 72.42,67.46 74.89,67.46 77.93,64.42 78.08,64.32 78.28,64.13 78.38,63.98 79.25,63.11 79.25,62.5 v1(78.74,61.99)
  L08_SIG2 w0.091: v1(108.22,34.07) 106.28,34.07 103.87,36.48 93.46,36.48 81.33,48.6 80.68,48.6 78.44,50.85 78.44,58.26 78.74,58.56 v1(78.74,61.99)
  BOTTOM w0.147: v1(78.74,61.99) 79.25,61.48 79.25,59.07 78.28,58.1 76.88,58.1 76.68,57.9 U81.22 ; U79.22 69.31,72.74 69.49,72.92 70.79,72.92 71.02,72.69 v1(71.02,71.81) ; R454.1 R453.1 v1(108.22,34.07)
C1N: length 3.7
  BOTTOM w0.108: J36.11 5.87,20.81 5.97,20.92 7.39,20.92 7.68,21.21 8.29,21.21 C460.1
C1P: length 3.7
  BOTTOM w0.108: J36.12 5.87,21.31 5.97,21.21 7.27,21.21 7.56,21.5 8.29,21.5 C460.2
C2N: length 3.7
  BOTTOM w0.108: J36.13 5.87,21.81 5.97,21.92 6.43,21.92 6.9,22.39 6.9,23 7,23.11 7.53,23.11 C454.1
C2P: length 3.7
  BOTTOM w0.108: J36.14 5.87,22.31 5.97,22.21 6.31,22.21 6.61,22.51 6.61,23.12 6.88,23.4 7.53,23.4 C454.2
CAN_MUX_OE: length 2.1
  TOP w0.147: R23.1 41.66,119.65 v1(41.66,119.65)
  BOTTOM w0.147: U67.15 v1(41.66,119.65)
CAN_MUX_SEL: length 114.9
  TOP w0.147: v1(44.45,120.36) 45.02,120.36 45.11,120.27 R16.1
  L03_SIG1 w0.091: v1(56.47,29.73) 56.47,31.24 50.9,36.8 50.9,43.04 47.33,46.61 45.73,46.61 42.14,50.2 42.14,56.22 47.22,61.29 47.22,64.49 49.75,67.03 49.75,70.97 47.02,73.71 47.02,85.01 48.58,86.58 48.58,89.78 46.95,91.41 46.95,92.51 44.58,94.88 44.58,97.03 44.13,97.47 44.13,101.95 45.26,103.07 45.26,112.73 43.72,114.27 43.72,119.69 44.39,120.36 v1(44.45,120.36)
  BOTTOM w0.147: v1(56.47,29.73) 56.5,29.76 U91.2 ; v1(44.45,120.36) 45.09,120.36 45.14,120.3 U67.1
CAP_VDDS0: length 0.8
  TOP w0.147: U23.H12 v1(93.86,75.9)
  BOTTOM w0.254: C390.1 v1(93.86,75.9)
CAP_VDDS1: length 0.9
  TOP w0.147: U23.T7 v1(86.66,80.7)
  BOTTOM w0.254: v1(86.66,80.7) 86.73,80.77 C298.1
CAP_VDDS2: length 0.6
  TOP w0.147: U23.R11 v1(87.46,77.5)
CAP_VDDS3: length 0.8
  TOP w0.147: U23.N14 v1(89.06,74.3)
  BOTTOM w0.254: C357.1 v1(89.06,74.3)
CAP_VDDS4: length 0.6
  TOP w0.147: U23.M16 v1(89.86,72.7)
CAP_VDDS5: length 0.6
  TOP w0.147: U23.L13 v1(91.46,75.1)
CAP_VDDS_MCU: length 0.7
  TOP w0.147: U23.H10 v1(93.86,78.3)
  BOTTOM w0.147: v1(93.86,78.3) 93.87,78.31 C289.1
CDC_EEPROMSEL: length 8.5
  TOP w0.147: U105.23 48.42,53.96 47.14,52.68 44.53,52.68 43.64,53.58 43.64,54.1 R686.2 R687.1
CDC_OE1: length 1.6
  TOP w0.147: U105.20 48.4,55.46 v1(48.39,55.45)
  BOTTOM w0.147: R688.2 48.62,55.22 v1(48.39,55.45)
CDC_OE1/OE4: length 29.8
  TOP w0.147: v1(54.16,56) 53.62,55.46 U105.11
  TOP w0.229: R672.2 54.51,56 v1(54.16,56)
  L03_SIG1 w0.091: v1(54.16,56) 53.88,55.72 53.88,45.12 52.4,43.63 52.4,41.91 52.07,41.59 v1(52.07,37.48)
  BOTTOM w0.147: R688.1 49.21,56.2 49.69,56.67 52.34,56.67 53.01,56 v1(54.16,56) ; v1(52.07,37.48) 52.32,37.23 53.22,37.23 53.99,36.45 U91.18
CDC_OE2: length 2.8
  TOP w0.147: v1(48.06,56.98) 48.03,56.98 47.78,56.73 R660.2 47.38,56.69 48.1,55.96 U105.19
CDC_OE3: length 2.2
  TOP w0.147: U105.12 53.36,55.96 53.62,56.22 53.62,56.49 v1(53.99,56.85) 54.27,56.85 R659.2
CDC_REFSEL: length 1.8
  TOP w0.147: v1(51.68,51.86) 51.39,52.15 51.39,52.31 51.38,52.32 U105.4
  BOTTOM w0.147: R656.1 51.37,52.17 v1(51.68,51.86)
CDC_XIN: length 7.5
  TOP w0.147: U105.1 49.88,52.59 48.41,51.12 48.41,50.39 C532.2 48.29,49.98 48.29,47.73 48.01,47.45 Y4.2
CDC_XOUT: length 7.2
  TOP w0.147: U105.2 50.38,52.32 50.37,52.31 50.37,52.23 50.15,52.01 50.03,52.01 49.07,51.05 C533.2 48.92,49.98 48.92,47.73 49.2,47.45 Y4.1
CDC_Y0: length 2
  TOP w0.147: TP102.1 54.38,52.66 53.58,53.46 U105.7
CDC_Y1N: length 1.7
  TOP w0.119: U105.21 48.64,54.96 48.52,54.84 47.97,54.84 R653.1
CDC_Y1P: length 1.7
  TOP w0.119: U105.22 48.62,54.46 48.54,54.54 47.96,54.54 R652.1
CDC_Y4N: length 1.7
  TOP w0.119: R655.1 54.3,54.54 53.87,54.54 53.8,54.46 U105.9
CDC_Y4P: length 1.7
  TOP w0.119: U105.10 53.62,54.96 53.74,54.84 54.29,54.84 R654.1
CDCEL_XIN: length 5.6
  BOTTOM w0.147: R246.1 C235.2 66.71,107.82 R245.1 66.95,106.99 66.93,106.98 R255.2 67.53,105.79 67.53,105.79 R252.2
CDCEL_XIN_IN: length 3.5
  BOTTOM w0.147: U70.11 63.57,107.06 63.8,106.84 R246.2 C235.1
CLKGEN_REFCLK1N: length 52.5
  TOP w0.108: v1(44.46,55.15) 44.74,54.87 44.76,54.85 arc(44.79,54.84) 44.81,54.84 44.96,54.84 arc(45.07,54.86) 45.17,54.93 R682.1 45.8,54.89 arc(45.85,54.85) 45.91,54.84 46.45,54.84 arc(46.57,54.89) 46.63,55.02 R653.2
  L08_SIG2 w0.081: v1(44.46,55.15) 44.73,54.88 arc(44.76,54.86) 44.79,54.85 44.87,54.85 arc(45.01,54.88) 45.13,54.96 46.46,56.29 arc(46.74,56.71) 46.84,57.21 46.84,57.68 arc(46.88,57.92) 47.02,58.12 49.12,60.22 arc(49.71,61.1) 49.91,62.12 49.91,63.73 arc(50.07,64.52) 50.52,65.19 60.61,75.28 arc(60.91,75.48) 61.26,75.55 73.27,75.55 arc(73.7,75.46) 74.08,75.22 74.27,75.03 arc(74.37,74.95) 74.5,74.93 78.33,74.93 arc(79.01,74.65) 79.29,73.98 79.29,73.25 arc(79.4,72.97) 79.67,72.86 80.14,72.86 arc(80.2,72.88) 80.22,72.94 v1(80.22,73.39)
  BOTTOM w0.108: R661.2 v1(80.22,73.39)
CLKGEN_REFCLK1P: length 52.6
  TOP w0.108: R652.2 46.63,54.41 arc(46.59,54.51) 46.48,54.55 45.96,54.55 arc(45.86,54.53) 45.77,54.47 R681.1 45.17,54.46 arc(45.07,54.53) 44.96,54.55 44.81,54.55 arc(44.79,54.55) 44.76,54.54 44.74,54.52 v1(44.46,54.24)
  L08_SIG2 w0.081: v1(80.22,72.02) 80.22,72.46 arc(80.2,72.52) 80.14,72.54 79.67,72.54 arc(79.18,72.75) 78.97,73.25 78.97,73.98 arc(78.78,74.43) 78.33,74.61 74.5,74.61 arc(74.25,74.66) 74.04,74.8 73.85,74.99 arc(73.58,75.17) 73.27,75.23 61.26,75.23 arc(61.03,75.19) 60.84,75.06 50.74,64.96 arc(50.36,64.4) 50.23,63.73 50.23,62.12 arc(50,60.97) 49.35,60 47.24,57.89 arc(47.18,57.8) 47.16,57.68 47.16,57.21 arc(47.03,56.59) 46.68,56.06 45.36,54.74 arc(45.13,54.59) 44.87,54.54 44.79,54.54 arc(44.76,54.53) 44.73,54.51 v1(44.46,54.24)
  BOTTOM w0.108: R662.2 v1(80.22,72.02)
CLKGEN_REFCLK4N: length 53.3
  TOP w0.108: R667.2 26.83,38.1 arc(26.91,38.13) 26.94,38.21 26.94,38.49 arc(26.97,38.57) 27.05,38.6 27.56,38.6 arc(28.05,38.5) 28.47,38.23 28.96,37.74 arc(29.53,37.36) 30.2,37.23 35.9,37.23 arc(36.49,37.34) 37,37.68 37.37,38.05 arc(37.66,38.25) 38.02,38.32 56.29,38.32 arc(57.49,38.82) 57.99,40.02 57.99,40.12 arc(58,40.17) 58.02,40.2 v1(58.28,40.46) ; v1(57.8,54.24) 57.52,54.52 57.5,54.54 arc(57.47,54.55) 57.45,54.55 57.3,54.55 arc(57.19,54.53) 57.09,54.46 R684.1 56.5,54.47 arc(56.4,54.53) 56.3,54.55 55.78,54.55 arc(55.68,54.51) 55.63,54.41 R655.2
  L08_SIG2 w0.081: v1(58.28,40.46) 58.28,40.16 arc(58.1,39.98) 57.92,40.16 57.92,52.12 arc(57.82,52.58) 57.56,52.97 57.57,52.97 57.4,53.14 arc(57.28,53.31) 57.24,53.52 57.24,54.38 arc(57.28,54.49) 57.39,54.54 57.47,54.54 arc(57.5,54.53) 57.53,54.51 v1(57.8,54.24)
CLKGEN_REFCLK4P: length 52.2
  TOP w0.108: R654.2 55.63,55.02 arc(55.69,54.89) 55.81,54.84 56.35,54.84 arc(56.41,54.85) 56.46,54.89 R683.1 57.09,54.93 arc(57.19,54.86) 57.3,54.84 57.45,54.84 arc(57.47,54.84) 57.5,54.85 57.52,54.87 v1(57.8,55.15) ; v1(57.4,40.46) 57.67,40.2 arc(57.69,40.17) 57.7,40.12 57.7,40.02 arc(57.28,39.02) 56.29,38.61 38.02,38.61 arc(37.55,38.52) 37.16,38.25 36.79,37.88 arc(36.38,37.61) 35.9,37.52 30.2,37.52 arc(29.64,37.63) 29.16,37.95 28.68,38.43 arc(28.16,38.77) 27.56,38.89 27.05,38.89 arc(26.97,38.92) 26.94,39 26.94,39.29 arc(26.91,39.36) 26.83,39.4 R668.2
  L08_SIG2 w0.081: v1(57.8,55.15) 57.53,54.88 arc(57.5,54.86) 57.47,54.85 57.39,54.85 arc(57.06,54.71) 56.92,54.38 56.92,53.52 arc(56.99,53.19) 57.17,52.91 57.34,52.74 arc(57.53,52.46) 57.6,52.12 57.6,40.82 arc(57.57,40.67) 57.48,40.54 v1(57.4,40.46)
CLKOUT0: length 103.7
  TOP w0.147: R50.2 v1(63.5,104.15)
  L03_SIG1 w0.091: v1(63.5,104.15) 62.16,102.81 62.16,97.73 61.63,97.2 61.63,87.23 60.1,85.7 60.1,76.12 62.39,73.84 68.53,73.84 69.57,72.8 71.17,72.8 71.55,72.42 71.55,71.7 71.3,71.46 71.3,68.88 72.54,67.65 74.97,67.65 77.96,64.66 79.22,64.66 v1(79.72,65.16)
  L08_SIG2 w0.091: v1(79.72,65.16) 79.5,64.94 79.5,58.49 84.39,53.61 87.81,53.61 87.96,53.76 88.31,53.76 88.47,53.61 93.85,53.61 97.77,57.53 97.77,63.8 v1(97.38,64.19)
  BOTTOM w0.147: R345.2 100.46,68.7 97.38,65.62 v1(97.38,64.19) ; U70.13 63.37,106.06 63.82,105.61 63.82,104.48 v1(63.5,104.15) R50.2
CONN_MCU_PORZ: length 121
  TOP w0.147: R7.1 v1(168.67,124.87) ; U35.3 v1(126.1,51.83)
  L08_SIG2 w0.091: v1(126.1,51.83) 126.1,54.01 124.56,55.55 124.56,58.55 123.81,59.3 123.83,59.31 123.83,60.15 123.25,60.72 123.25,71.96 121.79,73.42 121.79,88.9 123.34,90.44 123.7,90.44 125.17,91.91 125.17,111.11 130.66,116.6 160.4,116.6 v1(168.67,124.87) 168.67,126.44 168.35,126.76 168.35,129.89 168.89,130.43 J1.24
CONN_MCU_RESETZ: length 153.7
  TOP w0.147: J1.21 166.24,127.78 R6.1 ; v1(130.81,27.19) 130.78,27.22 Q8.1
  L03_SIG1 w0.091: J1.21 162.05,123.59 162.05,107.26 172.93,96.38 172.93,82.06 174.37,80.62 174.37,38.75 171.51,35.89 162.59,35.89 161.39,34.7 149.85,34.7 147.83,36.72 135.13,36.72 131.12,32.71 131.12,27.5 v1(130.81,27.19)
CPSW_EARTH: length 0.9
  BOTTOM w0.254: R299.1 v1(14.85,91.58)
CPSW_ETH1_D0M: length 18.8
  TOP w0.108: J14.10 25.76,103.87 25.87,103.87 26.64,103.1 26.78,103.1 26.88,103.01 26.88,102.67 27.15,102.4 27.52,102.4 27.79,102.67 27.79,103.01 27.89,103.1 28.54,103.1 29.13,103.69 29.91,103.69 30.18,103.96 30.18,104.8 30.28,104.9 30.41,104.9 30.51,104.8 30.51,103.96 30.77,103.69 31.15,103.69 31.42,103.96 31.42,104.8 31.51,104.9 31.65,104.9 31.75,104.8 31.75,103.96 32.01,103.69 32.39,103.69 32.65,103.96 32.65,104.8 32.75,104.9 32.89,104.9 32.98,104.8 32.98,103.96 33.25,103.69 34.9,103.69 35.11,103.48 U15.2
CPSW_ETH1_D0P: length 18.8
  TOP w0.108: J14.11 24.89,104.87 25.6,104.16 25.99,104.16 26.76,103.39 26.9,103.39 27.17,103.13 27.17,102.79 27.27,102.69 27.4,102.69 27.5,102.79 27.5,103.13 27.77,103.39 28.42,103.39 29.01,103.98 29.79,103.98 29.89,104.08 29.89,104.92 30.16,105.19 30.53,105.19 30.8,104.92 30.8,104.08 30.89,103.98 31.03,103.98 31.13,104.08 31.13,104.92 31.39,105.19 31.77,105.19 32.04,104.92 32.04,104.08 32.13,103.98 32.27,103.98 32.36,104.08 32.36,104.92 32.63,105.19 33.01,105.19 33.27,104.92 33.27,104.08 33.37,103.98 U15.1
CPSW_ETH1_D1M: length 18.8
  TOP w0.108: U15.5 35.11,101.98 35.01,102.09 32.29,102.09 31.79,102.6 30.53,102.6 30.35,102.42 v1(30.35,102.31)
  BOTTOM w0.108: v1(30.35,102.31) 30.35,102.58 30.46,102.69 30.95,102.69 31.28,103.01 31.28,103.54 30.72,104.09 29.02,104.09 26.83,101.9 24.38,101.9 23.03,103.25 22.93,103.25 22.35,103.82 J14.5
CPSW_ETH1_D1P: length 18.8
  TOP w0.108: U15.4 35.11,102.48 35.01,102.38 32.41,102.38 31.91,102.88 30.63,102.88 v1(30.35,103.17)
  BOTTOM w0.108: J14.4 21.79,102.55 21.79,102.83 21.92,102.96 22.91,102.96 24.26,101.61 26.95,101.61 29.14,103.8 30.6,103.8 30.99,103.42 30.99,103.13 30.83,102.98 30.54,102.98 v1(30.35,103.17)
CPSW_ETH1_D2M: length 18.7
  TOP w0.108: J14.2 22.35,98.69 22.46,98.8 23.09,98.8 24.88,100.59 25.8,100.59 25.89,100.49 25.89,100.02 26.16,99.75 26.53,99.75 26.8,100.02 26.8,100.49 26.9,100.59 27.03,100.59 27.13,100.49 27.13,100.02 27.39,99.75 27.77,99.75 28.04,100.02 28.04,100.49 28.13,100.59 28.27,100.59 28.37,100.49 28.37,100.02 28.63,99.75 29.01,99.75 29.27,100.02 29.27,100.49 29.37,100.59 35.01,100.59 35.11,100.48 U15.8
CPSW_ETH1_D2P: length 18.7
  TOP w0.108: U15.7 35.11,100.98 35.01,100.88 29.25,100.88 28.98,100.61 28.98,100.14 28.89,100.04 28.75,100.04 28.66,100.14 28.66,100.61 28.39,100.88 28.01,100.88 27.75,100.61 27.75,100.14 27.65,100.04 27.51,100.04 27.42,100.14 27.42,100.61 27.15,100.88 26.78,100.88 26.51,100.61 26.51,100.14 26.41,100.04 26.28,100.04 26.18,100.14 26.18,100.61 25.92,100.88 24.76,100.88 22.97,99.09 22.49,99.09 22.35,99.22 J14.3
CPSW_ETH1_D3M: length 18.9
  TOP w0.108: v1(30.35,98.03) 30.63,98.31 31.78,98.31 32.55,99.09 35.01,99.09 35.11,98.98 U15.11
  BOTTOM w0.108: J14.9 25.02,98.95 25.14,98.83 25.14,98.28 24.84,97.98 24.08,97.98 23.81,98.26 23.81,99.42 24.35,99.96 25.22,99.96 25.49,100.23 25.49,100.67 25.59,100.77 25.72,100.77 25.82,100.67 25.82,100.23 26.08,99.96 28.42,99.96 28.71,99.68 28.71,98.8 29.09,98.41 30.25,98.41 30.35,98.31 v1(30.35,98.03)
CPSW_ETH1_D3P: length 18.9
  TOP w0.108: U15.10 35.11,99.48 35.01,99.38 32.43,99.38 31.66,98.6 30.63,98.6 v1(30.35,98.88)
  BOTTOM w0.108: v1(30.35,98.88) 30.17,98.7 29.21,98.7 29,98.92 29,99.8 28.54,100.25 26.2,100.25 26.11,100.35 26.11,100.79 25.84,101.06 25.47,101.06 25.2,100.79 25.2,100.35 25.1,100.25 24.23,100.25 23.52,99.54 23.52,98.14 23.97,97.68 24.41,97.68 24.89,97.2 J14.8
CPSW_ETH1_GPIO_0: length 23
  TOP w0.147: U15.39 40.99,105.27 41.91,106.19 R41.2 41.91,106.51 42.51,106.51 v1(42.59,106.43)
  BOTTOM w0.147: R41.2 41.92,106.43 v1(42.59,106.43) 43.04,106.88 43.04,107.72 42.67,108.09 38.99,108.09 38.23,108.85 34.04,108.85 29.34,113.55 29.34,114.44 29.21,114.57 R230.2
CPSW_ETH1_GPIO_1: length 5.6
  TOP w0.147: R36.1 R35.2 41.02,107.93 41.32,107.64 41.32,106.1 41.08,105.87 40.83,105.87 40.49,105.53 U15.40
CPSW_ETH1_LED0: length 4
  TOP w0.147: TP9.1 36.2,105.42 36.76,105.42 36.99,105.18 U15.47
CPSW_ETH1_LED1: length 4.2
  BOTTOM w0.147: 31.37,95.06 30.4,95.06 29.97,94.63 28.81,94.63 28.56,94.88 J14.13
CPSW_ETH1_LED2: length 7.2
  BOTTOM w0.147: J14.16 26.33,108.17 Q12.3 R234.1
CPSW_ETH1_LED3: length 7.6
  TOP w0.147: J14.15 28.97,106.06 30.1,106.06 30.95,106.91 R37.1 31.17,108.81 Q3.3
CPSW_ETH1_LED_1000: length 9.4
  TOP w0.147: U15.46 37.49,105.18 37.42,105.25 37.42,105.26 37.26,105.42 37.25,105.42 36.98,105.69 36.97,105.69 36.96,105.71 36.89,105.71 36.79,105.81 36.7,105.81 35.94,106.57 R32.2 R31.1 33.64,109.13 33.43,109.34 R30.2
CPSW_ETH1_LED_ACT: length 24
  TOP w0.147: v1(39.12,109.11) 38.37,109.11 R34.1 R33.2 37.17,109.13 36.32,108.28 36.32,106.69 37.01,106 37.08,106 37.09,105.99 37.18,105.99 37.22,105.94 37.33,105.94 37.92,105.35 37.92,105.26 37.92,105.26 37.92,104.8 U15.45
  L03_SIG1 w0.091: v1(39.12,109.11) 36.45,109.11 35.38,108.04 35.38,98.38 34.73,97.74 v1(34.73,96.6)
  BOTTOM w0.147: R286.1 v1(34.73,96.6)
CPSW_FET_EN: length 1.7
  BOTTOM w0.147: R278.2 55.22,96.27 54.96,96.53 U75.8
CPSW_FET_SEL: length 91.3
  L03_SIG1 w0.091: v1(51.07,32.41) 50.81,32.68 50.56,32.68 48.95,34.29 48.95,40.54 44.65,44.83 42.85,44.83 40.13,47.55 40.13,57.48 41.56,58.91 41.56,61.45 42.45,62.34 42.45,71.48 41.71,72.23 41.71,73.32 41.84,73.45 41.84,88.85 41.91,88.92 v1(41.91,89.3)
  BOTTOM w0.147: U75.9 54.86,96.03 54.99,95.9 54.99,95.65 ; 54.99,95.65 54.86,95.52 54.16,95.52 U75.10 ; 54.99,95.65 55.17,95.65 55.77,95.05 R292.1 55.77,94.01 56.55,93.23 57.28,93.23 57.66,92.85 57.66,91.24 56.03,89.61 52.25,89.61 51.28,90.58 49.45,90.58 48.9,90.02 44.98,90.02 44.68,90.32 42.94,90.32 v1(41.91,89.3) ; U91.11 v1(51.07,32.41)
CPSW_RGMII1_ETH1_CLK: length 35.9
  TOP w0.147: v1(34.23,93.68) 34.09,93.83 C501.1
  L08_SIG2 w0.091: v1(34.23,93.68) 34.23,94.58 38.35,98.7 38.35,103.65 39.61,104.9 46.41,104.9 53.25,111.74 56.35,111.74 v1(57.4,112.79)
  BOTTOM w0.147: R239.2 v1(57.4,112.79)
CPSW_RGMII1_ETH1_CLK_OUT: length 4.3
  TOP w0.147: TP16.1 39.54,94.42 39.54,96.49 38.99,97.04 38.99,97.73
CPSW_RGMII1_ETH1_RBIAS: length 1.3
  TOP w0.147: U15.12 R70.1
CPSW_RGMII1_MDC: length 81.6
  TOP w0.147: U23.R2 v1(87.46,84.7) ; U27.7 51.18,86.71 v1(50.7,87.2) 50.7,86.69 49.1,85.09 47.47,85.09 45.8,86.77 45.8,89.53 45.14,90.2 42.24,90.2 40.59,91.85 38.07,91.85 37.13,92.79 37.13,93.95 36.65,94.44 36.47,94.44 35.97,94.95 35.97,95.5 36.6,96.14 R81.2 37.38,96.14 37.99,96.75 U15.16
  BOTTOM w0.147: v1(50.7,87.2) 50.22,86.72 50.22,86 53.52,82.7 60.83,82.7 61.21,83.08 61.21,83.34 60.76,83.79 56.34,83.79 56.01,84.12 56.01,84.33 56.29,84.61 70.25,84.61 71.38,85.75 73,85.75 TP64.1 74.05,84.7 v1(87.46,84.7)
CPSW_RGMII1_MDIO: length 65.9
  TOP w0.147: U15.17 38.49,96.72 38.48,96.71 R79.1 38.95,96.19 39.17,95.98 39.17,95.02 38.33,94.18 38.33,93.04 39.09,92.28 40.61,92.28 41.38,91.52 43.59,91.52 44.15,92.08 46.33,92.08 49.96,88.44 v1(49.96,87.33) 49.51,87.33 49.4,87.21 U27.3 ; U23.P5 v1(88.26,82.3)
  BOTTOM w0.114: v1(88.26,82.3) 88.66,82.7 88.66,84.46 88.14,84.98
  BOTTOM w0.147: v1(49.96,87.33) 49.96,87.43 50.22,87.68 55.7,87.68 57.67,85.71 70.37,85.71 TP20.1 70.89,86.23 86.88,86.23 88.14,84.98
CPSW_RGMII1_RD0: length 17.4
  TOP w0.147: U15.33 44.01,102.48 R56.2 44.38,102.81 45.12,102.07 46.86,102.07 v1(47.19,102.39) 47.14,102.45 R54.1
  BOTTOM w0.147: v1(47.19,102.39) 47.19,102.85 47.14,102.9 47.14,103.16 47.5,103.52 49.47,103.52 49.58,103.64 49.58,104.11 49.7,104.23 49.87,104.23 49.98,104.11 49.98,103.64 50.1,103.52 50.27,103.52 50.39,103.64 50.39,104.24 50.5,104.35 50.67,104.35 50.79,104.24 50.79,103.64 50.9,103.52 52.2,103.52 52.7,103.02 U75.41
CPSW_RGMII1_RD1: length 16.5
  TOP w0.147: U15.34 v1(43.53,102.98)
  BOTTOM w0.147: U75.39 51.7,101.35 51.18,101.87 50.61,101.87 50.49,101.99 50.49,103 50.38,103.12 50.21,103.12 50.09,103 50.09,101.99 49.98,101.87 49.81,101.87 49.69,101.99 49.69,103 49.57,103.12 49.41,103.12 49.29,103 49.29,101.99 49.17,101.87 48.26,101.87 48.14,101.99 48.14,102.68 48.02,102.8 47.85,102.8 47.74,102.68 47.74,101.99 47.62,101.87 46.1,101.87 44.99,102.98 v1(43.53,102.98)
CPSW_RGMII1_RD2: length 16.6
  TOP w0.147: 47.14,104.12 R51.2 ; 47.14,104.12 47.14,104.68 47.37,104.92 48.77,104.92 49.91,103.77 49.91,102.41 49.79,102.3 49.26,102.3 49.14,102.18 49.14,102.01 49.26,101.9 49.79,101.9 49.91,101.78 49.91,101.61 49.79,101.49 49.26,101.49 49.14,101.38 49.14,101.21 49.26,101.09 49.79,101.09 49.91,100.98 v1(49.91,100.09) ; 47.14,104.12 46.47,104.79 44.58,104.79 44.34,104.55 R52.1 43.81,103.96 43.33,103.48 U15.35
  BOTTOM w0.147: v1(49.91,100.09) 49.98,100.03 U75.38
CPSW_RGMII1_RD3: length 16.6
  TOP w0.147: v1(49.91,99.09) 50.37,99.55 50.37,100.29 50.48,100.41 50.56,100.41 50.68,100.53 50.68,100.69 50.56,100.81 50.48,100.81 50.37,100.93 50.37,101.09 50.48,101.21 50.64,101.21 50.76,101.33 50.76,101.49 50.64,101.61 50.48,101.61 50.37,101.73 50.37,101.9 50.48,102.01 50.64,102.01 50.76,102.13 50.76,102.3 50.64,102.41 50.48,102.41 50.37,102.53 50.37,102.7 50.48,102.82 50.64,102.82 50.76,102.93 50.76,103.1 50.64,103.22 50.48,103.22 50.37,103.33 50.37,103.83 48.9,105.3 44.26,105.3 43.5,104.53 43.5,104.34 43.14,103.98 U15.36
  BOTTOM w0.147: U75.36 49.98,99.03 v1(49.91,99.09)
CPSW_RGMII1_RESETN: length 12.4
  TOP w0.147: v1(39.9,108.6) 38.99,108.6 38.23,107.84 38.23,105.99 38.99,105.22 38.99,104.73
  BOTTOM w0.147: v1(39.9,108.6) 42.04,108.6 43.05,109.62 R240.1 43.65,111.16 43.66,111.14 U69.4
CPSW_RGMII1_RX_CTL: length 19.4
  TOP w0.147: U15.38 41.49,105.26 41.97,105.74 v1(42.8,105.74) 43.25,105.74 43.64,106.13 R39.1
  BOTTOM w0.147: U75.34 49.89,98.03 49.39,98.53 48.6,98.53 48.12,98.04 46.99,98.04 46.61,98.42 46.61,101.09 46.34,101.36 45.83,101.36 44.69,102.5 43.33,102.5 42.8,103.03 v1(42.8,105.74) 43.25,105.74 43.43,105.93 43.43,106.26 R39.1
CPSW_RGMII1_RXC: length 16.9
  TOP w0.147: v1(44.56,101.76) 44.34,101.98 U15.32
  BOTTOM w0.147: v1(44.56,101.76) 44.56,101.3 44.45,101.2 44.45,100.12 44.33,100 43.27,100 43.15,99.88 43.15,99.72 43.27,99.6 44.33,99.6 44.45,99.48 44.45,99.32 44.33,99.2 43.27,99.2 43.15,99.08 43.15,98.91 43.27,98.8 44.33,98.8 44.45,98.68 44.45,98.19 45.12,97.51 49.22,97.51 49.71,97.03 U75.32
CPSW_RGMII1_TD0: length 67.9
  TOP w0.147: v1(69.7,86.2) 68.3,86.2 68.16,86.34 68.16,86.55 68.81,87.21 68.81,87.42 68.61,87.63 68.4,87.63 67.74,86.97 67.53,86.97 67.32,87.18 67.32,87.39 67.98,88.05 67.98,88.25 67.77,88.46 67.56,88.46 66.91,87.8 66.7,87.8 65.54,88.96 63.88,88.96 63.73,88.81 63.73,88.29 63.58,88.14 63.29,88.14 63.14,88.29 63.14,88.81 62.99,88.96 59.1,88.96 58.95,89.11 58.95,89.77 58.8,89.92 58.51,89.92 58.36,89.77 58.36,89.11 58.21,88.96 57.29,88.96 57.21,89.04 57.21,89.25 57.57,89.61 57.57,89.82 57.36,90.03 57.16,90.03 56.79,89.67 56.58,89.67 56.38,89.88 56.38,90.09 56.74,90.45 56.74,90.66 56.53,90.87 56.32,90.87 55.96,90.5 55.75,90.5 54.28,91.97 52.37,91.97 51.38,92.96 51.38,93.62 47.58,97.42 44.61,97.42 44.02,98.02 44.02,99.2 43.82,99.4 43.82,99.59 43.43,99.98 U15.28 ; U23.V15 v1(85.06,73.5)
  L03_SIG1 w0.091: v1(85.06,73.5) 85.04,73.49 84.84,73.49 84.43,73.08 83.3,73.08 83.13,72.9 82.74,72.9 81.21,74.43 79.63,74.43 78.94,75.11 77.55,75.11 74.39,78.27 74.39,82.96 72.07,85.29 70.61,85.29 v1(69.7,86.2)
CPSW_RGMII1_TD1: length 68.5
  TOP w0.147: v1(70.86,87.18) 70.86,86.71 69.89,85.74 68.24,85.74 66.54,87.44 65.04,87.44 64.9,87.59 64.9,88.47 64.75,88.62 64.45,88.62 64.31,88.47 64.31,87.59 64.16,87.44 62.02,87.44 61.9,87.56 61.9,88.55 61.79,88.67 61.35,88.67 61.2,88.52 61.2,87.6 61.05,87.45 60.76,87.45 60.61,87.6 60.61,88.52 60.46,88.67 60.17,88.67 60.02,88.52 60.02,87.6 59.87,87.45 59.58,87.45 59.43,87.6 59.43,88.52 59.28,88.67 57.05,88.67 54.05,91.67 52.25,91.67 50.17,93.75 50.17,94.42 49.36,95.23 47.97,95.23 47.83,95.38 47.83,96.09 47.68,96.24 47.38,96.24 47.24,96.09 47.24,95.38 47.09,95.23 46.05,95.23 45.9,95.37 45.9,95.58 46.23,95.91 46.23,96.12 46.02,96.32 45.81,96.32 45.48,96 45.28,96 44.52,96.75 44.52,97.1 43.72,97.9 43.72,99.02 43.25,99.48 U15.27 ; U23.V14 v1(85.06,74.3)
  L03_SIG1 w0.091: v1(70.86,87.18) 71.9,87.18 75.34,83.74 75.34,78.91 76.51,77.74 77.3,77.74 78.97,76.07 79.27,76.07 79.96,75.39 82.11,75.39 82.48,75.02 83.78,75.02 84.09,74.71 84.66,74.71 v1(85.06,74.3)
CPSW_RGMII1_TD2: length 67.9
  TOP w0.147: v1(68.88,85.08) 68.15,85.08 66.49,86.74 65.89,86.74 65.77,86.85 65.77,87.03 65.65,87.15 65.49,87.15 65.37,87.03 65.37,86.85 65.25,86.74 65.09,86.74 64.97,86.85 64.97,87.03 64.85,87.15 64.69,87.15 64.57,87.03 64.57,86.85 64.45,86.74 64.28,86.74 64.17,86.85 64.17,87.03 64.05,87.15 63.88,87.15 63.77,87.03 63.77,86.85 63.65,86.74 63.48,86.74 63.36,86.85 63.36,87.03 63.25,87.15 63.08,87.15 62.96,87.03 62.96,86.85 62.85,86.74 62.68,86.74 62.56,86.85 62.56,87.03 62.44,87.15 62.28,87.15 62.16,87.03 62.16,86.85 62.04,86.74 61.88,86.74 61.76,86.85 61.76,87.03 61.64,87.15 61.48,87.15 61.36,87.03 61.36,86.85 61.24,86.74 61.07,86.74 60.96,86.85 60.96,87.03 60.84,87.15 60.67,87.15 60.56,87.03 60.56,86.85 60.44,86.74 58.98,86.74 58.84,86.88 58.84,87.99 58.69,88.14 58.39,88.14 58.25,87.99 58.25,86.88 58.1,86.74 57.86,86.74 57.75,86.85 57.75,87.34 53.8,91.29 52.02,91.29 49.18,94.13 46.68,94.13 46.55,94.26 46.55,94.59 46.42,94.72 46.24,94.72 46.11,94.59 46.11,94.26 45.98,94.13 45.35,94.13 43.43,96.05 43.43,98.82 43.26,98.98 U15.26 ; U23.W14 v1(84.26,74.3)
  L03_SIG1 w0.091: v1(68.88,85.08) 68.62,85.34 68.62,87.16 69.1,87.64 69.77,87.64 70.71,86.71 71.77,86.71 75.12,83.35 75.12,78.57 77.85,75.84 79.24,75.84 79.93,75.16 82.06,75.16 82.4,74.82 83.51,74.82 84.02,74.3 v1(84.26,74.3)
CPSW_RGMII1_TD3: length 67.9
  TOP w0.147: U23.AA14 81.49,74.7 80.77,73.99 v1(80.62,73.99) ; U15.25 42.96,98.48 43.13,98.31 43.13,95.93 45.23,93.83 47.58,93.83 47.69,93.71 47.69,93.32 47.81,93.21 47.98,93.21 48.1,93.32 48.1,93.71 48.21,93.83 49.06,93.83 49.58,93.31 49.58,92.61 49.58,92.37 50.99,90.96 53.52,90.96 57.2,87.28 57.2,86.03 57.31,85.91 57.48,85.91 57.6,86.03 57.6,86.32 57.71,86.44 57.88,86.44 58,86.32 58,86.03 58.12,85.91 58.28,85.91 58.4,86.03 58.4,86.32 58.52,86.44 58.68,86.44 58.8,86.32 58.8,86.03 58.92,85.91 59.08,85.91 59.2,86.03 59.2,86.32 59.32,86.44 59.49,86.44 59.6,86.32 59.6,86.03 59.72,85.91 59.89,85.91 60.01,86.03 60.01,86.32 60.12,86.44 60.29,86.44 60.41,86.32 60.41,86.03 60.52,85.91 60.69,85.91 60.81,86.03 60.81,86.32 60.93,86.44 61.09,86.44 61.21,86.32 61.21,86.03 61.33,85.91 61.49,85.91 61.61,86.03 61.61,86.32 61.73,86.44 61.89,86.44 62.01,86.32 62.01,86.03 62.13,85.91 62.3,85.91 62.41,86.03 62.41,86.32 62.53,86.44 62.7,86.44 62.81,86.32 62.81,86.03 62.93,85.91 63.1,85.91 63.22,86.03 63.22,86.32 63.33,86.44 63.5,86.44 63.62,86.32 63.62,86.03 63.73,85.91 63.9,85.91 64.02,86.03 64.02,86.32 64.14,86.44 64.3,86.44 64.42,86.32 64.42,86.03 64.54,85.91 64.7,85.91 64.82,86.03 64.82,86.32 64.94,86.44 65.1,86.44 65.22,86.32 65.22,86.03 65.34,85.91 65.51,85.91 65.62,86.03 65.62,86.32 65.74,86.44 65.91,86.44 66.02,86.32 66.02,86.03 66.14,85.91 66.88,85.91 68.38,84.42 69.55,84.42 69.7,84.57 v1(69.7,85.16)
  L03_SIG1 w0.091: v1(80.62,73.99) 78.41,73.99 74.21,78.19 74.21,82.81 73.42,83.61 73.29,83.61 72.91,83.23 72.78,83.23 72.65,83.36 72.65,83.49 73.03,83.86 73.03,83.99 71.92,85.1 70.12,85.1 70.07,85.16 v1(69.7,85.16)
CPSW_RGMII1_TX_CTL: length 68.2
  TOP w0.147: U23.U15 v1(85.86,73.5) ; v1(69.01,88.35) 67.96,89.41 59.97,89.41 51.05,98.32 51.05,103.66 49.03,105.68 43.69,105.68 42.74,104.73 U15.37
  L03_SIG1 w0.091: v1(69.01,88.35) 68.3,87.65 68.3,84.24 69.22,83.33 71.63,83.33 73.46,81.49 73.46,78.53 75.62,76.37 75.62,75.44 77.83,73.23 78.84,73.23 79.58,72.49 81.83,72.49 82.01,72.31 84.45,72.31 84.68,72.54 84.68,72.86 84.9,73.09 85.18,73.09 85.43,73.33 85.69,73.33 v1(85.86,73.5)
CPSW_RGMII1_TXC: length 67.8
  TOP w0.147: U15.29 v1(43.53,100.48) ; U23.U14 v1(85.86,74.3)
  L03_SIG1 w0.091: v1(85.86,74.3) 85.45,73.9 82.82,73.9 81.93,74.79 79.78,74.79 79.09,75.48 77.7,75.48 74.76,78.42 74.76,83.16 71.57,86.34 70.4,86.34 v1(69.72,87.02)
  L08_SIG2 w0.091: v1(43.53,100.48) 43.53,95.91 45.21,94.23 49.78,94.23 55.63,88.39 57.01,88.39 57.1,88.48 57.1,89.32 57.19,89.41 57.38,89.41 57.47,89.32 57.47,88.48 57.56,88.39 57.74,88.39 57.83,88.48 57.83,89.32 57.92,89.41 58.11,89.41 58.2,89.32 58.2,88.48 58.29,88.39 58.47,88.39 58.56,88.48 58.56,89.32 58.66,89.41 58.84,89.41 58.93,89.32 58.93,88.48 59.02,88.39 59.2,88.39 59.3,88.48 59.3,89.44 59.39,89.53 59.57,89.53 59.66,89.44 59.66,88.48 59.75,88.39 61.09,88.39 62.46,87.02 v1(69.72,87.02)
CPSW_RGMII_INTN: length 4.4
  TOP w0.147: U15.44 38.49,105.21 37.85,105.86 37.85,106.22 37.6,106.46 R42.1 37.06,106.46 36.83,106.69 v1(36.83,107.2)
  BOTTOM w0.147: R250.2 37,107.44 36.83,107.27 v1(36.83,107.2)
CTI_TCK: length 26.4
  TOP w0.147: U60.3 v1(98.2,12.78) ; R195.1 v1(78.11,21.74)
  L03_SIG1 w0.091: v1(78.11,21.74) 81.42,18.43 93.44,18.43 97.76,14.11 97.76,13.89 98.2,13.46 v1(98.2,12.78)
DDR_A0: length 47.6
  TOP w0.216: U13.P3 v1(89.61,99.35) ; U23.D2 v1(97.06,84.7)
  L03_SIG1 w0.147: v1(89.61,99.35) 90.01,99.75 90.01,100.53 90.14,100.66 90.66,100.66 90.81,100.52 90.81,97.55 92.2,96.15 95.72,96.15 97.13,97.56 97.13,101.36 97.38,101.62 97.69,101.62 97.8,101.51 97.8,100.64 97.91,100.53 98.06,100.53 98.17,100.64 98.17,101.51 98.28,101.62 99.5,101.62 99.6,101.51 99.6,100.76 99.71,100.65 99.86,100.65 99.97,100.76 99.97,101.51 100.08,101.62 100.24,101.62 100.52,101.33 100.52,100.13 101.02,99.64 101.02,95 99.56,93.55 99.56,88.14 97.06,85.63 v1(97.06,84.7)
  BOTTOM w0.114: v1(89.61,99.35) 89.03,98.78 89.03,97.04 88.7,96.72 R289.1
DDR_A1: length 48.6
  TOP w0.114: v1(92,99.35) 91.24,98.59 91.24,97.75 91.95,97.04 92.46,97.04 93.09,96.41 93.09,96.19
  TOP w0.216: v1(92,99.35) U13.P7 ; U23.C5 v1(97.86,82.3)
  TOP w0.23: 93.09,96.19 93.27,96.01 R90.1
  L03_SIG1 w0.147: v1(97.86,82.3) 97.86,82.54 98.26,82.94 98.26,83.27 98.49,83.5 98.82,83.5 99.06,83.74 99.06,84.07 99.29,84.3 99.63,84.3 101.14,85.81 101.14,92.93 102.59,94.39 102.59,103.91 102.3,104.2 98.39,104.2 98.28,104.09 98.28,103.91 98.18,103.81 98.02,103.81 97.91,103.91 97.91,104.09 97.81,104.2 97.65,104.2 97.55,104.09 97.55,103.91 97.44,103.81 97.29,103.81 97.18,103.91 97.18,104.09 97.07,104.2 96.92,104.2 96.81,104.09 96.81,103.91 96.7,103.81 96.55,103.81 96.44,103.91 96.44,104.09 96.33,104.2 96.07,104.2 95.31,103.44 95.31,98.77 94.69,98.15 92.93,98.15 92.5,98.58 92.5,98.86 v1(92,99.35)
DDR_A2: length 46.6
  TOP w0.114: 89.54,97.04 89.92,97.42 89.93,97.42 90.04,97.54 90.04,98.12 v1(89.61,98.55)
  TOP w0.216: U23.E2 v1(96.26,84.7) ; v1(89.61,98.55) U13.R3
  TOP w0.23: R86.1 88.7,96.21 89.54,97.04
  L03_SIG1 w0.147: v1(89.61,98.55) 90.11,99.06 90.3,99.06 90.45,98.92 90.45,97.36 92.13,95.68 96.04,95.68 97.6,97.24 97.6,98.38 97.71,98.48 98,98.48 98.11,98.59 98.11,98.74 98,98.85 97.71,98.85 97.6,98.96 97.6,99.11 97.71,99.22 98,99.22 98.11,99.33 98.11,99.48 98,99.59 97.71,99.59 97.6,99.7 97.6,100.04 97.75,100.19 99.94,100.19 100.65,99.49 100.65,95.15 99.17,93.67 99.17,93.33 99.06,93.22 98.22,93.22 98.11,93.11 98.11,92.96 98.22,92.85 99.06,92.85 99.17,92.75 99.17,92.59 99.06,92.49 98.22,92.49 98.11,92.38 98.11,92.23 98.22,92.12 99.06,92.12 99.17,92.01 99.17,89.87 99.06,89.76 98.5,89.76 98.39,89.65 98.39,89.5 98.5,89.39 99.06,89.39 99.17,89.28 99.17,89.13 99.06,89.02 98.5,89.02 98.39,88.92 98.39,88.76 98.5,88.66 99.06,88.66 99.17,88.55 99.17,88.26 98.82,87.92 98.16,87.92 97.92,87.68 97.92,86.86 96.66,85.6 96.66,85.11 v1(96.26,84.7)
DDR_A3: length 48.6
  TOP w0.114: 91.75,96.66 90.93,97.48 90.93,99.08 v1(92,100.15)
  TOP w0.216: v1(92,100.15) U13.N7 ; U23.D4 v1(97.06,83.1)
  TOP w0.23: 91.75,96.66 91.82,96.66 92.47,96.01 R89.1
  L03_SIG1 w0.147: v1(92,100.15) 91.6,99.75 91.6,98 92.56,97.04 94.88,97.04 96.09,98.25 96.09,101.74 96.89,102.55 97.21,102.55 97.32,102.65 97.32,102.95 97.43,103.06 97.58,103.06 97.69,102.95 97.69,102.65 97.8,102.55 97.95,102.55 98.06,102.65 98.06,102.95 98.17,103.06 98.32,103.06 98.43,102.95 98.43,102.65 98.53,102.55 98.69,102.55 98.79,102.65 98.79,102.95 98.9,103.06 99.05,103.06 99.16,102.95 99.16,102.65 99.27,102.55 100.03,102.55 100.3,102.81 101.39,102.81 101.8,102.4 101.8,94.64 100.3,93.13 100.3,86.24 99.97,85.9 98.42,85.9 98.26,85.74 98.26,84.54 98.02,84.3 97.69,84.3 97.46,84.07 97.46,83.63 97.2,83.38 97.2,83.37 97.06,83.23 v1(97.06,83.1)
