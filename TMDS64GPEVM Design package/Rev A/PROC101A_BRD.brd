# Allegro board PROC101A_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N28118245: length 2.6
  TOP w0.147: LD2.1 159.55,124.66 158.75,123.86 Q2.3
N28118248: length 2.3
  TOP w0.147: LD3.1 123.01,124 123.8,123.2 Q1.3
N28118251: length 3.3
  TOP w0.381: LD10.1 7.63,61.95 7.2,61.52 Q7.3
N28118254: length 2.9
  TOP w0.147: Q6.3 136.81,64.44 137.32,64.95 LD8.1
N28118257: length 3.2
  TOP w0.147: LD1.1 28.9,126.25 28.78,126.38 v1(28.32,126.38)
  BOTTOM w0.147: Q11.3 v1(28.32,126.38)
N28118260: length 7.2
  TOP w0.254: LD4.2 v1(151.26,103.01)
  BOTTOM w0.254: v1(151.26,103.01) 151.26,98.31 151.51,98.06 R276.2
N28118377: length 2.8
  TOP w0.147: LD9.2 172.71,63.68 v1(172.71,64.91)
  BOTTOM w0.147: R362.2 172.19,64.39 v1(172.71,64.91)
N28118380: length 2.4
  TOP w0.147: v1(163.7,52.97) LD15.2
  BOTTOM w0.147: R407.2 v1(163.7,52.97)
N28118607: length 2.8
  TOP w0.147: LD25.2 v1(18.8,10.68)
  BOTTOM w0.14: R556.2 v1(18.8,10.68)
N28118686: length 1.1
  TOP w0.381: R201.2 LD24.2
N28119618: length 2.6
  TOP w0.147: LD23.1 101.8,17.24 101.33,16.76 v1(100.82,16.76)
  BOTTOM w0.147: Q18.3 100.62,16.56 v1(100.82,16.76)
N28119621: length 3.2
  TOP w0.147: LD26.1 95.38,12.73 v1(95.91,13.27)
  BOTTOM w0.147: v1(95.91,13.27) Q19.3
N28787498: length 5.2
  TOP w0.147: C501.2 C500.1 35.36,95.94 35.58,96.16 35.94,96.16 36.55,96.77 37.32,96.77 37.49,96.94 U15.15
N28789368: length 2.8
  TOP w0.147: TP101.1 50.47,33.17 50.7,32.94 v1(51.82,32.94)
  BOTTOM w0.147: U91.12 51.84,32.91 v1(51.82,32.94)
N28853998: length 1.4
  TOP w0.147: R614.1 16.49,89.05 Q20.1
N28854850: length 3.5
  BOTTOM w0.147: R617.1 14,87.17 13.38,86.55 Q21.1
N28887698: length 11.1
  BOTTOM w0.147: R624.1 76.12,75.61 75.51,75 75.51,73.66 75.77,73.41 75.77,72.29 75.29,71.81 75.29,70.41 75.64,70.05 R625.1 76.19,70.05 77.11,69.14 78.74,69.14 79.22,68.66 R632.1
N28906258: length 2.2
  TOP w0.147: R631.2 J40.2
N28906289: length 2.2
  TOP w0.147: R630.2 J39.2
N248107881: length 1.5
  TOP w0.147: R189.2 C168.1

## Copper pours and planes (outline as drawn)
DGND on BOTTOM (solid shape): 53.43,92.3 51.47,92.3 51.47,99.75 53.43,99.75
DGND on BOTTOM (solid shape): 104.53,67.63 104.59,67.72 104.7,67.7 104.77,67.63 104.77,66.85 106.07,66.85 106.07,66.01 104.45,66.01 104.18,66.28 104.18,66.39 104.53,66.39
DGND on BOTTOM (solid shape): 89.88,53.32 86.05,49.49 86.02,49.49 85.58,49.05 85.47,49.03 85.4,49.12 85.4,49.71 89.48,53.79 89.48,54.95 89.67,55.14 89.67,56.38 89.88,56.38
DGND on BOTTOM (solid shape): 51.64,63.18 51.64,62.47 53.61,60.51 55.07,60.51 55.13,60.46 55.19,60.42 55.22,60.4 55.22,60.32 52.36,60.32 50.52,62.17 50.52,63.93 50,64.45 49.98,64.56 50.07,64.62 50.2,64.62
DGND on BOTTOM (solid shape): 73.34,93.14 73.45,93.16 73.51,93.07 73.51,91.23 73.45,91.13 73.34,91.15 73.01,91.48 72.02,91.48 70.88,90.33 70.78,90.33 70.68,90.4 70.71,90.51
DGND on BOTTOM (solid shape): 49.02,103.24 49.07,103.21 49.06,103.16 49.01,103.11 49.01,102.15 48.42,102.15 48.42,102.68 48.39,102.79 48.33,102.88 48.22,103 48.13,103.06 48.02,103.08 47.74,103.08 47.55,102.89 47.49,102.88 47.46,102.92 47.46,102.96 47.41,103.02 47.41,103.04 47.61,103.24
DGND on BOTTOM (solid shape): 73.47,121.99 73.56,121.92 73.54,121.81 72.62,120.89 72.62,118.2 72.17,117.75 72.1,117.75 72.02,117.79 72,117.88 72.01,117.97 72,118.07 72,118.44 72.19,118.44 72.19,119.69 72,119.69 72,119.87 71.69,120.17 71.69,121.5 71.52,121.5 71.52,121.67 71.37,121.81 71.35,121.92 71.44,121.99
DGND on BOTTOM (solid shape): 99.18,70.61 99.27,70.63 99.34,70.57 99.43,70.45 99.56,70.38 99.58,70.38 99.83,70.12 99.83,68.77 99.9,68.77 99.99,68.71 99.97,68.6 97.35,65.98 97.24,65.96 97.17,66.05 97.17,66.19 97.66,66.68 97.66,68.17 97.34,68.5 97.34,70.12 97.35,70.14 97.42,70.19 97.51,70.16 97.55,70.12 98.69,70.12
DGND on BOTTOM (solid shape): 17.74,71.23 22.62,66.35 24.5,66.35 24.89,66.73 25.28,66.35 25.95,66.35 26.33,66.73 26.72,66.35 27.39,66.35 27.77,66.73 28.16,66.35 28.83,66.35 29.22,66.73 29.6,66.35 33.39,66.35 33.39,65.64 31.9,65.64 31.37,65.12 27.73,65.12 27.73,65.79 27.3,66.22 26.63,66.22 26.24,65.83 25.86,66.22 25.19,66.22 24.76,65.79 24.76,65.12 23.64,65.12 18.6,70.16 16.59,70.16 16.03,70.72 16.03,71.12 16.09,71.21 16.19,71.2 16.94,70.99 17.65,71.33 17.66,71.34 17.74,71.34
DGND on BOTTOM (solid shape): 45.62,101.06 45.65,101.11 45.7,101.1 45.72,101.08 46.23,101.08 46.33,100.98 46.33,98.31 46.68,97.97 46.7,97.85 46.61,97.79 45.24,97.79 45.17,97.86 45.14,97.95 45.21,98.02 45.41,98.18 45.48,98.43 45.5,98.5 45.58,98.53 45.59,98.53 45.59,99.73 45.58,99.73 45.5,99.76 45.47,99.84 45.48,99.89 45.5,99.96 45.58,99.99 45.62,99.99
DGND on BOTTOM (solid shape): 92.86,48.94 92.94,48.97 93.01,48.93 93.05,48.88 93.1,48.84 93.14,48.77 93.11,48.69 90.83,46.41 90.83,41.79 90.29,41.24 90.17,41.22 90.11,41.32 90.11,46.78 90.15,46.86 90.23,46.88 90.7,47.14 90.5,47.64 90.44,47.71 90.47,47.8 91.17,48.51 92.43,48.51
DGND on BOTTOM (solid shape): 126.87,53.15 126.98,53.17 127.04,53.07 127.04,51.42 124.98,49.36 124.98,49.31 124.92,49.21 124.82,49.23 124.74,49.27 124.66,49.3 124.59,49.37 124.61,49.47 125.92,50.77 125.92,51.32 125.95,51.4 126.04,51.42 126.5,51.76 126.17,52.23 126.09,52.3 126.12,52.4
DGND on BOTTOM (solid shape): 151.23,41.82 151.23,41.61 151.39,41.44 151.39,41.03 150.99,41.03 150.99,40.9 150.09,40.9 148.41,39.21 147.47,39.21 147.47,41.59 147.64,41.59 147.64,41.3 148.81,41.3 148.81,42.55 148.72,42.55 148.64,42.58 148.61,42.66 148.21,43.09 147.8,42.66 147.78,42.58 147.7,42.55 147.64,42.55 147.64,42.27 147.47,42.27 147.47,42.93 147.5,43 147.57,43.03 147.88,43.19 147.96,43.53 147.98,43.61 148.06,43.65 148.63,43.65 148.64,43.66 149.38,43.66
DGND on BOTTOM (solid shape): 69.59,67.7 69.62,67.75 69.68,67.74 69.74,67.68 69.74,66.6 71.01,66.6 71.01,65.62 71.35,65.62 71.35,65.61 71.38,65.52 71.42,65.45 71.42,65.41 71.4,65.38 71.24,64.92 71.63,64.63 71.71,64.59 71.73,64.51 71.72,64.43 71.72,64.35 71.7,64.26 71.62,64.23 71.02,64.23 71.02,65.03 70.74,65.31 70.46,65.31 70.36,65.29 70.27,65.23 70.14,65.11 69.93,65.33 69.97,65.37 69.97,66.19 69.61,66.54 69.32,66.54 69.24,66.58 69.22,66.66 69.22,66.73 69.59,67.1
DGND on BOTTOM (solid shape): 66.45,51.25 66.45,49.78 66.38,49.68 66.27,49.7 65.5,50.47 65.27,50.47 65.27,50.78 64.28,50.78 64.28,52.45 64,52.74 64.17,52.91 64.17,53.3 63.97,53.5 63.88,53.56 63.77,53.58 63.6,53.58 63.6,53.75 63.58,53.86 63.52,53.95 63.4,54.07 63.31,54.13 63.2,54.15 63.03,54.15 63.03,54.32 63.01,54.43 62.95,54.52 62.83,54.64 62.74,54.7 62.64,54.72 62.46,54.72 62.46,54.89 62.44,55 62.38,55.09 62.26,55.2 62.17,55.26 62.07,55.28 61.7,55.28 61.7,55.48 61.68,55.58 61.62,55.67 57.52,59.77 57.52,59.81 57.55,59.89 57.62,59.92 57.78,59.92
DGND on BOTTOM (solid shape): 52.3,40.74 52.4,40.68 52.38,40.57 52.27,40.46 48.62,36.81 48.62,32.32 48.57,31.78 49.1,31.67 49.2,31.67 49.25,31.58 49.25,30.49 48.9,30.13 48.79,30.11 48.72,30.2 48.72,30.82 47.95,30.82 47.65,31.12 47.65,31.34 47.69,31.42 47.78,31.43 48.24,31.63 48.16,32.12 48.16,32.64 48.16,32.64 48.16,37.85 51.05,40.74
DGND on BOTTOM (solid shape): 80.3,54.64 80.35,54.55 80.35,53.79 80.39,53.75 80.4,53.7 80.35,53.67 79.62,53.67 79.34,53.39 79.34,52.86 79.11,52.86 78.66,52.41 78.66,52.34 78.61,52.26 78.51,52.25 78.45,52.27 78.39,52.28 77.87,52.28 77.72,52.12 77.65,52.1 77.58,52.12 77.45,52.21 77.3,52.24 77.28,52.24 77.25,52.27 77.23,52.38 77.32,52.44 77.66,52.67 77.62,53.08 77.62,54.45 78.38,54.45 78.38,54.56 78.63,54.56 78.63,54.4 79.87,54.4 79.87,54.48 79.9,54.55 79.98,54.58 80.09,54.59 80.2,54.64
DGND on BOTTOM (solid shape): 25.78,35.55 25.87,35.5 26.17,35.13 26.61,34.95 26.69,34.88 26.66,34.78 26.49,34.61 26.49,33.39 26.15,33.04 24.55,33.04 24.46,33.11 24.48,33.22 24.76,34.19 24.07,34.92 24.03,34.93 24.03,35.04 24.09,35.13 24.19,35.12 25.03,34.97 25.69,35.5
DGND on BOTTOM (solid shape): outline of 120 points within 130.76,73.97 135.09,86.85
DGND on BOTTOM (solid shape): 22.72,68.54 24.24,68.54 24.62,68.92 25.01,68.54 25.68,68.54 26.07,68.92 26.45,68.54 27.12,68.54 27.51,68.92 27.9,68.54 28.57,68.54 28.95,68.92 29.34,68.54 30.01,68.54 30.39,68.92 30.78,68.54 30.87,68.54 30.87,68.48 30.87,68.47 31.14,67.91 31.65,68.26 31.71,68.35 31.82,68.32 32.29,67.85 33.39,67.85 33.39,67.15 30.8,67.15 30.71,67.2 30.71,67.31 30.65,67.81 30.14,67.85 30.04,67.85 29.98,67.93 29.55,68.35 28.88,68.35 28.5,67.97 28.11,68.35 27.44,68.35 27.05,67.97 26.67,68.35 26,68.35 25.61,67.97 25.22,68.35 24.55,68.35 24.13,67.93 24.13,67.15 22.95,67.15 19.29,70.81 19.27,70.93 19.36,70.99 19.73,71.04 20.05,71.21
DGND on BOTTOM (solid shape): 124.11,131.71 124.2,131.65 124.17,131.54 123.84,130.95 123.89,130.28 123.87,130.14 123.82,130.01 123.81,129.93 123.42,129.54 123.42,129.04 123.36,128.95 123.25,128.97 121.43,128.74 122.11,127.05 122.15,127.04 122.15,126.66 118.94,123.45 118.83,123.42 118.77,123.52 118.77,127.33 119.02,127.59 119.02,129.44 119.12,129.54 119.2,129.55 119.33,129.6 119.47,129.62 120.87,130.08 120.68,131.54 120.66,131.65 120.75,131.71
DGND on BOTTOM (solid shape): 119.03,131.71 119.12,131.65 119.09,131.54 118.76,130.95 118.81,130.28 118.79,130.14 118.74,130.01 118.73,129.93 118.47,129.67 118.47,128.9 118.4,128.8 118.28,128.84 116.45,128.89 116.88,127.1 116.96,126.99 117.03,126.86 117.07,126.8 117.92,125.95 117.92,122.08 117.85,121.98 117.74,122.01 113.96,125.79 113.96,129.54 114.15,129.61 114.36,129.63 115.78,130.07 115.6,131.54 115.58,131.65 115.67,131.71
DGND on BOTTOM (solid shape): 96.95,88.1 97.01,88.01 97.01,85.12 97.05,85.08 97,85.03 96.99,85.03 96.74,84.63 97.14,84.38 97.2,84.38 97.2,84.22 97.14,84.23 96.73,83.9 97.14,83.58 97.2,83.58 97.2,83.42 97.14,83.43 96.99,83.43 96.86,83.36 96.78,83.35 96.71,83.39 96.64,83.48 96.55,83.55 96.5,83.62 96.52,83.7 96.57,84.02 96.31,84.23 96.3,84.23 96.21,84.32 96.26,84.37 96.28,84.37 96.59,84.75 96.18,85.03 96.12,85.02 96.12,85.18 96.18,85.18 96.56,85.36 96.45,85.77 96.41,85.84 96.44,85.92 96.46,85.94 96.46,88.06 96.7,88.06 96.78,88.07 96.85,88.1
DGND on BOTTOM (solid shape): 18.78,33.55 18.87,33.5 19.27,33.07 19.85,32.94 19.93,32.91 19.96,32.83 19.95,32.7 19.96,32.57 19.93,32.49 19.85,32.46 19.27,32.33 18.87,31.9 18.78,31.85 18.69,31.9 17.05,32.16 17.35,30.53 17.41,30.44 17.45,30.35 17.47,30.32 17.47,30.25 17.4,30.25 16.55,30.44 15.87,29.9 15.78,29.85 15.69,29.9 15.33,30.3 14.82,30.47 14.73,30.53 14.75,30.64 15.04,30.93 15.04,32.19 15.23,32.38 15.58,32.38 15.9,32.69 15.91,32.69 16.02,32.76 16.1,32.85 16.14,32.94 16.2,33.03 16.48,33.22 16.69,33.5 16.78,33.55 17.78,32.93
DGND on BOTTOM (solid shape): outline of 321 points within 67.53,35.26 88.08,43.75
DGND on BOTTOM (solid shape): outline of 395 points within 94.19,70.68 100.35,73.75
DGND on BOTTOM (solid shape): outline of 412 points within 97.56,82.16 100.22,86.04
DGND on TOP: 140.61,88.7 140.61,132.97 176.78,132.97 176.78,88.7 171.09,88.7 170.99,88.6 170.99,82.73 167.54,82.73 167.54,79.27 167.18,78.92 164.31,78.92 164.29,78.94 164.29,84.38 159.61,84.38 159.61,78.59 156.54,78.59 156.36,78.77 156.36,82.75 151.23,82.75 151.23,76.38 146.96,76.38 146.96,88.49 146.76,88.7
DGND on TOP: 104.72,68.17 104.72,69.11 102.21,69.11 102.21,76.07 103.58,76.07 103.58,78.44 110.85,78.44 110.85,75.23 106.05,75.23 106.05,69.7 109.02,69.7 109.02,68.17 ; 1 cut-out
DGND on TOP: 161.09,93.7 161.09,91.72 163.8,91.72 163.8,93.7
DGND on TOP: 106.86,33.1 115.32,33.1 115.24,33.17 115.24,40.72 112.6,43.36 112.6,46.81 111.81,46.81 109.07,44.07 109.07,38.79 106.53,36.25 106.53,33.43
DGND on TOP: 132.31,88.19 132.31,84.4 131.8,83.9 131.8,82.98 130.81,81.99 130.81,76.71 131.11,76.4 133.53,76.4 133.93,76 136.65,76 136.65,79.58 138.05,79.58 138.05,88.19
DGND on TOP: 63.12,33.68 63.12,44.75 76.25,44.75 76.35,44.86 76.35,46.2 85.55,46.2 86.03,45.72 86.03,44.75 86.28,44.75 86.28,33.68 ; 2 cut-outs
DGND on TOP: 71.48,79.32 74.17,79.32 74.19,79.3 75.62,79.3 75.97,79.65 77.14,79.65 78.59,78.21 78.59,78.18 79.3,77.47 81.58,77.47 81.64,77.42 81.64,76.99 81.23,76.58 76.17,76.58 75.95,76.81 75.95,77.55 75.77,77.72 72.54,77.72 71.48,78.79
DGND on TOP: 115.19,84.2 115.19,62.87 126.26,62.87 126.26,84.2 ; 4 cut-outs
DGND on TOP: 97.33,63.96 97.33,54.79 125.6,54.79 125.6,63.96 ; 5 cut-outs
DGND on TOP: 94.31,50.8 97.79,50.8 98.17,50.42 98.17,48.51 100.97,45.72 106.55,45.72 106.55,46.05 113.16,52.65 116.23,52.65 117.73,54.15 126.64,54.15 127.25,53.54 127.25,47.73 126.82,47.29 123.6,47.29 122.28,48.62 112.5,48.62 108.53,44.65 108.53,39.78 102.51,33.76 93.37,33.76 90.63,31.01 90.37,31.01 90.02,31.37 89.15,31.37 86.77,33.76 86.77,41.81 91.62,46.66 93.07,46.66 94.31,47.9 ; 10 cut-outs
DGND on TOP: 130.63,49.12 130.63,70.41 148.13,70.41 148.13,60.78 147.7,60.78 143.33,56.41 137.92,56.41 ; 1 cut-out
DGND on BOTTOM: 23.37,59.96 19.56,59.96 19.43,60.09 19.43,63.01 23.5,63.01 23.5,60.09
DGND on L02_GND1: 1.02,8.02 1.02,47.69 1.02,47.69 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.87 1.02,60.87 1.02,132.98 9.02,132.98 9.02,130.95 9.27,130.7 10.89,130.7 12.32,129.27 12.32,128.54 11.68,127.9 11.68,124.98 13.72,124.98 13.72,128.02 13.08,128.65 13.08,129.29 14.36,130.57 15.88,130.57 16.51,131.21 16.51,132.98 18.67,132.98 18.67,130.57 20.95,130.57 22.23,129.3 22.23,128.79 21.59,128.16 21.59,124.98 23.62,124.98 23.62,128.41 26.92,131.71 26.92,132.98 176.78,132.98 176.78,8.02 ; 7 cut-outs
DGND on L04_GND2: 1.02,8.02 1.02,47.31 1.02,47.31 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.52 1.02,60.52 1.02,132.98 176.78,132.98 176.78,8.02 ; 6 cut-outs
DGND on L07_GND3: 1.02,8.02 1.02,46.95 1.02,46.95 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.39 1.02,60.39 1.02,132.98 176.78,132.98 176.78,8.02 ; 6 cut-outs
DGND on L09_GND4: 1.02,8.02 1.02,49.01 1.02,49.01 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.34 1.02,60.34 1.02,132.98 176.78,132.98 176.78,8.02 ; 6 cut-outs
GNDUSB on TOP: 168.23,35.45 168.23,38.94 174.69,38.94 174.94,39.2 174.94,42.18 174.69,42.43 173.04,42.43 173.04,46.5 177.35,46.5 177.35,35.45
VCC1V2_DDR on TOP: 87.36,115.06 87.36,119.63 92.46,119.63 92.46,115.06
VCC1V2_DDR on TOP: 98,119.81 98,126.22 101.85,126.22 101.85,119.81
VCC1V2_DDR on BOTTOM: 87.88,119.78 92.99,119.78 92.99,115.08 87.88,115.08
VCC1V2_DDR on L08_SIG2: 87.76,115.57 93.85,115.57 93.85,118.75 94.87,119.76 102.23,119.76 102.23,124.01 93.53,124.01 87.76,118.24
VCC1V8 on TOP: 46.36,63.13 46.36,61.28 47.48,60.15 48.75,60.15 48.75,63.13
VCC1V8 on TOP: 95.85,37.99 95.85,36.29 102.11,36.29 102.11,37.99
VCC1V8 on TOP: 53.99,64.35 53.99,61.93 56.13,61.93 56.13,64.35
VCC1V8 on TOP: 113.06,46.85 113.06,45.61 121.74,45.61 121.74,46.85
VCC1V8 on TOP: 132.08,116.02 139.56,116.02 139.56,107.34 132.08,107.34
VCC1V8 on BOTTOM: 132.08,107.34 132.08,112.03 134.49,112.03 134.49,116.85 141.1,116.85 141.11,116.85 141.91,116.85 142.37,116.39 142.37,110.12 139.59,107.35 137.19,107.35 137.19,107.34
VCC1V8 on L03_SIG1: 49.23,65.38 54.46,65.38 56.67,63.17 56.67,60.88 55.85,60.07 48.41,60.07 47.78,60.71 47.78,63.93
VCC1V8 on L06_PWR2: 127.52,36.52 118.45,27.45 94.61,27.45 90.42,31.64 90.42,49.8 90.55,49.93 119.28,49.93 133.74,64.38 137.28,64.38 147.57,74.68 147.57,92.01 131.95,107.63 131.95,110.18 130.11,112.03 126.55,112.03 122.98,115.6 95.78,115.6 91.52,119.86 75.55,119.86 74.11,118.42 74.11,95.19 67.96,95.19 67.96,122.07 70.46,124.57 81.14,124.57 82.51,123.2 84.74,123.2 86.11,124.57 95.63,124.57 98.44,121.77 129.96,121.77 131.55,120.18 145.6,120.18 156.46,109.32 156.46,65.46 144.82,53.81 137.79,53.81 137.79,50.81 136.91,49.93 135.89,49.93 134.62,51.2 132.46,51.2 127.52,46.25
VCC1V8_HSE on TOP: 74.24,124.81 70.61,124.81 70.61,122.44 74.55,122.44 74.55,124.5
VCC1V8_HSE on BOTTOM: 70.36,122.44 70.36,129.14 71.91,130.7 74.55,130.7 74.55,125.11 74.55,125.11 74.55,123.46 73.53,122.44
VCC3V3_IO_HSE on TOP: 38.69,121.76 38.69,124.02 38.39,124.32 37.94,124.32 37.88,124.37 37.88,126 41.53,126 41.53,121.76
VCC3V3_IO_HSE on BOTTOM: 38.44,124.98 38.44,120.42 41.27,120.42 41.27,124.98
VCC3V3_PREREG on TOP: 136.6,57.5 136.6,59.79 139.51,59.79 139.51,57.84 139.17,57.5
VCC3V3_PREREG on TOP: 131.09,75.72 132.86,75.72 132.86,73.31 134.01,73.31 134.01,71.18 131.09,71.18
VCC3V3_PREREG on TOP: 97.28,119.11 95.24,119.11 94.11,117.98 94.11,115.25 97.13,115.25 97.13,117.61 96.9,117.84 96.9,118.6 97.03,118.73 97.28,118.73
VCC3V3_PREREG on TOP: 156.19,102.38 156.19,104.79 159.26,104.79 159.64,104.41 159.64,102.76 159.26,102.38
VCC3V3_PREREG on TOP: 149.79,96.95 158.01,96.95 158.01,101.94 149.32,101.94 149.32,97.42
VCC3V3_PREREG on BOTTOM: 144.91,122.82 141.22,122.82 141.22,119.9 141.48,119.65 144.78,119.65 144.91,119.78
VCC3V3_PREREG on BOTTOM: 142.11,102.5 141.6,102.5 140.39,101.28 140.39,100.05 142.73,100.05 142.73,101.88
VCC3V3_PREREG on L05_PWR1: 132.73,56.64 131.95,57.42 131.95,66.57 135.62,66.57 136.5,67.45 136.5,70.9 136.14,71.26 131.17,71.26 128.6,73.83 128.6,94.22 129.79,95.41 134.72,95.41 143.26,103.95 143.26,113.3 135.76,120.79 98.04,120.79 97.93,120.91 97.93,115.33 97.16,114.55 93.34,114.55 92.84,115.06 92.84,121.93 98.3,127.4 141,127.4 160.53,107.87 160.53,101.97 151,92.45 139.76,92.45 136.84,89.53 136.84,81.49 143.25,75.08 143.25,66.93 140.84,64.53 140.84,57.29 140.19,56.64 ; 1 cut-out
VCC3V3_TA on TOP: 72.39,21.1 72.39,16.77 75.16,14 84.09,14 84.71,14.62 84.71,17.92 84.45,18.18 77.95,18.18 75.03,21.1
VCC3V3_TA on BOTTOM: 57.66,21.1 50.14,21.1 50.14,13.6 55.37,13.6 55.37,18.3 56.82,19.75 57.51,19.75 57.66,19.89
VCC3V3_TA on BOTTOM: 82.27,17.82 82.27,13.17 84.96,13.17 84.96,17.82
VCC3V3_TA on BOTTOM: 66.52,20.87 66.52,19.65 72.95,19.65 72.95,20.87
VCC3V3_TA on L05_PWR1: 50.51,14.4 50.51,16.65 57.24,23.38 66.42,23.38 68.33,21.48 68.33,18.3 63.88,13.86 51.05,13.86
VCC3V3_TA on L06_PWR2: 64.01,21.86 64.01,51.37 69.72,57.09 69.72,65.04 70.62,65.94 72.26,65.94 73.15,65.04 73.15,61.36 73.77,60.73 79.97,60.73 86.71,53.99 109.73,53.99 109.98,53.74 109.98,42.56 112.19,40.35 112.19,38.4 111.65,37.86 104.9,37.86 103.98,38.78 103.98,40.25 106.17,42.43 106.17,50.13 105.49,50.81 73.7,50.81 72.71,49.82 72.71,26.11 74.55,24.27 96.9,24.27 98.55,22.62 98.55,18.94 66.93,18.94
VCC3V3_XDS on TOP: 167.39,11.44 167.39,10.56 167.26,10.43 163.58,10.43 163.58,12.08 164.72,12.08 165.35,11.44
VCC3V3_XDS on L05_PWR1: 139.04,23.76 133.48,23.76 131.95,25.29 131.95,28.84 135.64,32.53 154.56,32.53 159.51,27.57 162.69,27.57 165.93,24.33 165.93,10.29 163.91,8.27 150.61,8.27 140.46,18.42 140.46,22.34
VCC3V3_XDS on L08_SIG2: 140.51,17.04 125.96,31.6 125.96,46.13 122.89,49.2 122.89,56.16 136.63,56.16 138.86,53.92 138.86,39.12 142.85,35.13 153.82,35.13 158.24,30.71 158.24,22.38 152.91,17.04
VCC_1V8_FT4232 on TOP: 132.24,46.75 132.24,37.83 135.13,34.94 146.43,34.94 149.35,37.86 149.35,45.35 148.84,45.86 146.43,45.86 144.15,43.58 144.15,41.13 142.12,39.11 135.8,39.11 134.49,40.42 134.49,46.24 133.99,46.75
VCC_3V3_FT4232 on L06_PWR2: 128.27,46.75 134.37,52.85 144.4,52.85 144.4,48.91 143.51,48.02 138.94,48.02 134.24,43.32 134.24,37.35 135.38,36.21 145.67,36.21 147.45,37.99 147.45,43.58 156.21,43.58 156.21,41.04 147.4,32.23 141.74,32.23 136.7,27.19 128.4,27.19 125.48,30.11 125.48,33.15 128.27,35.94
VCC_3V3_MIPI on BOTTOM: 58.55,53.48 58.55,52.16 61.85,52.16 61.85,53.48
VCC_3V3_MIPI on L08_SIG2: 59.69,52.21 59.69,53.23 62.1,53.23 62.1,52.21
VCC_3V3_SYS on TOP: 138.55,88.15 138.56,88.15 138.56,93.02 142.04,93.02 142.04,88.79 146.25,88.79 146.25,77.59 138.81,77.59 138.55,77.85
VCC_3V3_SYS on TOP: 32.51,116.85 32.51,118.25 31.74,119.02 28.65,119.02 28.65,117.01 31.02,117.01 31.24,117.24 32,117.24 32.13,117.11 32.13,116.85
VCC_3V3_SYS on TOP: 19.56,59.7 19.56,58.31 20.33,57.54 23.42,57.54 23.42,59.63 21.14,59.63 20.83,59.32 20.07,59.32 19.94,59.45 19.94,59.7
VCC_3V3_SYS on TOP: 20.75,45.99 20.75,43.7 26.04,43.7 26.04,45.99
VCC_3V3_SYS on TOP: 119.75,62.53 119.95,62.33 119.95,60.85 114.71,60.85 114.71,61.75 116.1,61.75 116.89,62.53
VCC_3V3_SYS on BOTTOM: 75.82,112.22 76.71,112.22 76.71,115.46 75.82,115.46
VCC_3V3_SYS on BOTTOM: 49.72,91.07 49.72,91.58 48.5,92.8 47.31,92.8 47.31,90.57 47.56,90.31 48.96,90.31
VCC_3V3_SYS on BOTTOM: 15.75,18.68 16.26,18.68 17.48,19.9 17.48,21.21 15.24,21.21 14.99,20.96 14.99,19.45
VCC_3V3_SYS on BOTTOM: 43.58,45.35 43.58,46.88 52.84,46.88 52.84,45.35
VCC_3V3_SYS on BOTTOM: 74.82,120.4 76.21,120.4 77.09,119.52 77.09,116.94 76.71,116.94 76.71,118.38 76.26,118.83 74.82,118.83
VCC_3V3_SYS on BOTTOM: 91.72,129.74 91.72,132.65 90.42,132.65 90.42,129.74
VCC_3V3_SYS on BOTTOM: 138.56,93.28 141.55,93.28 143.62,91.21 145.37,91.21 145.37,80.54 138.55,80.54 138.55,88.15 138.56,88.15
VCC_3V3_SYS on L05_PWR1: 1.35,53.3 1.02,53.3 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.27,59.12 1.27,132.98 175.81,132.98 175.81,8.02 1.27,8.02 1.27,47.79 1.06,47.79 1.06,50.41 1.44,50.41 1.83,50.41 2.64,50.78 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 ; 7 cut-outs
VCC_3V3_SYS on L06_PWR2: 1.27,8.02 1.27,132.98 177.04,132.98 177.04,8.02 ; 38 cut-outs
VCC_5V0 on TOP: 81.72,125.48 81.72,122.4 84.79,122.4 84.79,125.48
VCC_5V0 on TOP: 171.63,87.52 171.63,79.83 176.73,79.83 176.73,88.14 172.26,88.14
VCC_5V0 on TOP: 34.87,48.53 33.48,48.53 33.1,48.91 33.1,51.32 33.22,51.45 34.75,51.45 35.13,51.07 35.13,48.78
VCC_5V0 on BOTTOM: 171.63,87.52 171.63,79.83 176.78,79.83 176.78,88.14 172.26,88.14
VCC_5V0 on L03_SIG1: 33.81,49.47 33.81,51.25 35.2,51.25 35.2,49.47
VCC_5V0 on L03_SIG1: 24.26,118.38 24.26,116.47 26.29,116.47 26.29,118.38
VCC_5V0 on L06_PWR2: 173.01,81.29 173.01,106 158.08,120.93 132.07,120.93 130.65,122.35 98.78,122.35 95.88,125.24 85.96,125.24 84.42,123.7 82.65,123.7 81.11,125.24 34.04,125.24 28.32,119.52 28.32,112.92 16.64,112.92 16.64,126.75 22.87,132.98 174.75,132.98 176.71,131.02 176.71,81.29
VCC_5V0_HSE on TOP: 70.75,126.07 70.75,125.11 74.29,125.11 74.8,124.6 80.64,124.6 80.9,124.86 80.9,127.01 79.5,128.41 75.56,128.41 74.53,127.38 74.53,126.22 74.38,126.07
VCC_CORE on TOP: 124.16,77.54 124.16,83.58 127.41,83.58 128.05,84.21 128.05,91.99 131.97,91.99 131.97,84.71 131.32,84.05 131.32,82.62 130.32,82.62 130.32,77.54
VDD3V3_CLKBUF on L05_PWR1: 52.83,105.55 52.83,109.36 54.48,111.01 67.31,111.01 67.65,110.67 67.65,109.02 68.58,108.09 73.91,108.09 75.56,106.44 75.56,103.52 74.8,102.76 68.71,102.76 67.82,101.87 67.82,95.39 65.66,93.23 62.87,93.23 59.69,96.41 59.69,99.46 54.74,104.41 53.98,104.41
VDD_0V85 on TOP: 154.55,106.31 153.53,107.33 150.63,107.33 150.63,109.21 150.63,109.21 150.63,114.31 155.45,114.31 155.45,106.44 155.32,106.31
VDD_0V85 on BOTTOM: 155.32,116.34 155.32,107.57 150.79,107.57 150.79,116.34
VDD_1V0 on BOTTOM: 44.34,92.44 45.17,92.44 45.17,94.17 41.2,94.17 40.89,93.87 40.89,91.58 41.15,91.33 43.23,91.33
VDD_1V0 on L05_PWR1: 34.04,101.61 34.04,104.28 36.7,106.95 39.51,106.95 39.72,106.74 39.72,104.95 42.67,102 48.64,102 49.15,101.49 49.15,99.71 48.78,99.34 44.2,99.34 43.91,99.05 43.91,91.93 43.31,91.33 41.36,91.33 41.01,91.69 41.01,93.15 41.82,93.96 41.82,97.01 38.73,100.09 35.56,100.09
VDD_1V1 on TOP: 18.86,59.9 12.45,59.9 12.45,65.47 18.86,65.47
VDD_1V1 on L06_PWR2: 13.08,66.31 13.08,59.58 15.75,56.91 43.78,56.91 49.55,62.68 49.55,86.53 47.76,88.31 40.99,88.31 35.24,82.56 34.54,82.56 34.54,81.68 35.81,81.68 35.81,66.44 34.29,66.44 34.29,65.42 35.69,65.42 35.69,62.5 29.28,62.5 25.47,66.31
VDD_2V5 on TOP: 33.21,116.14 39.62,116.14 39.62,111.09 33.21,111.09
VDD_2V5 on L06_PWR2: 29.46,63.26 35.17,63.26 35.17,64.54 34.92,64.78 33.4,64.78 33.27,64.91 33.27,66.94 33.53,67.2 34.92,67.2 35.17,67.44 35.17,80.62 34.87,80.91 33.66,80.91 33.4,81.17 33.4,83.2 33.53,83.33 34.92,83.33 35.17,83.57 35.17,101.41 39.5,105.75 39.5,113.26 38.7,114.06 32.76,114.06 27.3,108.6 27.3,65.42
VDD_2V8 on BOTTOM: 20.09,13.29 20.09,18.81 16.51,18.81 15.49,17.79 15.49,13.29
VDD_CORE on TOP: 121.51,84.11 121.51,90.57 119.06,90.57 119.06,99.31 124.97,99.31 124.97,91.45 127.38,91.45 127.38,84.11
VDD_CORE on BOTTOM: 103.63,81.03 100.6,81.03 100.6,86.49 103.63,86.49
VDD_CORE on L05_PWR1: 111.3,83.76 107.44,79.9 107.44,76.98 106.52,76.06 93.82,76.06 93.38,75.62 92.84,75.62 92.84,76.25 92.64,76.45 91.85,76.45 91.69,76.3 91.69,75.62 91.06,75.62 91.06,76.34 92.08,77.36 92.08,78.88 91.82,79.14 90.42,79.14 90.04,78.75 90.04,77.36 89.79,77.1 89.03,77.1 88.9,77.23 88.9,77.99 87.76,79.14 87.76,85.1 90.64,87.99 97.95,87.99 98.46,88.5 107.24,97.55 125.42,97.55 127.64,95.34 127.64,85.23 126.36,83.96 122.95,83.96 119.26,87.64 112.39,87.64 111.3,86.55 ; 1 cut-out
VDD_DDR4 on TOP: 86.91,119.78 86.91,115.05 81.9,115.05 81.9,119.78
VDD_DDR4 on BOTTOM: 97.79,92.12 99.82,92.12 99.82,86.5 97.79,86.5
VDD_DDR4 on BOTTOM: 74.8,118.19 74.8,117.04 74.89,116.96 76.55,116.96 76.55,118.19
VDD_DDR4 on L06_PWR2: 91.06,81.93 91.06,80.02 91.44,79.64 93.6,79.64 94.36,80.41 96.26,80.41 98.17,80.28 104.01,86.12 104.01,105.99 90.89,119.12 76.42,119.12 75.4,118.11 75.4,101.91 87.5,89.81 87.5,85.49
VDD_DLL_MMC0 on BOTTOM: 115.82,70.5 115.82,75.58 112.62,75.58 112.62,70.5
VDD_MMC1 on TOP: 113.06,62.64 113.06,59.83 110.14,59.83 108.97,61.01 108.97,62.66 113.03,62.66
VDD_MMC1 on L03_SIG1: 103.96,73.07 103.96,72.63 106.1,70.5 106.1,67.25 108.64,64.71 108.64,62.22 109.29,61.56 111.63,61.56 111.63,68.09 106.65,73.07
VDD_MMC1 on L06_PWR2: 108.97,62.68 108.97,61.24 110.28,61.24 110.28,62.68
VDD_MMC1 on L06_PWR2: 39.6,22.27 39.6,19.65 42.32,19.65 42.32,22.27
VDDA1V8 on TOP: 126.24,63.58 126.24,67.06 126.25,67.07 130.94,67.07 130.94,61.96 130.93,61.96 130.93,61.01 132.62,59.33 134.36,59.33 135,58.69 135,57.55 132.72,57.55 132.33,57.16 130.43,57.16 130.43,59.39
VDDA1V8 on BOTTOM: 128.81,57.93 126.24,60.5 126.24,67.06 126.25,67.07 130.94,67.07 130.94,61.96 130.93,61.96 130.93,60.99 132.1,59.82 132.1,58.34 131.7,57.93
VDDA_1V8 on TOP: 109.22,68.09 109.22,69.99 111.12,69.99 111.12,77.87 111.89,77.87 112.27,78.25 112.27,80.66 108.71,80.66 108.71,83.58 109.47,83.58 109.47,85.1 112.01,85.1 112.01,82.69 113.86,80.84 113.86,68.09
VDDA_1V8 on TOP: 130.81,68.05 126.21,68.05 126.21,72.63 130.81,72.63
VDDA_1V8 on TOP: 90.3,58.31 90.3,55.01 91.69,55.01 91.69,58.31
VDDA_1V8 on BOTTOM: 108.05,80.51 108.05,83.59 110.59,83.59 110.62,83.57 110.62,81.38 109.74,80.51
VDDA_1V8 on BOTTOM: 91.47,62.37 91.47,58.99 94.31,58.99 94.31,62.37
VDDA_1V8 on BOTTOM: 130.82,68.05 126.21,68.05 126.21,73.06 130.82,73.06
VDDA_1V8 on BOTTOM: 110.62,71.13 112.01,71.13 112.14,71.01 112.14,68.47 111.89,68.21 108.71,68.21 108.58,68.34 108.58,69.86 108.84,70.12 110.36,70.12 110.49,70.25 110.49,71.01
VDDA_1V8 on L03_SIG1: 94.7,78.3 94.91,78.09 94.91,75.7 94.07,74.86 91.4,74.86 90.3,75.97 90.3,78.3
VDDA_1V8 on L06_PWR2: 89.46,54.75 75.06,69.15 75.06,78.5 71.02,82.54 71.02,84.9 71.4,85.28 76.4,85.28 79.91,81.78 79.91,75.88 81.02,74.77 81.02,70.98 89.61,62.39 92.53,62.39 96.17,66.03 104.37,66.03 109.73,71.39 133.86,71.39 133.86,67.58 131.95,65.67 112.43,65.67 101.51,54.75 ; 3 cut-outs
VDDA_1V8 on L08_SIG2: 89.42,74.09 89.42,77.53 90.18,78.29 94.75,78.29 95.28,77.77 95.28,74.74 94.19,73.65 89.86,73.65
VDDA_1V8_MCU on TOP: 106.43,72.53 110.45,72.53 110.45,69.86 107.44,69.86 107.19,69.61 106.43,69.61
VDDA_1V8_MCU on BOTTOM: 107.95,70.35 107.95,72.66 110.24,72.66 110.24,70.35
VDDA_1V8_MCU on L05_PWR1: 92.03,76.09 92.03,75.73 91.59,75.3 91.59,74.36 91.86,74.09 92.04,74.09 93.91,72.22 98.84,72.22 100.31,70.75 110.11,70.75 110.24,70.88 110.24,75.66 93.85,75.66 93.52,75.33 92.91,75.33 92.5,75.74 92.5,76.09 92.44,76.15 92.08,76.15 ; 1 cut-out
VDDA_1V8_SERDES on TOP: 88.27,58.94 88.27,65.42 92.33,65.42 92.33,58.94
VDDA_1V8_SERDES on L05_PWR1: 86.04,66.85 86.04,64.55 86.4,64.19 90.82,64.19 91.12,64.49 91.12,65.86 87.76,69.23 87.76,74.43 87.14,75.05 80.57,75.05 80.57,67.77 80.58,67.77 85.12,67.77
VDDA_1V8_USB0 on BOTTOM: 88.2,62.35 88.2,65.63 92.36,65.63 92.36,62.75 91.06,62.75 91.06,59.04 89.43,59.04 89.43,62.35
VDDA_1V8_USB0 on L06_PWR2: 85.89,73.93 87.63,73.93 87.88,73.67 87.88,69.23 90.68,66.44 92.58,66.44 92.96,66.05 92.96,63.64 92.33,63.01 89.71,63.01 85.27,67.44 85.27,73.32
VDDA_ADC on BOTTOM: 109.35,74.82 109.35,72.93 110.62,72.93 110.62,71.64 112.4,71.64 112.4,74.82
VDDA_CORE on TOP: 113.03,100.68 118.56,100.68 118.56,94.4 116.59,94.4 116.59,96.56 115.82,97.33 113.03,97.33
VDDA_CORE on BOTTOM: 116.2,72.53 116.2,70.1 118.69,70.1 118.69,72.53
VDDA_CORE on BOTTOM: 69.77,77.99 69.77,81.76 72.26,81.76 72.26,77.99
VDDA_CORE on L03_SIG1: 113.28,100.98 113.28,99.84 115.57,99.84 115.57,100.98
VDDA_CORE on L03_SIG1: 117.22,70.88 117.22,69.74 118.87,69.74 118.87,70.88
VDDA_CORE on L05_PWR1: 70.41,79.34 70.41,80.23 72.19,80.23 72.19,79.34
VDDA_CORE on L05_PWR1: 113.28,100.85 113.28,99.84 115.44,99.84 115.44,100.85
VDDA_PLL0 on BOTTOM: 72.62,82.29 75.39,82.29 76.4,81.27 79.35,81.27 79.35,82.69 78.36,83.68 72.62,83.68
VDDA_PLL1 on BOTTOM: 103.31,78.63 109.5,78.63 109.5,80.23 103.31,80.23
VDDA_PLL2 on TOP: 105.03,87.52 105.03,85.36 106.03,85.36 106.29,85.61 111.38,85.61 111.38,87.52
VDDAR_0P85_SERDES0 on TOP: 72.9,77.48 75.69,77.48 75.69,75.71 72.9,75.71
VDDAR_0P85_SERDES0 on BOTTOM: 71.5,74.69 71.5,77.36 72.75,77.36 72.75,79.19 74.14,79.19 74.14,74.69
VDDAR_0P85_SERDES0 on L05_PWR1: 73.37,78.85 87.54,78.85 88.59,77.8 88.59,74.93 88.03,74.93 87.17,75.78 86.74,75.78 86.64,75.68 86.54,75.68 85.85,76.37 82.07,76.37 81.49,75.79 75.58,75.79 74.6,74.82 72.77,74.82 72.39,75.2 72.39,77.87
VDDAR_0P85_USB0 on BOTTOM: 72.75,81.96 72.75,80.02 74.52,80.02 74.52,74.78 76.54,74.78 76.71,74.94 76.71,75.88 76.12,76.47 76.12,81.96
VDDAR_CORE on TOP: 150.15,115.2 150.15,111.75 145.14,111.75 145.14,116.47 148.88,116.47
VDDAR_CORE on TOP: 113.28,96.03 113.28,90.87 119.76,90.87 119.94,91.05 119.94,93.69 119.89,93.74 116.33,93.74 116.08,93.99 116.08,95.77 115.82,96.03
VDDAR_CORE on BOTTOM: 150.15,116.47 150.15,111.75 150.11,111.75 150.5,111.37 150.5,105.55 149.86,104.92 148.59,104.92 147.57,105.93 147.57,109.32 145.14,111.75 145.14,116.47
VDDAR_CORE on L03_SIG1: 123.83,116.47 150.75,116.47 150.75,112.54 147.7,109.49 142.77,109.49 130.84,97.55 120.9,97.55 116.97,93.61 116.97,91.12 112.65,91.12 112.65,96.6 123.83,107.77
VDDC_1V2 on TOP: 163.32,21.86 163.32,23.18 168.04,23.18 168.04,21.86
VDDR_CORE on TOP: 107.19,80.34 107.19,78.63 111.72,78.63 111.72,80.34
VDDR_CORE on TOP: 116.68,80.48 116.68,80.02 118.92,80.02 118.97,80.08 118.97,81.85 118.85,81.98 118.85,83.68 119.3,84.14 120.65,84.14 120.65,89.53 120.65,89.96 115.42,89.96 115.42,81.75
VDDR_CORE on L05_PWR1: 88.88,75.77 90.45,77.34 90.45,78.65 90.57,78.77 91.57,78.77 91.7,78.64 91.7,77.4 90.73,76.44 90.73,74.89 93.9,71.72 98.04,71.72 100.15,69.61 110.36,69.61 111,70.25 111,76.21 109.47,77.74 109.47,80.79 109.6,80.91 113.46,80.91 116.36,83.81 118.49,83.81 118.49,82.31 119,81.8 119,80.15 118.52,79.67 118.52,76.1 118.49,76.08 118.49,74.24 112.09,67.83 111.49,67.83 109.29,65.64 97.57,65.64 95.38,67.83 90.81,67.83 88.88,69.76
VDDR_VTT on TOP: 84.33,95.39 96.77,95.39 96.77,97.92 98.68,97.92 98.68,93.61 82.65,93.61 81.15,95.12 81.15,97.93 83.06,97.93 84.07,96.92 84.07,95.65
VDDR_VTT on BOTTOM: 77.22,118.63 77.22,117.11 77.72,117.11 77.72,117.74 78.61,118.63 78.61,120.65 80.21,122.25 80.21,123.89 77.34,123.89 77.34,118.76
VDDR_VTT on BOTTOM: 81.41,95.51 81.41,106.87 83.95,106.87 83.95,95.9 84.96,94.88 94.17,94.88 94.17,91.9 92.81,91.9 92.81,92.53 92.26,93.08 83.84,93.08
VDDR_VTT on L05_PWR1: 76.96,124.09 76.96,121.55 78.23,120.28 78.23,117.11 81.92,113.43 81.92,95.26 96.79,95.26 101.73,100.2 101.73,106.19 86.23,106.19 86.23,117.74 78.99,124.98 77.85,124.98
VDDSHV_SD_IO on BOTTOM: 90.93,74.55 91.95,74.55 91.95,73.91 92.58,73.91 92.58,73.15 91.06,73.15 91.06,69.47 91.82,68.71 91.82,67.69 93.09,67.69 93.22,67.56 93.22,66.17 90.17,66.17 90.17,73.41 90.93,74.17
VDDSHV_SD_IO on L05_PWR1: 36.64,28.21 43.69,28.21 47.75,32.27 47.75,56.15 58.43,66.83 94.73,66.83 95.63,65.93 95.63,62.24 92.49,59.09 58.77,59.09 54.1,54.43 54.1,31.26 47.5,24.65 36.84,24.65 36.4,25.09 36.4,27.97
(no net) on TOP: outline of 87 points within 1.02,8.02 176.78,132.98 ; 54 cut-outs
(no net) on BOTTOM: 1.02,8.02 1.02,47.69 1.02,47.69 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.87 1.02,60.87 1.02,132.98 176.78,132.98 176.78,8.02 ; 114 cut-outs
(no net) on L03_SIG1: 1.02,8.02 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,132.98 176.78,132.98 176.78,44.62 176.2,44.62 174.73,43.16 176.2,41.69 176.78,41.69 176.78,39.87 176.2,39.87 174.73,38.41 176.2,36.94 176.78,36.94 176.78,27.48 176.2,27.48 174.73,26.01 176.2,24.55 176.78,24.55 176.78,22.73 176.2,22.73 174.73,21.26 176.2,19.8 176.78,19.8 176.78,8.02 ; 131 cut-outs
(no net) on L08_SIG2: 34.04,8.02 34.03,8.02 1.02,8.02 1.02,47.69 1.02,47.69 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.87 1.02,60.87 1.02,61.94 1.02,61.94 1.02,66.84 1.02,66.84 1.02,132.98 176.78,132.98 176.78,111.39 176.78,111.39 176.78,106.82 176.78,106.82 176.78,8.02 50.31,8.02 50.31,8.02 ; 140 cut-outs
CPSW_EARTH on TOP, BOTTOM: 2.79,90.69 1.02,92.47 1.02,110.5 8.38,110.5 8.89,110 8.89,97.05 11.18,94.76 14.48,94.76 15.49,93.74 15.49,91.2 14.99,90.69
DDR_VPP on BOTTOM: 87.38,109.49 87.38,109.97 86.33,111.02 83.39,111.02 83.39,109.35 86.6,109.35 86.74,109.49
DDR_VREFCA on BOTTOM: 78.03,115.58 78.03,112.59 79.37,112.59 79.37,115.58
FT4232_USB_VBUS on TOP: 170.88,41.92 170.88,46.24 172.28,46.24 172.28,41.92
FT4232_USB_VBUS on BOTTOM: 164.59,39.13 164.59,45.61 165.74,46.75 171.83,46.75 172.34,46.24 172.34,42.46 168.63,38.75 164.97,38.75
MAIN on TOP: 167.26,119.76 167.26,111.15 166.78,110.67 166.78,106.93 160.42,106.93 160.42,119.76
PRG_EARTH on L02_GND1, L04_GND2, L07_GND3, L09_GND4: 2.66,64.03 1.02,65.67 1.02,87.26 24.38,87.26 27.3,84.34 27.3,81.68 26.42,80.79 9.4,80.79 8.13,79.52 8.13,71.26 10.03,69.36 21.98,69.36 23.39,67.94 23.39,65.38 22.05,64.03
PRG_EARTH on L03_SIG1: 2.66,64.03 1.02,65.67 1.02,88.24 23.41,88.24 27.3,84.34 27.3,81.68 26.42,80.79 9.4,80.79 8.13,79.52 8.13,71.26 10.03,69.36 21.98,69.36 23.39,67.94 23.39,65.38 22.05,64.03
SHIELD on TOP, L02_GND1, L03_SIG1, L04_GND2, L07_GND3, L08_SIG2, L09_GND4: 168.73,110.49 168.73,114.25 173,114.25 173,121.31 172.57,121.74 168.73,121.74 168.73,124.56 176.59,124.56 176.59,110.49
SHIELD on BOTTOM: 168.73,109.17 168.73,114.25 173,114.25 173,121.31 172.57,121.74 168.73,121.74 168.73,124.56 176.59,124.56 176.59,109.17
SOC_DVDD1V8 on TOP: 106.23,74.82 109.44,74.82 109.44,73.04 106.23,73.04
SOC_DVDD1V8 on TOP, BOTTOM: 131.1,112.03 131.1,107.31 126.09,107.31 126.09,112.03
SOC_DVDD1V8 on L03_SIG1: 89.53,73.29 89.53,76.09 89.66,76.21 96.52,76.21 96.65,76.09 96.65,73.55 95.5,72.4 90.42,72.4
SOC_DVDD1V8 on L06_PWR2: 125.98,111.35 125.98,105.24 138.81,92.42 138.81,82.75 132.92,76.86 109.3,76.86 104.31,71.87 94.23,71.87 93.31,72.79 93.31,73.95 92.44,74.83 89.72,74.83 89.51,74.62 89.51,70.76 92.39,67.88 105.45,67.88 109,71.42 134.21,71.42 146.25,83.46 146.25,90.82 131.25,105.82 131.25,110.02 129.92,111.35
SOC_DVDD3V3 on TOP: 137.82,92.98 137.82,88.89 132.88,88.89 132.88,92.98
SOC_DVDD3V3 on BOTTOM: 102.83,73.27 105.53,73.27 105.53,74.86 102.83,74.86
SOC_DVDD3V3 on BOTTOM: 137.82,92.98 137.82,88.89 132.88,88.89 132.88,92.98
SOC_DVDD3V3 on L06_PWR2: 86.61,81.8 90.81,81.8 90.81,79.64 91.19,79.26 93.6,79.26 94.49,80.15 95.12,80.15 96.02,79.26 96.02,77.72 96.87,76.87 99.43,76.87 103.78,81.21 124.55,81.21 132.5,89.16 132.5,92.89 136.86,92.89 137.92,91.84 137.92,87.01 128.63,77.72 108.95,77.72 105.77,74.55 105.77,74.5 104.38,73.11 99.22,73.11 98.45,73.88 93.98,73.88 92.53,75.33 89.54,75.33 88.9,74.68 88.9,72.79 88.14,72.79 88.02,72.9 88.02,73.83 87.69,74.16 86.76,74.16 86.11,74.82 86.11,81.29
USB0_VBUS on TOP: 24.63,51.45 14.73,51.45 9.47,46.19 6.07,46.19 5.16,47.11 5.16,53.3 9.52,53.3 10.97,54.75 24.63,54.75
USB1_SHIELD on TOP: 1.02,49.04 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.85,57.18 2.7,57.5 1.02,57.5 1.02,61.53 5.11,61.53 5.61,61.03 5.61,56.58 5.38,56.35 5.38,49.04
USB1_SHIELD on L03_SIG1: 1.02,49.37 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,59.15 5.51,59.15 5.51,49.37
VMAIN on TOP: 163.85,78.7 167.35,78.7 167.35,73.73 156.67,73.73 156.67,78.2 160.09,78.2 160.09,84.09 163.85,84.09
VMAIN on TOP: 148.72,88.41 148.72,93.34 149.63,93.34 151.78,91.19 164.69,91.19 164.69,93.07 165.13,93.5 167.54,93.5 167.54,96.47 173.39,96.47 173.39,88.49 173.31,88.41
VMAIN on BOTTOM: 6.99,38.88 11.43,38.88 11.68,38.62 11.68,26.94 11.43,26.68 6.35,26.68 6.35,38.24
VMAIN on BOTTOM: 57.91,22.37 57.91,23.64 57.44,24.11 57.18,24.11 56.77,24.53 56.77,27.59 58.29,27.59 58.29,22.49 58.17,22.37
VMAIN on L03_SIG1: 151.64,51.96 151.64,79.64 158.75,86.76 170.05,86.76 172.21,84.6 172.21,81.04 173.35,79.9 173.35,49.8 171.83,48.27 155.32,48.27
VMAIN on L06_PWR2: 164.85,97.41 176.78,97.41 176.78,9.16 9.02,9.16 1.52,16.66 1.52,39.11 14.37,39.11 14.37,26.72 22.34,26.72 30.38,18.68 49.15,18.68 51.82,21.35 51.82,26.58 53.7,28.46 63.37,28.46 63.37,21.39 66.71,18.05 147.07,18.05 164.85,35.83
VPP_1V8 on BOTTOM: 138.81,106.19 138.81,102.38 141.35,102.38 142.37,103.39 142.37,106.19
VPP_DDR_2V5 on BOTTOM: 90.42,128.09 91.82,128.09 91.82,125.36 92.53,124.66 92.53,123.01 90.42,123.01
VPP_DDR_2V5 on BOTTOM: 82.85,108.47 82.85,111.15 80.69,111.15 80.69,108.47
XDS_SHIELD on TOP: 172.85,18.68 172.85,21.99 174.75,21.99 174.75,25.29 174.62,25.41 171.04,25.41 171.04,29.22 177.46,29.22 177.46,18.68
XDS_USB_VBUS on TOP: 167.26,11.78 167.26,13.81 164.2,13.81 164.2,12.86 165.28,11.78
XDS_USB_VBUS on L03_SIG1: 142.62,33.42 142.62,30.24 144.02,28.84 161.42,28.84 164.19,26.07 164.19,12.48 166.12,10.56 171.96,10.56 173.1,11.7 173.1,27.57 166.37,34.3 143.51,34.3
N17786037 on TOP: 32.69,115.33 32.69,121.27 39.75,121.27 39.75,118.51 33.53,118.51 33.02,118 33.02,115.33 33.02,115.33
N17839730 on TOP: 5.89,45.81 5.89,41.32 14.33,41.32 14.33,45.81
N18546005 on TOP: 167.23,108.25 171.08,108.25 171.08,103.3 172.31,102.06 172.31,96.82 167.34,96.82 167.13,96.62 167.13,94.13 166.98,93.98 164.82,93.98 164.74,94.06 164.74,95.99 163.86,96.88 162.05,96.88 162.05,100.3 162.1,100.3 167.23,105.44
N18968753 on TOP: 33.96,52.59 28.27,52.59 28.02,52.85 28.02,54.88 28.14,55.01 33.96,55.01
N19753729 on TOP: 167.58,82.27 171.13,82.27 171.13,65.29 167.77,65.29 167.77,69.83 166.33,71.26 166.33,76.3 167.58,76.3
N19753760 on TOP: 176.76,78.55 176.76,69.64 173.64,69.64 173.64,78.55
N19754201 on TOP: 151.92,64.04 151.92,65.75 150.37,67.31 150.37,71.37 151.92,72.93 151.92,82.13 156.03,82.13 156.03,64.04
N19754522 on TOP: 140.13,76.02 146.11,76.02 147.74,74.4 147.74,64.73 140.13,64.73
N26004036 on TOP: 149.95,93.53 151.71,91.76 157.46,91.76 157.46,94.49 149.9,94.49 149.9,93.53
N26016842 on BOTTOM: 57.77,21.1 58.29,21.1 58.29,13.73 56.36,13.73 56.36,18.25 57.77,19.66
N26733205 on TOP: 19.38,61.23 19.38,55.29 12.32,55.29 12.32,59.28 12.34,59.3 16.76,59.3 17.77,58.3 18.78,58.3 19.05,58.56 19.05,61.23 19.05,61.23
N26735457 on TOP: 98.81,119.29 92.96,119.29 92.96,126.35 95.89,126.35 95.89,119.87 96.14,119.62 98.8,119.62 98.81,119.62
N26735496 on BOTTOM: 134.22,122.17 134.22,118.76 140.76,118.76 140.76,122.17
N26736579 on TOP: 124.36,73.08 124.36,76.74 130.71,76.74 130.71,73.08

Small or netless copper shapes (teardrops, artwork): 1416 on TOP, 1186 on BOTTOM, 409 on L03_SIG1, 11 on L05_PWR1, 7 on L06_PWR2, 346 on L08_SIG2

## Text on the board
Ref Des/Assembly Bottom: A | PROC101A ASSEMBLY BOTTOM REV A
Ref Des/Silkscreen Bottom: PCIE RST SEL | A | PCIE PRSNT SEL | FOR EVALUATION ONLY; | NOT FCC APPROVED FOR RESALE
User.Comments: BOARD NAME: | AM64x EVM  BOARD | REV: A | DATE: 01/03/21 | DESCRIPTION: | SHEET | OF | 17 | PROC101A | SCALE: 1 | TEXAS INSTRUMENTS
Ref Des/Assembly Top: PROC101A ASSEMBLY TOP REV A
Ref Des/Silkscreen Top: FSI | CPSW PHY | MCAN1 | HSE | BOOTMODE 0-7 | GND | JTAG MUX SEL | VDD CORE | BOOTMODE 8-15 | I2C0 | VDDR CORE | ADC | MCU RST | SOC WARM RST | I2C1 | MCU RSTSTATz | UART | JTAG | OFF | ON | A | MCAN0 | ICSSG PHY | LATCH IN1 | SYNC OUT2 | LATCH IN0 | SYNC OUT0 | SOC/MCU GPIO | MCU WARM RST | SOC POR RST | RSTSTATz | PORz OUT | SYNC1 OUT | MCU PORz | SAFETY | 12V IN | OFF/ON SWITCH | DISPLAY | PCIE | ASSY# | SL# | AM64x/AM243x EVM | PROC101A | OPN# | USB2.0
PAGE_OUTLINE: LAYOUT BY | REVIEWED BY | APPROVED BY | SIGNATURES | AMB | UD | ZA | DATE | 030321 | SCALE: | SIZE | D | NONE | TEXAS INSTRUMENTS | AM64x  EVM  BOARD | SHEET 1 OF 17 | PROC101A | Rev | A
DISPLAY_TOP: 18. | 16. | 17. | FOR STACKUP DETAIL PROC101_STACKUP.PDF SHALL BE REFERRED. | ENSURE UL REGISTERED E-FILE NUMBER SHALL BE PRINTED ON THE PCB SILKSCREEN. | VIA ON PAD SHALL BE RESIN FILLED AND CAP-PLATED. | DETAIL-A
DIMENSION: 32.725 | BACKING PLATE OUTLINE | NON-PLATED MOUNTING HOLE | 30.225 | SOCKET OUTLINE | 4X | dia | 1.70 | 13.8625 | 8.7825 | 8.0000 | 0 | 0.80 | TYP | 441X | 0.42 | MIN  PADS | 11.3225 | NON-PLATED ALIGNMENT HOLE | 2X | 0.850
User.41: 03 | 04 | 01 | 02 | STRIPLINE | MICROSTRIP | EDGE COUPLED STRIPLINE | EDGE COUPLED MICROSTRIP | L3,L8 | L1,L10 | 3.7 | 4.2 | 5.8 | 9.05 | 3.6 | 6 | 4.4 | NA | 90 | 40 | 50 | L2/L4,L7/L9 | L2,L9
User.45: FIGURE | SIZE | 8.0 | 28.0 | 36.0 | 40.0 | 44.0 | 62.0 | 66.0 | 78.0 | 34.0 | 50.0 | 64.0 | 92.0 | 108.0 | 124.0 | 126.0 | 52.0x24.0 | 52.0x26.0 | 64.0x32.0 | 80.0x40.0 | 82.0x34.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | +1.0/-1.0 | PLATED | NON-PLATED | QTY | 3111 | 64 | 40 | 33 | 101 | 18 | 2 | 4 | 1 | 13 | 6 - Provide serial numbers to the assembled boards for identification. | 7 - The assembled board are wrapped in ESD Covers(individual) and packed securely before shipment. | ASSEMBLY NOTES:- | 1 - All MSL components should be baked as per JEDEC standard. | 2 - PCB should be baked at 120 degree for 8 hours. | 3 - Board assembly must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified. | 4 - These assemblies are ESD sensitive, ESD precautions shall be observed. | 5 - These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable. | PROC101 E2 ASSEMBLY TOP | PROC101 E2 ASSEMBLY BOTTOM
