# Allegro board PROC101A_BRD.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
FUSE_397_410X110_SMD_2-9
  rect 3.302x4.369 smd: 1(-5.045,0) 2(5.045,0)
HDR_1X2_68002-202_S_T_8-6
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(-2.54,0)
HDR_2X1_100_S_T
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(-2.54,0)
HDR_2X1_100_S_T_10-8
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(-2.54,0)
HDR_2X3_TSW-103-07-D_S_T_8-4
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54)
HDR_2X10_FTR-110-51-D-06_S_S_8-7
  rect 0.711x3.124 smd: 1(-5.715,-2.577) 2(-5.715,2.577) 3(-4.445,-2.577) 4(-4.445,2.577) 5(-3.175,-2.577) 7(-1.905,-2.577) 8(-1.905,2.577) 9(-0.635,-2.577) 10(-0.635,2.577) 11(0.635,-2.577) 12(0.635,2.577) 13(1.905,-2.577) 14(1.905,2.577) 15(3.175,-2.577) 16(3.175,2.577) 17(4.445,-2.577) 18(4.445,2.577) 19(5.715,-2.577) 20(5.715,2.577)
HDR_2X10_TSW_100_S_T
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(0,-2.54) 3(-2.54,0) 4(-2.54,-2.54) 5(-5.08,0) 6(-5.08,-2.54) 7(-7.62,0) 8(-7.62,-2.54) 9(-10.16,0) 10(-10.16,-2.54) 11(-12.7,0) 12(-12.7,-2.54) 13(-15.24,0) 14(-15.24,-2.54) 15(-17.78,0) 16(-17.78,-2.54) 17(-20.32,0) 18(-20.32,-2.54) 19(-22.86,0) 20(-22.86,-2.54)
HDR_2X12_TSW-112-07-D_S_T_8-6
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54) 11(12.7,0) 12(12.7,2.54) 13(15.24,0) 14(15.24,2.54) 15(17.78,0) 16(17.78,2.54) 17(20.32,0) 18(20.32,2.54) 19(22.86,0) 20(22.86,2.54) 21(25.4,0) 22(25.4,2.54) 23(27.94,0) 24(27.94,2.54)
HDR_3X1_100_S_T
  rect 1.803x1.803 hole 1.118: 1(0,0)
  round 1.803 hole 1.118: 2(-2.54,0) 3(-5.08,0)
HDR_5X1_100_S_T_11-2
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0) 5(-10.16,0)
HDR_5X2_100_S_T_8-6
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(0,-2.54) 3(-2.54,0) 4(-2.54,-2.54) 5(-5.08,0) 6(-5.08,-2.54) 7(-7.62,0) 8(-7.62,-2.54) 9(-10.16,0) 10(-10.16,-2.54)
IND4_ACM2012_90X50_SMD_1-3
  rect 0.762x0.406 smd: 1(-0.925,0.4) 2(-0.925,-0.4) 3(0.925,-0.4) 4(0.925,0.4)
IND0402_0-6
  rect 0.61x0.61 smd: 1(-0.46,0) 2(0.46,0)
IND0603_1
  rect 0.686x0.889 smd: 1(-0.7,0) 2(0.7,0)
IND_744316100_230X220_SMD_4-3
  rect 1.905x1.6 smd: 1(-2.05,0) 2(2.05,0)
IND_74438336100_130X130_SMD_2
  rect 1.295x3.404 smd: 1(-1.05,0) 2(1.05,0)
IND_74439346068_260X270_SMD_6-1
  rect 1.448x5.512 smd: 1(-2,0) 2(2,0)
IND_744373460047_270X270_SMD_3
  rect 2.946x3.505 smd: 1(-2.725,0) 2(2.725,0)
LED_150060RS55040_70X40_SMD_0-5
  rect 0.787x0.762 smd: 1(-0.8,0) 2(0.8,0)
LED_150060SS75000_70X40_SMD_0-8
  rect 0.787x0.787 smd: 1(-0.8,0) 2(0.8,0)
LED_150080VS75000_80X50_SMD_0-8
  rect 1.092x1.194 smd: 1(-1.05,0) 2(1.05,0)
LQFP64_19-68_390X390_1-6
  rect 1.499x0.305 smd: 1(-5.7,3.75) 2(-5.7,3.25) 3(-5.7,2.75) 4(-5.7,2.25) 5(-5.7,1.75) 6(-5.7,1.25) 7(-5.7,0.75) 8(-5.7,0.25) 9(-5.7,-0.25) 10(-5.7,-0.75) 11(-5.7,-1.25) 12(-5.7,-1.75) 13(-5.7,-2.25) 14(-5.7,-2.75) 15(-5.7,-3.25) 16(-5.7,-3.75) 33(5.7,-3.75) 34(5.7,-3.25) 35(5.7,-2.75) 36(5.7,-2.25) 37(5.7,-1.75) 38(5.7,-1.25) 39(5.7,-0.75) 40(5.7,-0.25) 41(5.7,0.25) 42(5.7,0.75) 43(5.7,1.25) 44(5.7,1.75) 45(5.7,2.25) 46(5.7,2.75) 47(5.7,3.25) 48(5.7,3.75)
  rect 0.305x1.499 smd: 17(-3.75,-5.7) 18(-3.25,-5.7) 19(-2.75,-5.7) 20(-2.25,-5.7) 21(-1.75,-5.7) 22(-1.25,-5.7) 23(-0.75,-5.7) 24(-0.25,-5.7) 25(0.25,-5.7) 26(0.75,-5.7) 27(1.25,-5.7) 28(1.75,-5.7) 29(2.25,-5.7) 30(2.75,-5.7) 31(3.25,-5.7) 32(3.75,-5.7) 49(3.75,5.7) 50(3.25,5.7) 51(2.75,5.7) 52(2.25,5.7) 53(1.75,5.7) 54(1.25,5.7) 55(0.75,5.7) 56(0.25,5.7) 57(-0.25,5.7) 58(-0.75,5.7) 59(-1.25,5.7) 60(-1.75,5.7) 61(-2.25,5.7) 62(-2.75,5.7) 63(-3.25,5.7) 64(-3.75,5.7)
MSOP8_25-59_125X125_1-1
  rect 1.651x0.457 smd: 1(-2.3,0.975) 2(-2.3,0.325) 3(-2.3,-0.325) 4(-2.3,-0.975) 5(2.3,-0.975) 6(2.3,-0.325) 7(2.3,0.325) 8(2.3,0.975)
MSOP10_19-68_120X120_1-1
  rect 1.448x0.305 smd: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
OSC4_ASFLMB_200X130_SMD
  rect 1.194x1.092 smd: 1(-1.27,-1.15) 2(1.27,-1.15) 3(1.27,1.15) 4(-1.27,1.15)
QFN16_19-68_160X140
  rect 0.864x0.279 smd: 1(-1.975,-0.75) 8(1.975,-0.75) 9(1.975,0.75) 16(-1.975,0.75)
  rect 0.279x0.864 smd: 2(-1.25,-1.725) 3(-0.75,-1.725) 4(-0.25,-1.725) 5(0.25,-1.725) 6(0.75,-1.725) 7(1.25,-1.725) 10(1.25,1.725) 11(0.75,1.725) 12(0.25,1.725) 13(-0.25,1.725) 14(-0.75,1.725) 15(-1.25,1.725)
  rect 2.54x2.057 smd: 17(0,0)
QFN24_19-68_160X160_0-8
  rect 0.711x0.305 smd: 1(-2.05,1.25) 2(-2.05,0.75) 3(-2.05,0.25) 4(-2.05,-0.25) 5(-2.05,-0.75) 6(-2.05,-1.25) 13(2.05,-1.25) 14(2.05,-0.75) 15(2.05,-0.25) 16(2.05,0.25) 17(2.05,0.75) 18(2.05,1.25)
  rect 0.305x0.711 smd: 7(-1.25,-2.05) 8(-0.75,-2.05) 9(-0.25,-2.05) 10(0.25,-2.05) 11(0.75,-2.05) 12(1.25,-2.05) 19(1.25,2.05) 20(0.75,2.05) 21(0.25,2.05) 22(-0.25,2.05) 23(-0.75,2.05) 24(-1.25,2.05)
  rect 2.896x2.896 smd: 25(0,0)
QFN24_19-68_160X160_1
  rect 0.711x0.305 smd: 1(-2.05,1.25) 2(-2.05,0.75) 3(-2.05,0.25) 4(-2.05,-0.25) 5(-2.05,-0.75) 6(-2.05,-1.25) 13(2.05,-1.25) 14(2.05,-0.75) 15(2.05,-0.25) 16(2.05,0.25) 17(2.05,0.75) 18(2.05,1.25)
  rect 0.305x0.711 smd: 7(-1.25,-2.05) 8(-0.75,-2.05) 9(-0.25,-2.05) 10(0.25,-2.05) 11(0.75,-2.05) 12(1.25,-2.05) 19(1.25,2.05) 20(0.75,2.05) 21(0.25,2.05) 22(-0.25,2.05) 23(-0.75,2.05) 24(-1.25,2.05)
  rect 2.896x2.896 smd: 25(0,0)
QFN24_19-68_220X140_1
  rect 0.838x0.279 smd: 1(-2.725,-0.75) 12(2.725,-0.75) 13(2.725,0.75) 24(-2.725,0.75)
  rect 0.279x0.838 smd: 2(-2.25,-1.725) 3(-1.75,-1.725) 4(-1.25,-1.725) 5(-0.75,-1.725) 6(-0.25,-1.725) 7(0.25,-1.725) 8(0.75,-1.725) 9(1.25,-1.725) 10(1.75,-1.725) 11(2.25,-1.725) 14(2.25,1.725) 15(1.75,1.725) 16(1.25,1.725) 17(0.75,1.725) 18(0.25,1.725) 19(-0.25,1.725) 20(-0.75,1.725) 21(-1.25,1.725) 22(-1.75,1.725) 23(-2.25,1.725)
  custom 0.508x0.508 smd: 25(0,0)
QFN32_19-68_200X200
  rect 0.94x0.305 smd: 1(-2.55,1.75) 2(-2.55,1.25) 3(-2.55,0.75) 4(-2.55,0.25) 5(-2.55,-0.25) 6(-2.55,-0.75) 7(-2.55,-1.25) 8(-2.55,-1.75) 17(2.55,-1.75) 18(2.55,-1.25) 19(2.55,-0.75) 20(2.55,-0.25) 21(2.55,0.25) 22(2.55,0.75) 23(2.55,1.25) 24(2.55,1.75)
  rect 0.305x0.94 smd: 9(-1.75,-2.55) 10(-1.25,-2.55) 11(-0.75,-2.55) 12(-0.25,-2.55) 13(0.25,-2.55) 14(0.75,-2.55) 15(1.25,-2.55) 16(1.75,-2.55) 25(1.75,2.55) 26(1.25,2.55) 27(0.75,2.55) 28(0.25,2.55) 29(-0.25,2.55) 30(-0.75,2.55) 31(-1.25,2.55) 32(-1.75,2.55)
  rect 3.556x3.556 smd: 33(0,0)
QFN32_19-68_200X200_1
  rect 0.94x0.305 smd: 1(-2.55,1.75) 2(-2.55,1.25) 3(-2.55,0.75) 4(-2.55,0.25) 5(-2.55,-0.25) 6(-2.55,-0.75) 7(-2.55,-1.25) 8(-2.55,-1.75) 17(2.55,-1.75) 18(2.55,-1.25) 19(2.55,-0.75) 20(2.55,-0.25) 21(2.55,0.25) 22(2.55,0.75) 23(2.55,1.25) 24(2.55,1.75)
  rect 0.305x0.94 smd: 9(-1.75,-2.55) 10(-1.25,-2.55) 11(-0.75,-2.55) 12(-0.25,-2.55) 13(0.25,-2.55) 14(0.75,-2.55) 15(1.25,-2.55) 16(1.75,-2.55) 25(1.75,2.55) 26(1.25,2.55) 27(0.75,2.55) 28(0.25,2.55) 29(-0.25,2.55) 30(-0.75,2.55) 31(-1.25,2.55) 32(-1.75,2.55)
  rect 3.556x3.556 smd: 33(0,0)
QFN40_19-68_240X240_0-9_EP3-4
  rect 0.889x0.305 smd: 1(-3.05,2.25) 2(-3.05,1.75) 3(-3.05,1.25) 4(-3.05,0.75) 5(-3.05,0.25) 6(-3.05,-0.25) 7(-3.05,-0.75) 8(-3.05,-1.25) 9(-3.05,-1.75) 10(-3.05,-2.25) 21(3.05,-2.25) 22(3.05,-1.75) 23(3.05,-1.25) 24(3.05,-0.75) 25(3.05,-0.25) 26(3.05,0.25) 27(3.05,0.75) 28(3.05,1.25) 29(3.05,1.75) 30(3.05,2.25)
  rect 0.305x0.889 smd: 11(-2.25,-3.05) 12(-1.75,-3.05) 13(-1.25,-3.05) 14(-0.75,-3.05) 15(-0.25,-3.05) 16(0.25,-3.05) 17(0.75,-3.05) 18(1.25,-3.05) 19(1.75,-3.05) 20(2.25,-3.05) 31(2.25,3.05) 32(1.75,3.05) 33(1.25,3.05) 34(0.75,3.05) 35(0.25,3.05) 36(-0.25,3.05) 37(-0.75,3.05) 38(-1.25,3.05) 39(-1.75,3.05) 40(-2.25,3.05)
  rect 3.404x3.404 smd: 41(0,0)
QFN48_19-68_280X280_1
  rect 0.813x0.305 smd: 1(-3.5,2.75) 2(-3.5,2.25) 3(-3.5,1.75) 4(-3.5,1.25) 5(-3.5,0.75) 6(-3.5,0.25) 7(-3.5,-0.25) 8(-3.5,-0.75) 9(-3.5,-1.25) 10(-3.5,-1.75) 11(-3.5,-2.25) 12(-3.5,-2.75) 25(3.5,-2.75) 26(3.5,-2.25) 27(3.5,-1.75) 28(3.5,-1.25) 29(3.5,-0.75) 30(3.5,-0.25) 31(3.5,0.25) 32(3.5,0.75) 33(3.5,1.25) 34(3.5,1.75) 35(3.5,2.25) 36(3.5,2.75)
  rect 0.305x0.813 smd: 13(-2.75,-3.5) 14(-2.25,-3.5) 15(-1.75,-3.5) 16(-1.25,-3.5) 17(-0.75,-3.5) 18(-0.25,-3.5) 19(0.25,-3.5) 20(0.75,-3.5) 21(1.25,-3.5) 22(1.75,-3.5) 23(2.25,-3.5) 24(2.75,-3.5) 37(2.75,3.5) 38(2.25,3.5) 39(1.75,3.5) 40(1.25,3.5) 41(0.75,3.5) 42(0.25,3.5) 43(-0.25,3.5) 44(-0.75,3.5) 45(-1.25,3.5) 46(-1.75,3.5) 47(-2.25,3.5) 48(-2.75,3.5)
  rect 5.639x5.639 smd: 49(0,0)
QFN48_19-68_280X280_1_EP4-2
  rect 0.838x0.305 smd: 1(-3.5,2.75) 2(-3.5,2.25) 3(-3.5,1.75) 4(-3.5,1.25) 5(-3.5,0.75) 6(-3.5,0.25) 7(-3.5,-0.25) 8(-3.5,-0.75) 9(-3.5,-1.25) 10(-3.5,-1.75) 11(-3.5,-2.25) 12(-3.5,-2.75) 25(3.5,-2.75) 26(3.5,-2.25) 27(3.5,-1.75) 28(3.5,-1.25) 29(3.5,-0.75) 30(3.5,-0.25) 31(3.5,0.25) 32(3.5,0.75) 33(3.5,1.25) 34(3.5,1.75) 35(3.5,2.25) 36(3.5,2.75)
  rect 0.305x0.838 smd: 13(-2.75,-3.5) 14(-2.25,-3.5) 15(-1.75,-3.5) 16(-1.25,-3.5) 17(-0.75,-3.5) 18(-0.25,-3.5) 19(0.25,-3.5) 20(0.75,-3.5) 21(1.25,-3.5) 22(1.75,-3.5) 23(2.25,-3.5) 24(2.75,-3.5) 37(2.75,3.5) 38(2.25,3.5) 39(1.75,3.5) 40(1.25,3.5) 41(0.75,3.5) 42(0.25,3.5) 43(-0.25,3.5) 44(-0.75,3.5) 45(-1.25,3.5) 46(-1.75,3.5) 47(-2.25,3.5) 48(-2.75,3.5)
  rect 4.191x4.191 smd: 49(0,0)
RES0402
  rect 0.508x0.508 smd: 1(-0.42,0) 2(0.42,0)
RES0402_0-5
  rect 0.559x0.635 smd: 1(-0.49,0) 2(0.49,0)
RES0402_0-5#2
  rect 0.483x0.508 smd: 1(-0.42,0) 2(0.42,0)
RES0402_0-75
  rect 0.686x0.737 smd: 1(-0.521,0) 2(0.521,0)
RES0603_0-75
  rect 0.635x0.991 smd: 1(-0.74,0) 2(0.74,0)
RES1206-4TERM_0-75
  rect 1.753x1.092 smd: 1(-1.375,0.7) 2(-1.375,-0.7) 3(1.375,-0.7) 4(1.375,0.7)
RES1206_0-75
  rect 1.194x1.854 smd: 1(-1.6,0) 2(1.6,0)
RES1210_0-75
  rect 1.346x2.794 smd: 1(-1.6,0) 2(1.6,0)
RES2512-4TERM_0-75
  rect 3.302x1.397 smd: 1(-2.15,-1.8) 2(2.15,-1.8) 3(2.15,1.8) 4(-2.15,1.8)
RESA_EXB2HV_0602-8_0-6
  rect 0.432x0.508 smd: 1(-1.837,-0.75) 8(1.837,-0.75) 9(1.837,0.75) 16(-1.837,0.75)
  rect 0.254x0.508 smd: 2(-1.25,-0.75) 3(-0.75,-0.75) 4(-0.25,-0.75) 5(0.25,-0.75) 6(0.75,-0.75) 7(1.25,-0.75) 10(1.25,0.75) 11(0.75,0.75) 12(0.25,0.75) 13(-0.25,0.75) 14(-0.75,0.75) 15(-1.25,0.75)
SC70-5
  rect 0.94x0.406 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0.65)
SC70-5#2
  rect 1.143x0.457 smd: 1(-1.199,0.65) 2(-1.199,0) 3(-1.199,-0.65) 4(1.199,-0.65) 5(1.199,0.65)
SC70-5_1-1
  rect 1.143x0.457 smd: 1(-1.199,0.65) 2(-1.199,0) 3(-1.199,-0.65) 4(1.199,-0.65) 5(1.199,0.65)
SC70-6
  rect 1.143x0.457 smd: 1(-1.199,0.65) 2(-1.199,0) 3(-1.199,-0.65) 4(1.199,-0.65) 5(1.199,0) 6(1.199,0.65)
SC70-6_1-1
  rect 1.143x0.457 smd: 1(-1.199,0.65) 2(-1.199,0) 3(-1.199,-0.65) 4(1.199,-0.65) 5(1.199,0) 6(1.199,0.65)
SC70-6_1-1#2
  rect 0.762x0.406 smd: 1(-1,0.65) 2(-1,0) 3(-1,-0.65) 4(1,-0.65) 5(1,0) 6(1,0.65)
SOIC8_1-8
  rect 1.549x0.61 smd: 1(-2.7,1.905) 2(-2.7,0.635) 3(-2.7,-0.635) 4(-2.7,-1.905) 5(2.7,-1.905) 6(2.7,-0.635) 7(2.7,0.635) 8(2.7,1.905)
SOIC16_1-8
  rect 1.753x0.66 smd: 1(-2.8,4.445) 2(-2.8,3.175) 3(-2.8,1.905) 4(-2.8,0.635) 5(-2.8,-0.635) 6(-2.8,-1.905) 7(-2.8,-3.175) 8(-2.8,-4.445) 9(2.8,-4.445) 10(2.8,-3.175) 11(2.8,-1.905) 12(2.8,-0.635) 13(2.8,0.635) 14(2.8,1.905) 15(2.8,3.175) 16(2.8,4.445)
SON6_19-68_40X60_0-6
  rect 0.838x0.254 smd: 1(-0.55,0.5) 2(-0.55,0) 3(-0.55,-0.5) 4(0.55,-0.5) 5(0.55,0) 6(0.55,0.5)
SON6_19-68_40X60_PB_0-6
  rect 0.406x0.305 smd: 1(-0.3,0.5) 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
SON6_25-59_85X85
  rect 0.711x0.356 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0) 6(1.1,0.65)
  rect 1.092x1.702 smd: 7(0,0)
SON6_25-59_85X85_0-8
  rect 0.711x0.356 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0) 6(1.1,0.65)
  rect 1.092x1.702 smd: 7(0,0)
SON6_SN74LVC2G17_40X60_0-6
  rect 0.356x0.203 smd: 1(-0.275,0.5)
  rect 0.305x0.203 smd: 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
SON8_25-59_130X130_1
  rect 0.94x0.356 smd: 1(-1.55,0.975) 2(-1.55,0.325) 3(-1.55,-0.325) 4(-1.55,-0.975) 5(1.55,-0.975) 6(1.55,-0.325) 7(1.55,0.325) 8(1.55,0.975)
  rect 1.753x2.515 smd: 9(0,0)
SON10_19-68_125X125_1
  rect 0.838x0.279 smd: 1(-1.475,1) 2(-1.475,0.5) 3(-1.475,0) 4(-1.475,-0.5) 5(-1.475,-1) 6(1.475,-1) 7(1.475,-0.5) 8(1.475,0) 9(1.475,0.5) 10(1.475,1)
  custom 0.412x0.412 smd: 11(0,0)
SOT23-5
  rect 1.295x0.66 smd: 1(-1.4,0.95) 2(-1.4,0) 3(-1.4,-0.95) 4(1.4,-0.95) 5(1.4,0.95)
SOT23-5_1-5
  rect 1.092x0.61 smd: 1(-1.3,0.95) 2(-1.3,0) 3(-1.3,-0.95) 4(1.3,-0.95) 5(1.3,0.95)
SOT23-5_1-5#2
  rect 1.295x0.66 smd: 1(-1.4,0.95) 2(-1.4,0) 3(-1.4,-0.95) 4(1.4,-0.95) 5(1.4,0.95)
SOT23-6
  rect 1.041x0.61 smd: 1(-1.35,0.95) 2(-1.35,0) 3(-1.35,-0.95) 4(1.35,-0.95) 5(1.35,0) 6(1.35,0.95)
SOT23-6_1-1
  rect 1.295x0.66 smd: 1(-1.4,0.95) 2(-1.4,0) 3(-1.4,-0.95) 4(1.4,-0.95) 5(1.4,0) 6(1.4,0.95)
SOT23-6_1-5
  rect 1.295x0.66 smd: 1(-1.4,0.95) 2(-1.4,0) 3(-1.4,-0.95) 4(1.4,-0.95) 5(1.4,0) 6(1.4,0.95)
SOT23-123_1-2
  rect 0.838x0.61 smd: 1(-1.05,0.95) 2(-1.05,-0.95) 3(1.05,0)
SW3_ATE1F-6M3_370X710_TH_5-6
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(-2.54,0) 3(-5.08,0) SH1(-5.08,-7.62) SH2(0,-7.62)
SW4_SKHMQLE010_240X260_SMD_3-1
  rect 1.6x1.397 smd: 1(-4.2,2.25) 2(4.2,2.25) 3(-4.2,-2.25) 4(4.2,-2.25) 5(4.2,0)
SW8_218-8LPST_450X230_SMD_2-7
  rect 0.762x1.27 smd: 1(-4.445,-3.81) 2(-3.175,-3.81) 3(-1.905,-3.81) 4(-0.635,-3.81) 5(0.635,-3.81) 6(1.905,-3.81) 7(3.175,-3.81) 8(4.445,-3.81) 9(4.445,3.81) 10(3.175,3.81) 11(1.905,3.81) 12(0.635,3.81) 13(-0.635,3.81) 14(-1.905,3.81) 15(-3.175,3.81) 16(-4.445,3.81)
TO_SOT23-123
  rect 1.27x0.66 smd: 1(-1.25,0.95) 2(-1.25,-0.95) 3(1.25,0)
TO_SOT23-123#2
  rect 0.838x0.61 smd: 1(-1.05,0.95) 2(-1.05,-0.95) 3(1.05,0)
TP20_SMD
  round 0.457 smd: 1(0,0)
TP40_SMD
  round 1.016 smd: 1(0,0)
TP_40X65
  round 1.651 hole 1.016: 1(0,0)
TP_CIR67D40_TH_4-6
  round 1.702 hole 1.016: 1(0,0)
TQFN42_19-68_140X360_0-8
  rect 0.838x0.305 smd: 1(-1.7,4) 2(-1.7,3.5) 3(-1.7,3) 4(-1.7,2.5) 5(-1.7,2) 6(-1.7,1.5) 7(-1.7,1) 8(-1.7,0.5) 9(-1.7,0) 10(-1.7,-0.5) 11(-1.7,-1) 12(-1.7,-1.5) 13(-1.7,-2) 14(-1.7,-2.5) 15(-1.7,-3) 16(-1.7,-3.5) 17(-1.7,-4) 22(1.7,-4) 23(1.7,-3.5) 24(1.7,-3) 25(1.7,-2.5) 26(1.7,-2) 27(1.7,-1.5) 28(1.7,-1) 29(1.7,-0.5) 30(1.7,0) 31(1.7,0.5) 32(1.7,1) 33(1.7,1.5) 34(1.7,2) 35(1.7,2.5) 36(1.7,3) 37(1.7,3.5) 38(1.7,4)
  rect 0.305x0.838 smd: 18(-0.75,-4.45) 19(-0.25,-4.45) 20(0.25,-4.45) 21(0.75,-4.45) 39(0.75,4.45) 40(0.25,4.45) 41(-0.25,4.45) 42(-0.75,4.45)
  rect 2.159x7.645 smd: 43(0,0)
TQFP128_15-74_550X550_1-2
  rect 1.499x0.203 smd: 1(-7.7,6.2) 2(-7.7,5.8) 3(-7.7,5.4) 4(-7.7,5) 5(-7.7,4.6) 6(-7.7,4.2) 7(-7.7,3.8) 8(-7.7,3.4) 9(-7.7,3) 10(-7.7,2.6) 11(-7.7,2.2) 12(-7.7,1.8) 13(-7.7,1.4) 14(-7.7,1) 15(-7.7,0.6) 16(-7.7,0.2) 17(-7.7,-0.2) 18(-7.7,-0.6) 19(-7.7,-1) 20(-7.7,-1.4) 21(-7.7,-1.8) 22(-7.7,-2.2) 23(-7.7,-2.6) 24(-7.7,-3) 25(-7.7,-3.4) 26(-7.7,-3.8) 27(-7.7,-4.2) 28(-7.7,-4.6) 29(-7.7,-5) 30(-7.7,-5.4) 31(-7.7,-5.8) 32(-7.7,-6.2) 65(7.7,-6.2) 66(7.7,-5.8) 67(7.7,-5.4) 68(7.7,-5) 69(7.7,-4.6) 70(7.7,-4.2) 71(7.7,-3.8) 72(7.7,-3.4) 73(7.7,-3) 74(7.7,-2.6) 75(7.7,-2.2) 76(7.7,-1.8) 77(7.7,-1.4) 78(7.7,-1) 79(7.7,-0.6) 80(7.7,-0.2) 81(7.7,0.2) 82(7.7,0.6) 83(7.7,1) 84(7.7,1.4) 85(7.7,1.8) 86(7.7,2.2) 87(7.7,2.6) 88(7.7,3) 89(7.7,3.4) 90(7.7,3.8) 91(7.7,4.2) 92(7.7,4.6) 93(7.7,5) 94(7.7,5.4) 95(7.7,5.8) 96(7.7,6.2)
  rect 0.203x1.499 smd: 33(-6.2,-7.7) 34(-5.8,-7.7) 35(-5.4,-7.7) 36(-5,-7.7) 37(-4.6,-7.7) 38(-4.2,-7.7) 39(-3.8,-7.7) 40(-3.4,-7.7) 41(-3,-7.7) 42(-2.6,-7.7) 43(-2.2,-7.7) 44(-1.8,-7.7) 45(-1.4,-7.7) 46(-1,-7.7) 47(-0.6,-7.7) 48(-0.2,-7.7) 49(0.2,-7.7) 50(0.6,-7.7) 51(1,-7.7) 52(1.4,-7.7) 53(1.8,-7.7) 54(2.2,-7.7) 55(2.6,-7.7) 56(3,-7.7) 57(3.4,-7.7) 58(3.8,-7.7) 59(4.2,-7.7) 60(4.6,-7.7) 61(5,-7.7) 62(5.4,-7.7) 63(5.8,-7.7) 64(6.2,-7.7) 97(6.2,7.7) 98(5.8,7.7) 99(5.4,7.7) 100(5,7.7) 101(4.6,7.7) 102(4.2,7.7) 103(3.8,7.7) 104(3.4,7.7) 105(3,7.7) 106(2.6,7.7) 107(2.2,7.7) 108(1.8,7.7) 109(1.4,7.7) 110(1,7.7) 111(0.6,7.7) 112(0.2,7.7) 113(-0.2,7.7) 114(-0.6,7.7) 115(-1,7.7) 116(-1.4,7.7) 117(-1.8,7.7) 118(-2.2,7.7) 119(-2.6,7.7) 120(-3,7.7) 121(-3.4,7.7) 122(-3.8,7.7) 123(-4.2,7.7) 124(-4.6,7.7) 125(-5,7.7) 126(-5.4,7.7) 127(-5.8,7.7) 128(-6.2,7.7)
TSSOP8_25-59_125X180_1-2
  rect 1.702x0.457 smd: 1(-3,0.975) 2(-3,0.325) 3(-3,-0.325) 4(-3,-0.975) 5(3,-0.975) 6(3,-0.325) 7(3,0.325) 8(3,0.975)
TSSOP16_25-59_205X180
  rect 1.702x0.457 smd: 1(-3,2.275) 2(-3,1.625) 3(-3,0.975) 4(-3,0.325) 5(-3,-0.325) 6(-3,-0.975) 7(-3,-1.625) 8(-3,-2.275) 9(3,-2.275) 10(3,-1.625) 11(3,-0.975) 12(3,-0.325) 13(3,0.325) 14(3,0.975) 15(3,1.625) 16(3,2.275)
TSSOP16_25-59_205X180_1-2
  rect 1.702x0.457 smd: 1(-3,2.275) 2(-3,1.625) 3(-3,0.975) 4(-3,0.325) 5(-3,-0.325) 6(-3,-0.975) 7(-3,-1.625) 8(-3,-2.275) 9(3,-2.275) 10(3,-1.625) 11(3,-0.975) 12(3,-0.325) 13(3,0.325) 14(3,0.975) 15(3,1.625) 16(3,2.275)
unnamed
  round 2.616 hole 2.743 unplated: (0,0)
unnamed#3
  round 1.549 hole 1.676 unplated: (-13.862,13.862) (-13.862,-13.862) (13.862,13.862) (13.862,-13.862)
  round 0.737 hole 0.864 unplated: (-13.862,-8.782) (13.862,11.322)
UQFN10_19-68_80X60_0-6
  rect 0.584x0.305 smd: 1(-0.635,0.75) 4(-0.635,-0.75) 6(0.635,-0.75) 9(0.635,0.75)
  rect 0.584x0.254 smd: 2(-0.635,0.25) 3(-0.635,-0.25) 7(0.635,-0.25) 8(0.635,0.25)
  rect 0.305x0.635 smd: 5(0,-0.86) 10(0,0.86)
UQFN16_TMUX1574_70X100_0-6
  rect 0.711x0.203 smd: 1(-0.75,0.6)
  rect 0.61x0.203 smd: 2(-0.8,0.2) 3(-0.8,-0.2) 4(-0.8,-0.6) 9(0.8,-0.6) 10(0.8,-0.2) 11(0.8,0.2) 12(0.8,0.6)
  rect 0.203x0.61 smd: 5(-0.6,-1.2) 6(-0.2,-1.2) 7(0.2,-1.2) 8(0.6,-1.2) 13(0.6,1.2) 14(0.2,1.2) 15(-0.2,1.2) 16(-0.6,1.2)
USIP8_TPS82084_110X120_1-4
  rect 0.61x0.508 smd: 1(-1.1,0.975) 2(-1.1,0.325) 3(-1.1,-0.325) 4(-1.1,-0.975) 5(1.1,-0.975) 6(1.1,-0.325) 7(1.1,0.325) 8(1.1,0.975)
  rect 1.194x2.007 smd: 9(0,0)
VFBGA153_19-68_460X520_1-1
  round 0.203 smd: A1(-3.25,3.25) A2(-2.75,3.25) A3(-2.25,3.25) A4(-1.75,3.25) A5(-1.25,3.25) A6(-0.75,3.25) B1(-3.25,2.75) C1(-3.25,2.25) D1(-3.25,1.75) M1(-3.25,-2.25) N1(-3.25,-2.75) P1(-3.25,-3.25)
  round 0.254 smd: A7(-0.25,3.25) A8(0.25,3.25) A9(0.75,3.25) A10(1.25,3.25) A11(1.75,3.25) A12(2.25,3.25) A13(2.75,3.25) A14(3.25,3.25) B2(-2.75,2.75) B3(-2.25,2.75) B4(-1.75,2.75) B5(-1.25,2.75) B6(-0.75,2.75) B7(-0.25,2.75) B8(0.25,2.75) B9(0.75,2.75) B10(1.25,2.75) B11(1.75,2.75) B12(2.25,2.75) B13(2.75,2.75) B14(3.25,2.75) C2(-2.75,2.25) C3(-2.25,2.25) C4(-1.75,2.25) C5(-1.25,2.25) C6(-0.75,2.25) C7(-0.25,2.25) C8(0.25,2.25) C9(0.75,2.25) C10(1.25,2.25) C11(1.75,2.25) C12(2.25,2.25) C13(2.75,2.25) C14(3.25,2.25) D2(-2.75,1.75) D3(-2.25,1.75) D4(-1.75,1.75) D12(2.25,1.75) D13(2.75,1.75) D14(3.25,1.75) E1(-3.25,1.25) E2(-2.75,1.25) E3(-2.25,1.25) E5(-1.25,1.25) E6(-0.75,1.25) E7(-0.25,1.25) E8(0.25,1.25) E9(0.75,1.25) E10(1.25,1.25) E12(2.25,1.25) E13(2.75,1.25) E14(3.25,1.25) F1(-3.25,0.75) F2(-2.75,0.75) F3(-2.25,0.75) F5(-1.25,0.75) F10(1.25,0.75) F12(2.25,0.75) F13(2.75,0.75) F14(3.25,0.75) G1(-3.25,0.25) G2(-2.75,0.25) G3(-2.25,0.25) G5(-1.25,0.25) G10(1.25,0.25) G12(2.25,0.25) G13(2.75,0.25) G14(3.25,0.25) H1(-3.25,-0.25) H2(-2.75,-0.25) H3(-2.25,-0.25) H5(-1.25,-0.25) H10(1.25,-0.25) H12(2.25,-0.25) H13(2.75,-0.25) H14(3.25,-0.25) J1(-3.25,-0.75) J2(-2.75,-0.75) J3(-2.25,-0.75) J5(-1.25,-0.75) J10(1.25,-0.75) J12(2.25,-0.75) J13(2.75,-0.75) J14(3.25,-0.75) K1(-3.25,-1.25) K2(-2.75,-1.25) K3(-2.25,-1.25) K5(-1.25,-1.25) K6(-0.75,-1.25) K7(-0.25,-1.25) K8(0.25,-1.25) K9(0.75,-1.25) K10(1.25,-1.25) K12(2.25,-1.25) K13(2.75,-1.25) K14(3.25,-1.25) L1(-3.25,-1.75) L2(-2.75,-1.75) L3(-2.25,-1.75) L12(2.25,-1.75) L13(2.75,-1.75) L14(3.25,-1.75) M2(-2.75,-2.25) M3(-2.25,-2.25) M4(-1.75,-2.25) M5(-1.25,-2.25) M6(-0.75,-2.25) M7(-0.25,-2.25) M8(0.25,-2.25) M9(0.75,-2.25) M10(1.25,-2.25) M11(1.75,-2.25) M12(2.25,-2.25) M13(2.75,-2.25) M14(3.25,-2.25) N2(-2.75,-2.75) N3(-2.25,-2.75) N4(-1.75,-2.75) N5(-1.25,-2.75) N6(-0.75,-2.75) N7(-0.25,-2.75) N8(0.25,-2.75) N9(0.75,-2.75) N10(1.25,-2.75) N11(1.75,-2.75) N12(2.25,-2.75) N13(2.75,-2.75) N14(3.25,-2.75) P2(-2.75,-3.25) P3(-2.25,-3.25) P4(-1.75,-3.25) P5(-1.25,-3.25) P6(-0.75,-3.25) P7(-0.25,-3.25) P8(0.25,-3.25) P9(0.75,-3.25) P10(1.25,-3.25) P11(1.75,-3.25) P12(2.25,-3.25) P13(2.75,-3.25) P14(3.25,-3.25)
VQFNHR11_TPS62097_80X80_1
  rect 1.143x0.305 smd: 1(-0.675,0.225) 7(0.675,0.225)
  rect 2.489x0.305 smd: 2(0,-0.225)
  rect 0.254x0.584 smd: 3(-0.75,-0.912) 4(-0.25,-0.912) 5(0.25,-0.912) 6(0.75,-0.912) 8(0.75,0.912) 9(0.25,0.912) 10(-0.25,0.912) 11(-0.75,0.912)
VSONHR7_TPS62085_80X80_1
  rect 0.61x0.254 smd: 1(-0.9,0.75) 2(-0.9,0.25) 3(-0.9,-0.25) 4(-0.9,-0.75)
  rect 1.651x0.457 smd: 5(0.45,-0.6) 6(0.45,0) 7(0.45,0.6)
VSONHR8_TPS62823_60X80_1
  rect 0.559x0.254 smd: 1(-0.675,0.75) 2(-0.675,0.25) 3(-0.675,-0.25) 4(-0.675,-0.75) 5(0.675,-0.75) 6(0.675,-0.25) 7(0.675,0.25) 8(0.675,0.75)
VSONP8_CSD18543Q_120X130_0-9
  rect 0.711x0.406 smd: 1(-1.55,0.975) 2(-1.55,0.325) 3(-1.55,-0.325) 4(-1.55,-0.975)
  rect 2.515x2.54 smd: 5(0.645,0)
VSSOP8_19-68_85X95_0-9
  rect 1.041x0.305 smd: 1(-1.65,0.75) 2(-1.65,0.25) 3(-1.65,-0.25) 4(-1.65,-0.75) 5(1.65,-0.75) 6(1.65,-0.25) 7(1.65,0.25) 8(1.65,0.75)
VSSOP8_25-59_120X120_1-1
  rect 1.651x0.457 smd: 1(-2.3,0.975) 2(-2.3,0.325) 3(-2.3,-0.325) 4(-2.3,-0.975) 5(2.3,-0.975) 6(2.3,-0.325) 7(2.3,0.325) 8(2.3,0.975)
WSON10_19-68_80X120_0-8
  rect 0.787x0.305 smd: 1(-1.1,1) 2(-1.1,0.5) 3(-1.1,0) 4(-1.1,-0.5) 5(-1.1,-1) 6(1.1,-1) 7(1.1,-0.5) 8(1.1,0) 9(1.1,0.5) 10(1.1,1)
  rect 0.94x2.489 smd: 11(0,0)
X2SON4_TLV71318P_40X40_0-4
  custom 0.077x0.077 smd: 1(-0.43,0.325) 2(-0.43,-0.325) 3(0.43,-0.325) 4(0.43,0.325)
  rect 0.584x0.584 smd rot 135: 5(0,0)
X2SON8_15-74_70X50
  rect 0.94x0.203 smd: 1(-0.6,0.6) 2(-0.6,0.2) 3(-0.6,-0.2) 4(-0.6,-0.6) 5(0.6,-0.6) 6(0.6,-0.2) 7(0.6,0.2) 8(0.6,0.6)
XTAL4_ABM10W_100X80_SMD_0-6
  rect 1.194x0.838 smd: 1(-0.812,-0.6) 2(0.812,-0.6) 3(0.812,0.6) 4(-0.812,0.6)
XTAL4_NX3225GA_130X100_SMD_0-9
  rect 1.422x1.219 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTAL_ABM3_205X130_SMD_1-4
  rect 1.803x2.413 smd: 1(-1.9,0) 2(1.9,0)

## Nets
3V3_AUX: J27.B10(3.3VAUX) R493.2
DGND: C1.2 C2.2 C3.2 C4.1 C5.1 C6.2 C7.1 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.1 C22.1 C23.1 C24.1 C25.2 C26.2 C27.1 C28.2 C29.2 C30.1 C31.1 C32.2 C33.2 C34.1 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.1 C43.2 C44.2 C45.2 C46.2 C48.1 C49.2 C50.2 C51.2 C52.2 C53.1 C55.1 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.1 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.1 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C86.1 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C95.2 C97.2 C98.1 C99.2 C101.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.1 C114.2 C117.1 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.1 C134.1 C135.2 C136.2 C137.1 C138.2 C139.1 C140.2 C141.2 C143.2 C144.1 C145.1 C146.1 C147.2 C148.2 C149.2 C150.2 C151.1 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.2 C159.1 C160.1 C161.2 C162.1 C163.1 C164.1 C165.1 C166.2 C167.2 C168.2 C169.2 C170.2 C171.1 C172.1 C173.1 C174.2 C175.2 C176.2 C177.1 C178.1 C179.1 C180.2 C181.2 C182.1 C183.1 C184.2 C185.1 C186.2 C187.2 C188.1 C189.1 C190.1 C191.2 C192.1 C193.1 C194.1 C195.2 C196.1 C197.2 C199.1 C200.2 C201.2 C202.2 C205.2 C206.2 C207.1 C208.2 C209.2 C210.1 C211.2 C212.2 C213.1 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.1 C222.2 C223.2 C224.2 C225.1 C226.1 C227.1 C228.2 C229.2 C230.2 C231.1 C232.2 C233.2 C234.2 C236.2 C237.2 C238.2 C239.2 C240.1 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C249.2 C250.2 C251.2 C252.1 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C270.1 C271.1 C273.1 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.1 C283.1 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C301.2 C302.2 C303.2 C304.2 C305.2 C306.2 C307.2 C308.2 C309.2 C310.2 C311.2 C312.2 C313.2 C314.2 C315.2 C316.2 C317.2 C318.2 C319.2 C320.2 C321.2 C322.2 C323.2 C324.2 C325.2 C326.2 C327.2 C328.2 C329.2 C330.2 C331.2 C332.2 C333.2 C334.2 C335.2 C336.2 C337.2 C338.2 C339.2 C340.2 C341.2 C342.2 C343.2 C344.2 C345.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.2 C358.2 C359.2 C360.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.1 C367.2 C368.2 C369.2 C370.2 C371.2 C372.2 C373.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C384.2 C385.2 C387.2 C388.2 C389.2 C390.2 C391.2 C392.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.2 C407.1 C408.1 C409.1 C410.1 C411.1 C412.1 C413.1 C414.1 C415.2 C416.1 C417.2 C418.2 C419.1 C420.1 C421.2 C422.1 C423.1 C424.1 C425.1 C426.2 C427.2 C428.2 C429.1 C430.2 C431.2 C432.2 C433.2 C434.2 C435.2 C436.2 C437.2 C438.2 C439.2 C440.1 C441.2 C442.1 C443.2 C444.1 C445.1 C446.2 C447.1 C448.2 C449.2 C450.2 C451.2 C452.2 C453.1 C455.2 C456.1 C457.1 C458.2 C459.2 C461.1 C462.1 C463.1 C464.1 C465.1 C466.1 C467.1 C468.1 C469.2 C470.1 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C477.2 C478.2 C479.2 C482.2 C483.2 C484.2 C485.1 C486.2 C487.2 C488.2 C491.2 C492.2 C493.2 C494.1 C495.1 C500.2 C509.2 C513.2 C517.2 C519.2 C520.2 C521.2 C522.2 C523.2 C524.2 C525.2 C526.2 C527.2 C529.1 C532.1 C533.1 D1.2(ANODE) D2.2(A) D6.1 D7.1(A) D8.1 D9.1 D10.1 D11.1 FB8.2 FL7.2(GND) FL17.2(GND1) FL18.2(GND1) FL19.2(GND1) FL20.2(GND1) J1.23 J2.A6 J2.A10 J2.A16 J2.A18 J2.A23 J2.A24 J2.A25 J2.B3 J2.B5 J2.B6 J2.B10 J2.B16 J2.B18 J2.B19 J2.B23 J2.B25 J2.B26 J2.B27 J2.B28 J2.B30 J2.C4 J2.C7 J2.C10 J2.C13 J2.C16 J2.C17 J2.C18 J2.C19 J2.C20 J2.C25 J2.C30 J2.D4 J2.D7 J2.D10 J2.D13 J2.D16 J2.D20 J2.D25 J2.D30 J2.E5 J2.E6 J2.E7 J2.E10 J2.E16 J2.E20 J2.E22 J2.E25 J2.E28 J2.E29 J3.1 J3.5 J3.8 J3.9 J3.12 J3.13 J3.16 J3.20 J4.3 J5.1 J6.2 J7.3 J7.4 J12.2 J15.2 J16.2 J17.2 J18.2 J21.A10(GND) J21.B10(GND) J23.6 J24.5(GND) J25.10 J25.12 J25.16 J25.20 J26.5(GND) J27.A4(GND#A4) J27.A12(GND#A12) J27.A15(GND#A15) J27.A18(GND#A18) J27.A20(GND#A20) J27.A23(GND#A23) J27.A24(GND#A24) J27.A27(GND#A27) J27.A28(GND#A28) J27.A31(GND#A31) J27.B4(GND#B4) J27.B7(GND#B7) J27.B13(GND#B13) J27.B16(GND#B16) J27.B18(GND#B18) J27.B21(GND#B21) J27.B22(GND#B22) J27.B25(GND#B25) J27.B26(GND#B26) J27.B29(GND#B29) J27.B32(GND#B32) J28.5(GND) J29.3 J31.2 J32.2 J33.16 J33.57 J33.61 J33.62 J33.63 J33.64 J36.8 J37.6(VSS) J37.10 J37.11 J37.12(CD2) J37.13 J37.14 J38.7 J38.16 J38.25 J38.34 J38.40 J38.41 J38.42 LD4.1(CATHODE) LD6.1(CATHODE) LD9.1(CATHODE) LD15.1(CATHODE) LD20.1(CATHODE) LD22.1(CATHODE) LD24.1(CATHODE) LD25.1(CATHODE) Q1.2(S) Q2.2(S) Q3.2(S) Q4.2(S) Q5.2(S) Q6.2(S) Q7.2(S) Q8.3(D) Q9.3(D) Q10.3(D) Q11.2(S) Q12.2(S) Q13.2(S) Q14.2(S) Q15.2(S) Q16.2(S) Q17.3(D) Q18.2(S) Q19.2(S) Q20.2(S) Q21.2(S) R8.1 R9.1 R16.2 R17.1 R21.2 R23.2 R26.1 R29.2 R31.2 R34.2 R36.2 R38.2 R40.1 R45.2 R49.2 R52.2 R53.2 R54.2 R59.2 R60.2 R61.2 R62.1 R65.2 R66.1 R68.1 R70.2 R93.1 R96.2 R97.2 R100.2 R102.2 R107.2 R108.2 R110.1 R115.2 R117.1 R120.2 R121.2 R124.1 R132.2 R135.2 R140.1 R145.2 R148.1 R151.2 R154.2 R167.2 R170.1 R175.1 R177.1 R182.1 R183.2 R198.2 R205.2 R206.1 R207.1 R208.1 R209.1 R213.2 R218.2 R231.2 R240.2 R241.2 R245.2 R247.2 R249.2 R251.2 R254.1 R257.2 R260.2 R262.1 R263.1 R268.2 R283.2 R292.2 R294.2 R299.2 R301.2 R304.2 R315.2 R320.2 R322.2 R333.2 R338.2 R341.2 R344.1 R346.2 R348.1 R349.1 R356.1 R359.2 R363.2 R364.2 R367.2 R371.2 R385.2 R386.2 R397.1 R400.1 R401.1 R402.1 R405.2 R409.1 R413.1 R430.2 R436.2 R437.1 R444.1 R445.1 R452.1 R453.2 R468.2 R473.2 R474.2 R488.2 R489.2 R497.2 R498.2 R502.2 R503.2 R507.1 R509.2 R510.2 R513.2 R514.2 R518.2 R519.2 R528.2 R529.2 R531.1 R532.1 R541.1 R549.1 R554.1 R555.1 R561.2 R563.2 R565.2 R566.2 R602.1 R605.2 R606.2 R622.1 R623.1 R630.1 R631.1 R636.2 R638.2 R643.1 R644.2 R645.2 R656.2 R681.2 R682.2 R683.2 R684.2 R687.2 SW1.1 SW1.SH1 SW1.SH2 SW4.3 SW4.4 SW4.5(GND) SW5.3 SW5.4 SW5.5(GND) SW6.3 SW6.4 SW6.5(GND) SW7.3 SW7.4 SW7.5(GND) TP2.1(TP) TP3.1(TP) TP5.1(TP) TP26.1(TP) TP31.1(TP) TP34.1(TP) TP54.1(TP) TP63.1(TP) U1.7(GND) U2.2(GND) U3.2(GND) U4.2(GND) U5.1(PGND) U5.11(AGND) U6.1(A1) U6.7(GND) U7.4(GND) U8.2(GND) U8.25(PAD) U9.1(PGND) U9.11(AGND) U10.2(GND) U11.7(GND) U12.5(GND#5) U12.6(GND#6) U12.9(EP) U13.A2(VSSQ#A2) U13.A8(VSSQ#A8) U13.B2(VSS#B2) U13.C9(VSSQ#C9) U13.D2(VSSQ#D2) U13.D8(VSSQ#D8) U13.E1(VSS#E1) U13.E3(VSSQ#E3) U13.E8(VSSQ#E8) U13.E9(VSS#E9) U13.F1(VSSQ#F1) U13.G8(VSS#G8) U13.H1(VSSQ#H1) U13.H9(VSSQ#H9) U13.K1(VSS#K1) U13.K9(VSS#K9) U13.M9(VSS#M9) U13.N1(VSS#N1) U13.T1(VSS#T1) U14.1(A1) U14.2(A0) U14.7(GND) U15.49(GND) U16.2(A0) U16.7(GND) U17.3(GND#3) U17.4(GND#4) U17.5(GND#5) U17.11(EP) U18.2(GND) U19.3(GND) U20.49(GND) U21.1(S1) U21.2(S2) U21.3(S3) U22.1(S1) U22.2(S2) U22.3(S3) U23.A1(VSS#A1) U23.A5(VSS#A5) U23.A6(VSS#A6) U23.A21(VSS#A21) U23.AA1(VSS#AA1) U23.AA15(VSS#AA15) U23.AA18(VSS#AA18) U23.AA21(VSS#AA21) U23.C3(VSS#C3) U23.C10(VSS#C10) U23.C15(VSS#C15) U23.D1(VSS#D1) U23.E11(VSS#E11) U23.E13(VSS#E13) U23.F8(VSS#F8) U23.F10(VSS#F10) U23.F15(VSS#F15) U23.G1(VSS#G1) U23.G3(VSS#G3) U23.G7(VSS#G7) U23.G9(VSS#G9) U23.G16(VSS#G16) U23.H6(VSS#H6) U23.H8(VSS#H8) U23.H11(VSS#H11) U23.H20(VSS#H20) U23.H21(VSS#H21) U23.J7(VSS#J7) U23.J9(VSS#J9) U23.J14(VSS#J14) U23.J16(VSS#J16) U23.K6(VSS#K6) U23.K8(VSS#K8) U23.L1(VSS#L1) U23.L3(VSS#L3) U23.L7(VSS#L7) U23.L9(VSS#L9) U23.L16(VSS#L16) U23.M6(VSS#M6) U23.M8(VSS#M8) U23.M10(VSS#M10) U23.M12(VSS#M12) U23.N7(VSS#N7) U23.N9(VSS#N9) U23.N11(VSS#N11) U23.N13(VSS#N13) U23.N15(VSS#N15) U23.P1(VSS#P1) U23.P6(VSS#P6) U23.P8(VSS#P8) U23.P10(VSS#P10) U23.P18(VSS#P18) U23.R7(VSS#R7) U23.R9(VSS#R9) U23.R12(VSS#R12) U23.T8(VSS#T8) U23.T10(VSS#T10) U23.T11(VSS#T11) U23.T15(VSS#T15) U23.T16(VSS#T16) U23.U3(VSS#U3) U23.V17(VSS#V17) U23.W10(VSS#W10) U23.W18(VSS#W18) U23.Y14(VSS#Y14) U23.Y17(VSS#Y17) U23.Y19(VSS#Y19) U25.3(AGND) U25.5(PGND) U27.5(GND) U28.7(GND) U29.2(GND) U30.14(PGND2) U30.17(PGND1) U30.35(AGND) U30.38(SYNIN) U30.41(EP) U31.3(GND) U32.1(PGND) U32.11(AGND) U33.3(GND) U33.7(EP) U34.8(G\) U34.16(GND) U35.2(GND) U36.1(GND) U37.8(GND1) U37.9(GND2) U37.17(PAD) U38.4(GND) U39.2(GND) U40.B3(VSS) U40.C1(VSSQ#C1) U40.E5(VSSQ#E5) U41.2(GND) U42.3(GND) U43.3(GND) U43.7(EP) U44.A6(VSS#A6) U44.C4(VSSQ#C4) U44.E7(VSS#E7) U44.G5(VSS#G5) U44.H10(VSS#H10) U44.J5(VSS#J5) U44.K8(VSS#K8) U44.N2(VSSQ#N2) U44.N5(VSSQ#N5) U44.P4(VSSQ#P4) U44.P6(VSSQ#P6) U45.2(GND) U46.3(A2) U46.5(GND) U46.6(B2) U47.3(GND) U48.2(GND) U49.5(GND) U50.4(GND) U51.4(GND) U52.3(GND) U53.3(GND) U54.3(GND) U55.2(GND) U56.3(A2) U56.5(GND) U56.6(B2) U57.3(GND) U58.3(GND) U59.10(GNDA) U59.17(GND#17) U59.48(GND#48) U59.55(GND#55) U59.58(GND#58) U59.64(W\A\K\E\) U59.66(XOSC0) U59.80(GND#80) U59.114(GND#114) U60.7(2A) U60.8(GND) U60.9(3A) U60.12(4A) U61.6(GND) U61.9(PAD) U62.3(GND) U62.7(EP) U63.2(GND) U64.2(GND) U65.5(GND) U66.1(A0) U66.2(A1) U66.3(A2) U66.8(GND) U67.8(GND) U68.4(PGND) U68.8(GND) U68.11(EP) U69.3(GND) U70.4(GND#4) U70.9(GND#9) U70.15(GND#15) U70.16(GND#16) U70.21(GND#21) U70.25(GND#25) U70.26(GND#26) U70.32(GND#32) U70.33(EP) U71.2(GND) U72.2(GND) U72.5(EP) U73.3(GND) U74.2(GND#2) U74.4(GND#4) U74.6(GND#6) U75.43(GND) U76.2(GND) U77.2(GND) U77.5(EP) U79.11(GND1) U79.12(GND2) U79.13(GND3) U79.25(EP) U80.49(GND) U81.11(GND1) U81.12(GND2) U81.13(GND3) U81.25(EP) U82.1(1\O\E\) U82.10(GND1) U82.11(GND2) U82.16(2\O\E\) U83.5(VSS) U84.1(1\O\E\) U84.10(GND1) U84.11(GND2) U84.16(2\O\E\) U85.3(GND) U86.2(GND) U87.1(GND1) U87.5(GND2) U87.10(AGND) U87.11(GND3) U87.13(TEST) U87.15(GND4) U87.25(GND5) U87.35(GND6) U87.47(GND7) U87.51(GND8) U88.3(GND) U89.1(1\O\E\) U89.10(GND1) U89.11(GND2) U89.16(2\O\E\) U90.3(GND) U91.25(GND) U91.33(EP) U92.5(VSS) U93.3(GND) U94.3(GND) U95.1(ANODE) U96.25(GND) U96.33(EP) U97.1(PGND) U97.5(FB) U97.6(AGND) U97.11(EP) U98.8(GND1) U98.9(GND2) U98.17(PAD) U99.2(GND) U100.2(GND) U100.5(EP) U102.3(GND) U103.3(GND) U104.3(GND) U105.25(GND) Y1.2(GND1) Y1.4(GND2) Y2.2 Y2.4
GNDUSB: C160.2 J26.SH1 J26.SH2 J26.SH3 J26.SH4 J26.SH5 J26.SH6 R182.2
VCC1V1_PG: R136.2 R396.1 U32.5(PG)
VCC1V2_DDR: C20.1 C21.2 J8.1 L2.2 R22.1 R214.1 TP4.1(TP) U5.3(VOS)
VCC1V2_PG: R14.2 R219.1 U5.5(PG) U103.1(A) U104.1(A)
VCC1V8: C30.2 C170.1 C212.1 C217.1 C221.2 C415.1 C417.1 C418.1 C430.1 C443.1 C476.1 C477.1 C485.2 FL17.1(IN) FL18.1(IN) J13.1 L8.2 R24.2 R155.1 R156.2 R159.1 R160.1 R161.1 R162.1 R163.1 R164.1 R165.1 R166.1 R168.2 R169.1 R172.1 R173.1 R176.1 R178.1 R179.1 R180.1 R181.1 R193.1 R233.2 R414.2 R429.2 R456.1 R457.1 R575.1 TP51.1(TP) U10.3(VCCA) U35.5(VCC) U40.B4(VCC) U40.D1(VCCQ#D1) U40.E4(VCCQ#E4) U44.C6(VCCQ#C6) U44.M4(VCCQ#M4) U44.N4(VCCQ#N4) U44.P3(VCCQ#P3) U44.P5(VCCQ#P5) U54.5(VCC) U63.1(IN) U63.3(ON) U65.3(FB) U65.4(VOS) U73.5(VCC) U85.5(VCC)
VCC1V8_HSE: C18.1 C19.1 C206.1 J2.C2 J2.C3 U63.5(QOD) U63.6(OUT)
VCC2V5_PG: R217.2 R225.1 U9.5(PG)
VCC3V3_IO_HSE: C14.1 C16.1 C205.1 J2.A27 J2.A28 J2.A29 U64.5(QOD) U64.6(OUT)
VCC3V3_PREREG: C9.1 C37.1 C40.1 C46.1 C95.1 C126.1 C179.2 C211.1 C265.1 C283.2 C479.1 C495.2 L3.2 R58.2 R123.2 R219.2 R259.1 R276.1 R277.1 TP12.1(TP) U5.7(PVIN) U5.8(AVIN) U12.3(VIN1) U12.4(VIN2) U25.7(VIN) U33.6(IN) U57.5(VCC) U65.7(VIN) U72.4(IN) U76.6(VCC) U103.5(VCC) U104.5(VCC)
VCC3V3_PREREG_EN: R579.2 U102.4(Y)
VCC3V3_R: J33.1 R411.1
VCC3V3_REF: C509.1 C521.1 C524.1 FL19.3(OUT) U105.3(VDDREF)
VCC3V3_SYS_PG: C118.1 R131.2 R580.2 R583.2 R589.2 TP49.1(TP) TP97.1(TP) U30.24(PG1)
VCC3V3_TA: C181.1 C190.2 C388.1 C405.1 C434.1 C458.1 C469.1 C472.1 C494.2 J38.1 J38.2 J38.3 L9.2 R185.2 R201.1 R355.2 R439.1 R494.1 R495.1 R521.2 R522.2 R523.2 R524.2 R525.2 R526.2 R533.2 R535.2 R550.1 R551.1 TP96.1(TP) U51.1(VCCA) U79.1(VCCA) U81.1(VCCA) U90.5(VCC) U96.27(VCCP) U96.31(VCC) U97.8(SLEEP) U97.10(VOS) U102.5(VCC)
VCC3V3_VCO: C513.1 C520.1 C527.1 FL20.3(OUT) U105.24(VDDVCO)
VCC3V3_XDS: C166.1 C167.1 C171.2 C174.1 C175.1 C176.1 C178.2 C191.1 C192.2 C196.2 C197.1 C198.1 C464.2 R199.2 R200.2 R202.1 R203.1 R204.1 R505.1 R557.2 R558.2 R559.2 R560.2 U55.7(VCCB) U56.8(VCCB) U59.7(VDD#7) U59.8(VDDA) U59.16(VDD#16) U59.26(VDD#26) U59.28(VDD#28) U59.39(VDD#39) U59.47(VDD#47) U59.51(VDD#51) U59.52(VDD#52) U59.69(VDD#69) U59.79(VDD#79) U59.90(VDD#90) U59.101(VDD#101) U59.113(VDD#113) U59.122(VDD#122) U61.3(OUT1) U61.4(OUT2) U98.16(VCCB)
VCC5V0_PG: R134.1 U30.7(PG2) U102.1(A)
VCC_1V8_FT4232: C419.2 C420.2 C440.2 C441.1 U87.12(VCORE#12) U87.37(VCORE#37) U87.49(VREGOUT) U87.64(VCORE#64)
VCC_3V3_FT4232: C158.1 C409.2 C412.2 C413.2 C414.2 C423.2 C424.2 C442.2 C445.2 FB23.2 FB24.2 LD21.2(ANODE) R186.2 R191.2 R463.2 U43.1(OUT) U82.2(VCCB) U84.2(VCCB) U87.20(VCCIO#20) U87.31(VCCIO#31) U87.42(VCCIO#42) U87.50(VREGIN) U87.56(VCCIO#56) U89.2(VCCB) U92.8(VCC)
VCC_3V3_MIPI: C164.2 FB21.2 R447.1 R459.2 R460.1 R461.1 U48.3(VCCA)
VCC_3V3_SYS: C5.2 C6.1 C10.1 C17.1 C22.2 C25.1 C26.1 C27.2 C29.1 C32.1 C35.1 C44.1 C45.1 C50.1 C52.1 C53.2 C55.2 C67.1 C70.1 C83.1 C84.1 C89.1 C90.1 C99.1 C101.1 C104.1 C109.1 C113.2 C127.1 C128.1 C144.2 C145.2 C146.2 C147.1 C149.1 C150.1 C151.2 C155.2 C156.2 C157.2 C161.1 C162.2 C163.2 C165.2 C173.2 C182.2 C183.2 C188.2 C189.2 C194.2 C199.2 C207.2 C208.1 C209.1 C216.1 C219.1 C220.1 C237.1 C260.1 C266.1 C275.1 C276.1 C281.1 C284.1 C286.1 C320.1 C349.1 C369.1 C384.1 C385.1 C389.1 C404.1 C407.2 C408.2 C410.2 C411.2 C421.1 C426.1 C429.2 C435.1 C436.1 C437.1 C438.1 C444.2 C456.2 C457.2 C459.1 C461.2 C470.2 FB1.1 FB12.1 FB14.1 FB19.1 FB21.1 FL19.1(IN) FL20.1(IN) J1.1 J7.10 J19.1 J25.5 J27.A9(+3.3V#A9) J27.A10(+3.3V#A10) J27.B8(+3.3V#B8) J29.1 R6.2 R7.2 R15.2 R18.1 R19.2 R25.1 R27.1 R32.1 R33.1 R35.1 R37.2 R39.2 R41.1 R42.2 R47.2 R51.1 R56.1 R72.1 R76.1 R79.2 R81.1 R94.1 R95.1 R98.1 R101.1 R103.2 R104.1 R105.2 R113.1 R114.1 R116.1 R125.1 R126.1 R128.1 R131.1 R133.1 R143.2 R150.1 R153.1 R184.2 R187.2 R188.2 R196.2 R197.2 R210.2 R211.2 R212.2 R224.2 R225.2 R226.2 R234.2 R242.2 R265.1 R270.1 R278.1 R285.1 R295.4 R300.2 R303.1 R305.2 R306.1 R308.1 R309.1 R310.1 R311.1 R336.1 R340.1 R347.1 R353.1 R354.1 R357.1 R358.1 R360.2 R362.1 R365.2 R366.1 R368.2 R369.1 R370.2 R380.2 R381.1 R382.1 R383.1 R384.1 R387.1 R388.1 R394.2 R395.2 R396.2 R398.2 R399.2 R403.2 R406.2 R411.2 R416.2 R418.1 R419.1 R420.1 R421.1 R424.1 R426.1 R431.1 R438.2 R455.1 R458.1 R465.2 R472.2 R475.2 R476.2 R477.1 R481.1 R482.2 R486.2 R487.2 R490.2 R493.1 R496.2 R499.2 R501.2 R504.2 R508.2 R511.2 R512.2 R515.2 R516.1 R517.2 R520.2 R527.2 R530.2 R534.2 R536.2 R537.2 R540.2 R562.1 R564.1 R574.1 R576.1 R608.1 R609.1 R610.1 R611.1 R612.2 R613.2 R615.2 R616.2 R634.1 R635.1 R637.2 R639.2 R640.1 R641.1 R642.1 R672.1 R686.1 TP44.1(TP) U1.1(A1) U1.6(VS+) U6.2(A0) U6.6(VS+) U7.8(VCC) U8.5(V+) U9.7(PVIN) U9.8(AVIN) U10.7(VCCB) U11.6(VS+) U14.6(VS+) U15.19(VDDIO#19) U15.30(VDDIO#30) U15.41(VDDIO#41) U16.6(VS+) U18.4(V+) U19.5(VCC) U20.18(VDDIO#18) U20.30(VDDIO#30) U27.10(VCC) U28.6(VS+) U29.4(V+) U31.5(VCC) U32.7(PVIN) U32.8(AVIN) U34.1(VCC) U37.1(VCCA) U37.16(VCCB) U39.1(VIN) U41.5(VCC) U44.E6(VCC#E6) U44.F5(VCC#F5) U44.J10(VCC#J10) U44.K9(VCC#K9) U45.3(VCCA) U45.7(VCCB) U46.1(VCCA) U46.8(VCCB) U47.5(VCC) U48.7(VCCB) U50.8(VCC) U51.8(VCCB) U52.5(VCC) U53.5(VCC) U55.3(VCCA) U56.1(VCCA) U60.16(VCC) U62.6(IN) U64.1(IN) U64.3(ON) U66.16(VCC) U67.16(VCC) U68.2(VLDOIN) U68.10(VDD) U69.5(VCC) U75.1(VCC#1) U75.17(VCC#17) U75.30(VCC#30) U77.4(IN) U79.23(VCCB1) U79.24(VCCB2) U80.18(VDDIO#18) U80.30(VDDIO#30) U81.23(VCCB1) U81.24(VCCB2) U82.3(VCCA) U83.8(VCC) U84.3(VCCA) U86.5(VCC) U88.5(VCC) U89.3(VCCA) U91.27(VCCP) U91.31(VCC) U93.5(VCC) U94.5(VCC) U98.1(VCCA) U99.5(VIN) U100.4(IN)
VCC_5V0: C15.1 C69.1 C71.1 C139.2 C271.2 FB2.1 FL7.1(I) R109.1 R111.2 R266.1 R314.1 R407.1 TP18.1(TP) U2.1(IN) U2.3(ON) U30.6(VCCX) U74.5(VDD)
VCC_5V0_HSE: C11.1 C12.1 C13.1 J2.A1 J2.A2 J2.A3 U2.5(QOD) U2.6(OUT)
VCC_CAN: C23.2 C24.2 FB2.2 U3.3(VCC) U4.3(VCC)
VCC_CORE: C72.2 C77.1 C486.1 J20.1 L4.2 R92.3 TP23.1(TP)
VCC_CORE_EN: R584.2 TP24.1(TP) U103.4(Y)
VCC_CORE_FB: C96.2 R117.2 R118.2 U25.2(FB)
VCC_CORE_PG: R123.1 R312.2 U25.8(PG) U102.2(B) U104.2(B)
VCC_LCD: C474.1 J36.1 TP100.1(TP)
VCC_LM5140: C107.1 C108.1 D4.2(ANODE) D5.2(ANODE) U30.15(VCC#15) U30.16(VCC#16)
VDD1V8_PG: C403.1 R127.2 R143.1 R581.2 TP50.1(TP) U33.5(PG) U65.2(PG)
VDD3V3_CLKBUF: C34.2 C225.2 C226.2 C234.1 FB12.2 R50.1 R55.2 R243.2 R248.1 R253.2 R255.1 U70.2(VDDO#2) U70.6(VDDO#6) U70.10(VDD) U70.19(VDDO#19) U70.23(VDDO#23) U71.4(VDD)
VDD_0V85: C31.2 C33.1 J11.1 R227.4 TP8.1(TP) U12.8(VOUT)
VDD_0V85_EN: R57.1 U104.4(Y)
VDD_0V85_PG: R20.2 R58.1 U12.2(PG) U103.2(B)
VDD_1V0: C36.1 C39.1 C41.1 C51.1 C238.1 C253.1 C259.1 C263.1 C274.1 C280.1 TP56.1(TP) U15.6(VDD1P0#6) U15.24(VDD1P0#24) U15.31(VDD1P0#31) U15.42(VDD1P0#42) U77.1(OUT)
VDD_1V1: C68.1 C76.1 C78.1 C105.1 C110.1 C112.1 C122.1 C124.1 C293.1 C301.1 C306.1 C316.1 C394.1 C395.1 C401.1 L7.2 R361.1 TP28.1(TP) U20.6(VDDA1P1) U20.31(VDD1P1#31) U20.39(VDD1P1#39) U32.3(VOS) U80.6(VDDA1P1) U80.31(VDD1P1#31) U80.39(VDD1P1#39)
VDD_2V5: C28.1 C38.1 C43.1 C73.1 C80.1 C106.1 C111.1 C114.1 C249.1 C258.1 C261.1 C297.1 C305.1 C313.1 C392.1 C397.1 L1.2 R232.1 TP6.1(TP) U9.3(VOS) U15.3(VDDA2P5#3) U15.9(VDDA2P5#9) U20.3(VDDA2P5#3) U20.9(VDDA2P5#9) U80.3(VDDA2P5#3) U80.9(VDDA2P5#9)
VDD_2V8: C463.2 C471.1 J36.7 R538.1 R556.1 TP99.1(TP) U100.1(OUT)
VDD_CORE: C96.1 C315.1 C318.1 C323.1 C324.1 C325.1 C329.1 C332.1 C334.1 C335.1 C336.1 C339.1 C345.1 C352.1 C354.1 C482.1 C483.1 C484.1 J20.2 R78.1 R92.2 R106.1 R118.1 R284.1 R298.1 TP14.1(TP) TP55.1(TP) U23.J10(VDD_CORE#J10) U23.J12(VDD_CORE#J12) U23.K9(VDD_CORE#K9) U23.K11(VDD_CORE#K11) U23.L8(VDD_CORE#L8) U23.L12(VDD_CORE#L12) U23.M9(VDD_CORE#M9) U23.M11(VDD_CORE#M11) U23.N8(VDD_CORE#N8) U23.N10(VDD_CORE#N10) U23.P9(VDD_CORE#P9)
VDD_DDR4: C213.2 C222.1 C223.1 C224.1 C229.1 C230.1 C232.1 C233.1 C236.1 C239.1 C241.1 C242.1 C248.2 C250.1 C268.1 C288.1 C290.1 C294.1 C302.1 C303.1 C307.1 C308.1 C310.1 C311.1 C314.1 C317.1 J8.2 R22.4 R63.2 R67.2 R69.2 U13.A1(VDDQ#A1) U13.A9(VDDQ#A9) U13.B3(VDD#B3) U13.B9(VDD#B9) U13.C1(VDDQ#C1) U13.D1(VDD#D1) U13.D9(VDDQ#D9) U13.F2(VDDQ#F2) U13.F8(VDDQ#F8) U13.G1(VDDQ#G1) U13.G7(VDD#G7) U13.G9(VDDQ#G9) U13.J1(VDD#J1) U13.J2(VDDQ#J2) U13.J8(VDDQ#J8) U13.J9(VDD#J9) U13.L1(VDD#L1) U13.L9(VDD#L9) U13.R1(VDD#R1) U13.T9(VDD#T9) U23.F7(VDDS_DDR#F7) U23.G6(VDDS_DDR#G6) U23.H7(VDDS_DDR#H7) U23.J6(VDDS_DDR#J6) U23.J8(VDDS_DDR_C) U23.K7(VDDS_DDR#K7) U23.L6(VDDS_DDR#L6) U68.1(VDDQSNS)
VDD_DLL_MMC0: C365.1 C373.1 C377.1 FB17.2 U23.H14(VDD_DLL_MMC0)
VDD_MMC1: C119.1 C148.1 C184.1 C382.1 FB9.1 U23.H15(VDDA_3P3_SDIO) U39.5(QOD) U39.6(VOUT)
VDD_MMC1_SD: C451.1 FB9.2 J37.4(VDD)
VDDA1V8: C117.2 C129.1 J22.1 R144.1 R351.2 TP29.1(TP) U33.1(OUT)
VDDA_1V8: C79.1 C338.1 C342.1 C346.1 C370.1 FB3.1 FB5.1 FB6.1 FB13.1 FB15.1 FB18.1 FB20.1 J22.2 R351.3 U23.G11(VDDA_TEMP0) U23.H13(VDDS_OSC) U23.L11(VDDA_TEMP1)
VDDA_1V8_MCU: C103.1 C353.1 C387.1 FB5.2 U23.K12(VDDA_MCU)
VDDA_1V8_SERDES: C120.1 C121.1 C375.1 FB6.2 R632.2 U23.R14(VDDA_1P8_SERDES0)
VDDA_1V8_USB0: C380.1 C398.1 C399.1 FB20.2 U23.R15(VDDA_1P8_USB0)
VDDA_ADC: C4.2 C7.2 C363.1 C367.1 C368.1 FB18.2 J3.4 J3.17 U23.J13(VDDA_ADC)
VDDA_CORE: FB4.1 FB16.1 FB17.1 R75.2 R78.2 U23.K13(VDD_MMC0)
VDDA_LM5140: C138.1 R134.2 U30.3(FB2) U30.28(FB1) U30.33(DEMB) U30.34(ILSET) U30.36(VDDA) U30.37(OSC)
VDDA_PLL0: C327.1 C340.1 C355.1 FB15.2 U23.N12(VDDA_PLL0)
VDDA_PLL1: C299.1 C300.1 C322.1 FB13.2 U23.H9(VDDA_PLL1)
VDDA_PLL2: C74.1 C75.1 C347.1 FB3.2 U23.J11(VDDA_PLL2)
VDDA_SYS_MON: R314.2 R315.1 R604.2 U23.K10(VMON_VSYS)
VDDAR_0P85_SERDES0: C88.1 C91.1 C92.1 C93.1 C344.1 C356.1 C362.1 FB4.2 U23.P11(VDDA_0P85_SERDES0_C) U23.P12(VDDA_0P85_SERDES0#P12) U23.P13(VDDA_0P85_SERDES0#P13)
VDDAR_0P85_USB0: C341.1 C350.1 C358.1 FB16.2 U23.T12(VDDA_0P85_USB0)
VDDAR_CORE: J11.2 R44.1 R75.1 R227.1 R297.1 TP10.1(TP)
VDDAR_SENSE: R282.2 R283.1 R284.2 U76.3(SENSE)
VDDB_3V3_DISPLAY: C455.1 C462.2 J36.10 U99.1(VOUT)
VDDC_1V2: C185.2 C186.1 C187.1 U59.87(VDDC#87) U59.115(VDDC#115)
VDDIM: C427.1 C428.1 U44.C2(VDDIM)
VDDO12: C519.1 C523.1 C526.1 FL17.3(OUT) U105.16(VDDO12)
VDDO34: C517.1 C522.1 C525.1 FL18.3(OUT) U105.15(VDDO34)
VDDR_CORE: C86.2 C87.1 C330.1 C475.1 R106.2 R282.1 R297.2 R307.1 TP61.1(TP) U23.L10(VDDR_CORE#L10) U23.M13(VDDR_CORE#M13)
VDDR_VTT: C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C64.1 C210.2 C244.1 C246.1 C251.1 C254.1 C264.1 C267.1 R46.2 R71.2 R77.2 R83.2 R84.2 R85.2 R86.2 R87.2 R88.2 R89.2 R90.2 R91.2 R256.2 R258.2 R264.2 R269.2 R271.2 R273.2 R274.2 R275.2 R287.2 R288.2 R289.2 R290.2 R291.2 TP48.1(TP) U68.3(VTT) U68.5(VTTSNS)
VDDSHV_SD_IO: C372.1 C381.1 C400.1 C446.1 R479.1 R480.1 R483.1 R484.1 R485.1 R646.1 TP39.1(TP) U23.K15(CAP_VDDSHV_MMC1) U23.L14(VDDSHV5#L14) U23.L15(VDDSHV5#L15) U49.10(VCC)
VIN_MON_PORZ_3V3_PG: C57.1 R259.2 R578.2 R585.2 R586.2 R587.2 R588.2 TP45.1(TP) U17.10(PGOOD) U41.3(B) U74.1(OUT)
ADC0_AIN0: J3.15 U23.G20(ADC0_AIN0)
ADC0_AIN1: J3.14 U23.F20(ADC0_AIN1)
ADC0_AIN2: J3.6 U23.E21(ADC0_AIN2)
ADC0_AIN3: J3.18 U23.D20(ADC0_AIN3)
ADC0_AIN4: J3.10 U23.G21(ADC0_AIN4)
ADC0_AIN5: J3.7 U23.F21(ADC0_AIN5)
ADC0_AIN6: J3.3 U23.F19(ADC0_AIN6)
ADC0_AIN7: J3.11 U23.E20(ADC0_AIN7)
ADDR: R532.2 U96.26(ADDR)
ADDR_1: R452.2 U91.26(ADDR)
BOOTMODE0: R325.1 RA1.8 RA2.1 U23.T20(GPMC0_AD0)
BOOTMODE1: R326.1 RA1.7 RA2.2 U23.U21(GPMC0_AD1)
BOOTMODE2: R327.1 RA1.6 RA2.3 U23.T18(GPMC0_AD2)
BOOTMODE3: R328.1 RA1.5 RA2.4 U23.U20(GPMC0_AD3)
BOOTMODE4: R329.1 RA1.4 RA2.5 U23.U18(GPMC0_AD4)
BOOTMODE5: R330.1 RA1.3 RA2.6 U23.U19(GPMC0_AD5)
BOOTMODE6: R331.1 RA1.2 RA2.7 U23.V20(GPMC0_AD6)
BOOTMODE7: R332.1 RA1.1 RA2.8 U23.V21(GPMC0_AD7)
BOOTMODE8: R372.1 RA3.8 RA4.1 U23.V19(GPMC0_AD8)
BOOTMODE9: R373.1 RA3.7 RA4.2 U23.T17(GPMC0_AD9)
BOOTMODE10: R374.1 RA3.6 RA4.3 U23.R16(GPMC0_AD10)
BOOTMODE11: R375.1 RA3.5 RA4.4 U23.W20(GPMC0_AD11)
BOOTMODE12: R376.1 RA3.4 RA4.5 U23.W21(GPMC0_AD12)
BOOTMODE13: R377.1 RA3.3 RA4.6 U23.V18(GPMC0_AD13)
BOOTMODE14: R378.1 RA3.2 RA4.7 U23.Y21(GPMC0_AD14)
BOOTMODE15: R379.1 RA3.1 RA4.8 U23.Y20(GPMC0_AD15)
BOOTMODE_I2C_SCL: J38.37 R550.2 TP43.1(TP) U96.29(SCL)
BOOTMODE_I2C_SDA: J38.39 R551.2 TP42.1(TP) U96.30(SDA)
BOOTMODEON: R453.1 R454.1 U79.22(O\E\) U81.22(O\E\)
C1N: C460.1 J36.11
C1P: C460.2 J36.12
C2N: C454.1 J36.13
C2P: C454.2 J36.14
CAN_MUX_OE: R23.1 U67.15(O\E\)
CAN_MUX_SEL: R16.1 U67.1(S) U91.2(P01)
CAP_VDDS0: C390.1 U23.H12(CAP_VDDS0)
CAP_VDDS1: C298.1 U23.T7(CAP_VDDS1)
CAP_VDDS2: C348.1 U23.R11(CAP_VDDS2)
CAP_VDDS3: C357.1 U23.N14(CAP_VDDS3)
CAP_VDDS4: C396.1 U23.M16(CAP_VDDS4)
CAP_VDDS5: C391.1 U23.L13(CAP_VDDS5)
CAP_VDDS_MCU: C289.1 U23.H10(CAP_VDDS_MCU)
CDC_EEPROMSEL: R686.2 R687.1 U105.23(EEPROMSEL)
CDC_OE1: R688.2 U105.20(STATUS/GPIO1)
CDC_OE1/OE4: R672.2 R688.1 U91.18(P21) U105.11(OE/GPIO4)
CDC_OE2: R660.2 U105.19(SDA/GPIO2)
CDC_OE3: R659.2 U105.12(SCL/GPIO3)
CDC_REFSEL: R656.1 U105.4(REFSEL)
CDC_XIN: C532.2 U105.1(XIN) Y4.2
CDC_XOUT: C533.2 U105.2(XOUT) Y4.1
CDC_Y0: TP102.1(TP) U105.7(Y0)
CDC_Y1N: R653.1 U105.21(Y1N)
CDC_Y1P: R652.1 U105.22(Y1P)
CDC_Y4N: R655.1 U105.9(Y4N)
CDC_Y4P: R654.1 U105.10(Y4P)
CDCEL_XIN: C235.2 R245.1 R246.1 R252.2 R255.2
CDCEL_XIN_IN: C235.1 R246.2 U70.11(XIN)
CLKGEN_REFCLK1N: R653.2 R661.2 R682.1
CLKGEN_REFCLK1P: R652.2 R662.2 R681.1
CLKGEN_REFCLK4N: R655.2 R667.2 R684.1
CLKGEN_REFCLK4P: R654.2 R668.2 R683.1
CLKOUT0: R50.2 R257.1 R345.2 U70.13(PRI_INP)
CONN_MCU_PORZ: J1.24 R7.1 U35.3(B)
CONN_MCU_RESETZ: J1.21 Q8.1(G) R6.1
CPSW_EARTH: C287.1 J14.SH1 J14.SH2 R299.1
CPSW_ETH1_D0M: J14.10 U15.2(TD_M_A)
CPSW_ETH1_D0P: J14.11 U15.1(TD_P_A)
CPSW_ETH1_D1M: J14.5 U15.5(TD_M_B)
CPSW_ETH1_D1P: J14.4 U15.4(TD_P_B)
CPSW_ETH1_D2M: J14.2 U15.8(TD_M_C)
CPSW_ETH1_D2P: J14.3 U15.7(TD_P_C)
CPSW_ETH1_D3M: J14.9 U15.11(TD_M_D)
CPSW_ETH1_D3P: J14.8 U15.10(TD_P_D)
CPSW_ETH1_GPIO_0: R41.2 R230.2 R251.1 U15.39(GPIO_0)
CPSW_ETH1_GPIO_1: R35.2 R36.1 U15.40(GPIO_1)
CPSW_ETH1_LED0: TP9.1(TP) U15.47(LED_0)
CPSW_ETH1_LED1: J14.13 Q13.3(D)
CPSW_ETH1_LED2: J14.16 Q12.3(D) R234.1
CPSW_ETH1_LED3: J14.15 Q3.3(D) R37.1
CPSW_ETH1_LED_1000: R30.2 R31.1 R32.2 U15.46(LED_1)
CPSW_ETH1_LED_ACT: R33.2 R34.1 R286.1 U15.45(LED_2)
CPSW_FET_EN: R278.2 U75.8(EN)
CPSW_FET_SEL: R292.1 U75.9(SEL1) U75.10(SEL2) U91.11(P12)
CPSW_RGMII1_ETH1_CLK: C501.1 R239.2
CPSW_RGMII1_ETH1_CLK_OUT: TP16.1(TP) U15.18(CLK_OUT)
CPSW_RGMII1_ETH1_RBIAS: R70.1 U15.12(RBIAS)
CPSW_RGMII1_MDC: R81.2 TP64.1(TP) U15.16(MDC) U23.R2(PRG0_PRU1_GPO19) U27.7(B1)
CPSW_RGMII1_MDIO: R79.1 TP20.1(TP) U15.17(MDIO) U23.P5(PRG0_PRU1_GPO18) U27.3(A1)
CPSW_RGMII1_RD0: R54.1 R56.2 U15.33(RX_D0) U75.41(B0)
CPSW_RGMII1_RD1: U15.34(RX_D1) U75.39(B1)
CPSW_RGMII1_RD2: R51.2 R52.1 U15.35(RX_D2) U75.38(B2)
CPSW_RGMII1_RD3: U15.36(RX_D3) U75.36(B3)
CPSW_RGMII1_RESETN: R240.1 U15.43(RESET_N) U69.4(Y)
CPSW_RGMII1_RX_CTL: R39.1 R249.1 U15.38(RX_DV/RX_CTRL) U75.34(B4)
CPSW_RGMII1_RXC: U15.32(RX_CLK) U75.32(B5)
CPSW_RGMII1_TD0: U15.28(TX_D0) U23.V15(PRG1_PRU1_GPO7)
CPSW_RGMII1_TD1: U15.27(TX_D1) U23.V14(PRG1_PRU1_GPO9)
CPSW_RGMII1_TD2: U15.26(TX_D2) U23.W14(PRG1_PRU1_GPO10)
CPSW_RGMII1_TD3: U15.25(TX_D3) U23.AA14(PRG1_PRU1_GPO17)
CPSW_RGMII1_TX_CTL: U15.37(TX_EN/TX_CTRL) U23.U15(PRG1_PRU0_GPO9)
CPSW_RGMII1_TXC: U15.29(GTX_CLK) U23.U14(PRG1_PRU0_GPO10)
CPSW_RGMII_INTN: R42.1 R250.2 U15.44(INT/PWDN)
CTI_TCK: R195.1 U60.3(1B2)
DDR_A0: R289.1 U13.P3(A0) U23.D2(DDR0_A0)
DDR_A1: R90.1 U13.P7(A1) U23.C5(DDR0_A1)
DDR_A2: R86.1 U13.R3(A2) U23.E2(DDR0_A2)
DDR_A3: R89.1 U13.N7(A3) U23.D4(DDR0_A3)
DDR_A4: R290.1 U13.N3(A4) U23.D3(DDR0_A4)
DDR_A5: R287.1 U13.P8(A5) U23.F2(DDR0_A5)
DDR_A6: R275.1 U13.P2(A6) U23.J2(DDR0_A6)
DDR_A7: R77.1 U13.R8(A7) U23.L5(DDR0_A7)
DDR_A8: R84.1 U13.R2(A8) U23.J3(DDR0_A8)
DDR_A9: R91.1 U13.R7(A9) U23.J4(DDR0_A9)
DDR_A10: R291.1 U13.M3(A10/AP) U23.K3(DDR0_A10)
DDR_A11: R83.1 U13.T2(A11) U23.J1(DDR0_A11)
DDR_A12: R88.1 U13.M7(A12/BC_N) U23.M5(DDR0_A12)
DDR_A13: R71.1 U13.T8(A13) U23.K4(DDR0_A13)
DDR_A14_WEN: R264.1 U13.L2(WE_N/A14) U23.H4(DDR0_WE_N)
DDR_A15_CAS: R271.1 U13.M8(CAS_N/A15) U23.J5(DDR0_CAS_N)
DDR_A16_RAS: R274.1 U13.L8(RAS_N/A16) U23.F6(DDR0_RAS_N)
DDR_ACTN: R87.1 U13.L3(ACT_N) U23.H2(DDR0_ACT_N)
DDR_ALERTN: R69.1 U13.P9(ALERT_N) U23.H1(DDR0_ALERT_N)
DDR_BA0: R273.1 U13.N2(BA0) U23.G4(DDR0_BA0)
DDR_BA1: R288.1 U13.N8(BA1) U23.G5(DDR0_BA1)
DDR_BG0: R269.1 U13.M2(BG0) U23.G2(DDR0_BG0)
DDR_CKE: R46.1 R247.1 U13.K2(CKE) U23.F4(DDR0_CKE0)
DDR_CLKN: R267.1 U13.K8(CK_C) U23.E1(DDR0_CK0_N)
DDR_CLKP: R261.1 U13.K7(CK_T) U23.F1(DDR0_CK0)
DDR_CSN: R256.1 U13.L7(CS_N) U23.E3(DDR0_CS0_N)
DDR_DQ0: U13.G2(DQ0) U23.A3(DDR0_DQ0)
DDR_DQ1: U13.F7(DQ1) U23.A4(DDR0_DQ3)
DDR_DQ2: U13.H3(DQ2) U23.B4(DDR0_DQ7)
DDR_DQ3: U13.H7(DQ3) U23.B3(DDR0_DQ4)
DDR_DQ4: U13.H2(DQ4) U23.B5(DDR0_DQ2)
DDR_DQ5: U13.H8(DQ5) U23.A2(DDR0_DQ1)
DDR_DQ6: U13.J3(DQ6) U23.C4(DDR0_DQ5)
DDR_DQ7: U13.J7(DQ7) U23.C2(DDR0_DQ6)
DDR_DQ8: U13.A3(DQ8) U23.N5(DDR0_DQ8)
DDR_DQ9: U13.B8(DQ9) U23.N4(DDR0_DQ12)
DDR_DQ10: U13.C3(DQ10) U23.M3(DDR0_DQ11)
DDR_DQ11: U13.C7(DQ11) U23.M4(DDR0_DQ14)
DDR_DQ12: U13.C2(DQ12) U23.N3(DDR0_DQ13)
DDR_DQ13: U13.C8(DQ13) U23.N2(DDR0_DQ15)
DDR_DQ14: U13.D3(DQ14) U23.L2(DDR0_DQ10)
DDR_DQ15: U13.D7(DQ15) U23.L4(DDR0_DQ9)
DDR_LDM: U13.E7(NF/LDM_N/LDBI_N) U23.B2(DDR0_DM0)
DDR_LDQS_N: U13.F3(LDQS_C) U23.B1(DDR0_DQS0_N)
DDR_LDQS_P: U13.G3(LDQS_T) U23.C1(DDR0_DQS0)
DDR_ODT: R258.1 U13.K3(ODT) U23.E5(DDR0_ODT0)
DDR_PARITY: R85.1 U13.T3(PAR) U23.K5(DDR0_PAR)
DDR_RESET#: R66.2 R67.1 U13.P1(RESET_N) U23.D5(DDR0_RESET0_N)
DDR_TEN: R62.2 R63.1 U13.N9(TEN)
DDR_UDM: U13.E2(NF/UDM_N/UDBI_N) U23.M2(DDR0_DM1)
DDR_UDQS_N: U13.A7(UDQS_C) U23.M1(DDR0_DQS1_N)
DDR_UDQS_P: U13.B7(UDQS_T) U23.N1(DDR0_DQS1)
DDR_VPP: C227.2 C228.1 C270.2 FB11.2 U13.B1(VPP#B1) U13.R9(VPP#R9)
DDR_VREFCA: C42.2 C218.1 U13.M1(VREFCA) U68.6(VTTREF)
DDR_VTT_EN: U10.5(A1) U23.L18(OSPI0_CSN1)
DDR_VTT_EN_3V3: R29.1 TP7.1(TP) U10.8(B1) U68.7(S3) U68.9(S5)
DEBOUNCE_GPIO_SOC/MCU: C465.2 D8.2 Q17.2(S) R534.1 SW5.1 SW5.2 U50.3(2A)
DEBOUNCE_MCU_RESETZ: C466.2 D9.2 Q8.2(S) R536.1 SW6.1 SW6.2 U50.1(1A)
DEBOUNCE_WARM_RST: C467.2 D11.2 Q10.2(S) R537.1 SW4.1 SW4.2 U50.6(3A)
DIR: R355.1 R356.2 U79.2(DIR) U81.2(DIR)
