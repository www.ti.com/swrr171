# Allegro board PROC101A_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SERDES_REFCLK0_N_C: length 8.1
  TOP w0.14: U23.W16 v1(84.26,72.7)
  BOTTOM w0.108: R333.1 R661.1 R680.2 78.7,72.96 arc(78.73,72.88) 78.8,72.85 81.94,72.85 arc(82.32,72.77) 82.63,72.56 82.88,72.31 arc(83.02,72.22) 83.19,72.19 83.47,72.19 arc(83.59,72.21) 83.69,72.28 83.7,72.29 arc(83.87,72.4) 84.07,72.44 84.16,72.44 arc(84.23,72.47) 84.26,72.54 v1(84.26,72.7)
SERDES_REFCLK0_P: length 81.8
  L08_SIG2 w0.081: v1(76.38,72.2) 76.5,72.08 arc(76.71,72.03) 76.83,72.22 76.83,72.54 arc(76.89,72.68) 77.03,72.73 77.17,72.73 arc(77.61,72.92) 77.79,73.36 77.79,73.46 arc(77.63,73.82) 77.27,73.98 74.34,73.98 arc(74.03,74.04) 73.77,74.21 73.71,74.27 arc(73.53,74.39) 73.31,74.43 62.93,74.43 arc(61.88,74.23) 60.99,73.63 52.7,65.34 arc(51.86,64.08) 51.56,62.6 51.56,58.93 arc(51.12,56.7) 49.86,54.81 44.79,49.74 arc(42.66,48.32) 40.14,47.82 35.28,47.82 arc(33.37,47.44) 31.75,46.35 arc(30.9,45.09) 30.61,43.6 30.61,38.87 arc(30.56,38.75) 30.43,38.7 30.35,38.7 arc(30.32,38.7) 30.29,38.72 v1(30.02,38.99)
  BOTTOM w0.108: v1(30.02,38.99) 29.71,38.68 29.18,38.68 28.29,37.8 27.56,37.8 27.3,38.05 27.3,38.56 26.98,38.89 26.46,38.89 26.35,39 R666.2 ; R625.2 R623.2 77.57,71.18 arc(77.68,71.34) 77.72,71.53 R679.1 76.7,72.07 arc(76.52,72.1) v1(76.38,72.2)
SERDES_REFCLK0_P_C: length 8.1
  TOP w0.14: U23.W17 v1(84.26,71.9)
  BOTTOM w0.108: v1(84.26,71.9) 84.26,72.05 arc(84.23,72.12) 84.16,72.15 84.07,72.15 arc(83.98,72.13) 83.91,72.08 83.9,72.07 arc(83.7,71.94) 83.47,71.9 83.19,71.9 arc(82.91,71.95) 82.68,72.11 82.43,72.36 arc(82.21,72.5) 81.94,72.56 78.86,72.56 arc(78.74,72.51) 78.7,72.4 R679.2 R662.1 R346.1
SERDES_RXN0: length 86.9
  TOP w0.14: U23.Y15 v1(83.46,73.5)
  L08_SIG2 w0.081: v1(83.46,73.5) 83.22,73.26 arc(83.19,73.24) 83.15,73.22 83.14,73.21 83.1,73.21 arc(82.85,73.16) 82.64,73.02 81.33,71.71 arc(80.52,71.17) 79.57,70.98 76.78,70.98 arc(75.55,71.22) 74.52,71.92 73.66,72.77 arc(73.28,73.02) 72.83,73.11 64.55,73.11 arc(63.32,72.87) 62.29,72.18 56.65,66.54 arc(56.65,66.54) 56.65,66.54 56.58,66.49 56.52,66.42 arc(53.95,62.58) 53.05,58.05 53.05,49.12 arc(52.8,47.88) 52.1,46.83 51.13,45.86 arc(49.99,45.1) 48.64,44.83 45.21,44.83 arc(43.34,44.46) 41.76,43.4 36.6,38.24 arc(35.57,37.55) 34.36,37.31 30.05,37.31 arc(29.84,37.35) 29.67,37.47 29.61,37.53 arc(29.42,37.66) 29.19,37.7 26.28,37.7 arc(25.97,37.57) 25.84,37.27 25.84,36.45 25.77,35.86 arc(25.83,35.59) 25.98,35.36 27.18,34.16 arc(27.41,34) 27.68,33.95 J27.A17
SERDES_RXP0: length 86.9
  TOP w0.14: U23.Y16 v1(83.46,72.7)
  L08_SIG2 w0.081: v1(83.46,72.7) 83.39,72.78 arc(83.26,72.86) 83.1,72.89 arc(82.97,72.87) 82.86,72.79 81.55,71.48 arc(80.64,70.88) 79.57,70.66 76.78,70.66 arc(75.43,70.93) 74.29,71.69 73.44,72.55 arc(73.16,72.73) 72.83,72.8 64.55,72.8 arc(63.45,72.58) 62.51,71.95 56.88,66.32 arc(56.86,66.3) 56.84,66.28 56.79,66.25 56.74,66.2 arc(54.24,62.46) 53.37,58.05 53.37,49.12 arc(53.09,47.76) 52.32,46.61 51.36,45.64 arc(50.11,44.81) 48.64,44.51 45.21,44.51 arc(43.46,44.17) 41.98,43.18 36.82,38.01 arc(35.69,37.26) 34.36,36.99 30.05,36.99 arc(29.72,37.06) 29.45,37.24 29.39,37.3 arc(29.3,37.36) 29.19,37.38 28.96,37.38 arc(28.84,37.33) 28.79,37.21 28.79,37.06 arc(28.62,36.9) 28.46,37.06 28.46,37.21 arc(28.29,37.38) 28.12,37.21 28.12,36.96 arc(27.95,36.79) 27.79,36.96 27.79,37.21 arc(27.62,37.38) 27.45,37.21 27.45,36.99 arc(27.28,36.82) 27.12,36.99 27.12,37.21 arc(26.95,37.38) 26.78,37.21 26.78,36.99 arc(26.61,36.82) 26.45,36.99 26.45,37.21 arc(26.4,37.33) 26.28,37.38 arc(26.2,37.35) 26.16,37.27 26.16,36.45 arc(26.18,36.35) 26.24,36.27 26.4,36.11 arc(26.57,35.99) J27.A16
SERDES_TXN0: length 90.4
  TOP w0.108: C100.1 74.3,71.09 arc(74.26,71.07) 74.22,71.06 73.81,71.06 arc(73.77,71.07) 73.75,71.09 v1(73.47,71.37)
  L08_SIG2 w0.081: v1(73.47,71.37) 73.2,71.1 arc(73.18,71.08) 73.14,71.07 72.95,71.07 arc(72.77,71.04) 72.62,70.94 72.47,70.78 arc(72.3,70.67) 72.1,70.63 71.24,70.63 arc(70.76,70.72) 70.36,70.99 70.36,70.99 arc(69.72,71.42) 68.98,71.56 64.98,71.56 arc(64.49,71.47) 64.08,71.19 62,69.11 arc(61.54,68.42) 61.38,67.62 61.38,62.01 arc(61.38,62) 61.38,61.99 arc(61.29,61.78) 61.15,61.6 56.45,56.89 arc(55.96,56.17) 55.8,55.32 55.8,45.91 arc(55.35,43.66) 54.08,41.76 50.31,37.99 arc(49.92,37.4) 49.78,36.71 49.78,26.62 arc(49.65,25.96) 49.28,25.4 arc(48.43,24.84) 47.44,24.64 32.93,24.64 arc(32.14,24.8) 31.47,25.24 30.45,26.26 arc(29.59,26.83) 28.57,27.03 27.97,27.03 arc(27.66,27.1) 27.4,27.27 25.9,28.77 arc(25.88,28.79) 25.87,28.81 arc(25.8,28.93) 25.78,29.06 J27.B15
SERDES_TXN0_C: length 8.8
  TOP w0.108: U23.AA16 82.71,73.1 arc(82.63,73.07) 82.6,73 82.6,72.96 arc(82.57,72.88) 82.49,72.85 80.51,72.85 arc(79.84,72.72) 79.27,72.34 78.13,71.2 arc(77.98,71.09) 77.8,71.06 75.72,71.06 arc(75.45,71.11) 75.22,71.27 75.13,71.36
SERDES_TXP0: length 90.4
  TOP w0.108: C102.1 74.3,70.74 arc(74.26,70.76) 74.22,70.77 73.83,70.77 73.78,70.76 arc(73.76,70.75) 73.75,70.74 v1(73.47,70.46)
  L08_SIG2 w0.081: J27.B14 25.62,28.61 arc(25.64,28.58) 25.67,28.55 25.84,28.38 arc(25.89,28.26) 25.84,28.14 25.75,28.05 arc(25.75,27.81) 25.99,27.81 26.08,27.9 arc(26.32,27.9) 26.32,27.67 26.26,27.61 arc(26.26,27.37) 26.5,27.37 26.55,27.43 arc(26.67,27.48) 26.79,27.43 27.17,27.05 arc(27.54,26.8) 27.97,26.72 28.57,26.72 arc(29.47,26.54) 30.23,26.03 31.24,25.02 arc(32.02,24.5) 32.93,24.32 47.44,24.32 arc(48.55,24.54) 49.5,25.18 arc(49.94,25.84) 50.1,26.62 50.1,36.71 arc(50.21,37.28) 50.54,37.77 54.3,41.53 arc(55.64,43.54) 56.11,45.91 56.11,55.32 arc(56.26,56.05) 56.67,56.67 61.38,61.37 arc(61.57,61.62) 61.68,61.91 arc(61.69,61.96) 61.7,62.01 61.7,67.62 arc(61.83,68.3) 62.22,68.88 64.3,70.97 arc(64.61,71.17) 64.98,71.25 68.98,71.25 arc(69.6,71.12) 70.13,70.77 arc(70.64,70.43) 71.24,70.31 72.1,70.31 arc(72.42,70.37) 72.69,70.55 72.85,70.71 arc(72.89,70.74) 72.95,70.75 73.14,70.75 arc(73.18,70.75) 73.2,70.73 v1(73.47,70.46)
SERDES_TXP0_C: length 8.9
  TOP w0.108: U23.AA17 82.71,72.3 arc(82.63,72.34) 82.6,72.41 82.6,72.45 arc(82.57,72.53) 82.49,72.56 80.51,72.56 arc(79.95,72.45) 79.47,72.13 78.34,70.99 arc(78.09,70.83) 77.8,70.77 75.53,70.77 arc(75.43,70.75) 75.35,70.69 75.13,70.47
SOC_CLKIN: length 101.9
  TOP w0.147: R137.1 v1(98.21,61.95)
  L03_SIG1 w0.091: v1(62.61,87.9) 60.33,85.61 60.33,76.21 62.48,74.06 70.67,74.06 72.44,72.29 72.44,68.55 73.17,67.83 75.05,67.83 77.71,65.17 v1(78.74,65.17)
  L08_SIG2 w0.091: v1(98.21,61.95) 98.21,57.71 92.46,51.96 83.69,51.96 79.25,56.4 79.25,64.66 v1(78.74,65.17)
  BOTTOM w0.147: v1(62.61,87.9) 72.14,87.9 73.79,89.55 73.79,99.72 72.16,101.35 71.17,101.35 70.89,101.07 U73.4
SOC_CLKIN_3V3: length 2.4
  BOTTOM w0.147: R272.2 66.72,100.34 66.8,100.42 U73.2
SOC_DVDD1V8: length 4.3
  TOP w0.254: U23.M15 v1(89.86,73.5) ; U23.K14 v1(92.26,74.3) ; U23.E12 v1(96.26,75.9) ; U23.K16 v1(92.26,72.7) ; U23.J15 v1(93.06,73.5) ; U23.M14 v1(89.86,74.3)
  BOTTOM w0.254: C383.1 92.27,72.71 v1(92.26,72.7) ; C379.1 89.74,73.62 v1(89.86,73.5) ; v1(96.26,75.9) 96.41,75.9 C359.1
  vias: v1(106.83,73.5) v1(108.23,73.47) v1(108.96,73.5) v1(126.62,111.01) v1(126.62,110) v1(126.62,108.98) v1(126.62,107.96) v1(127.64,111.01) v1(127.64,110) v1(127.64,108.98) v1(127.64,107.96) v1(128.65,111.01) v1(128.65,110) v1(128.65,108.98) v1(128.65,107.96)
SOC_DVDD3V3: length 15.7
  TOP w0.254: U23.P7 v1(88.26,80.7) ; U23.M7 v1(89.86,80.7) ; U23.N6 v1(89.06,81.5) ; U23.R10 v1(87.46,78.3) ; U23.F11 v1(95.46,77.5) ; U23.T9 v1(86.66,79.1) ; U23.R8 v1(87.46,79.9) ; U23.P14 v1(88.26,74.3) ; U23.G10 v1(94.66,78.3) ; U23.P15 v1(88.26,73.5) ; U23.F9 v1(95.46,79.1) ; U23.F14 v1(95.46,74.3) ; U23.G14 v1(94.66,74.3) ; U23.G8 v1(94.66,79.9) ; U23.G12 v1(94.66,75.9) ; U23.F13 v1(95.46,75.1) ; U23.R13 v1(87.46,75.1)
  L06_PWR2 w0.381: v1(88.26,73.5) v1(88.26,74.3)
  BOTTOM w0.254: v1(94.66,79.9) 94.78,79.78 C321.1 ; v1(87.46,75.1) 87.34,75.22 C360.1 ; v1(88.26,80.7) 88.38,80.82 C312.1 ; v1(87.46,79.9) 87.34,80.02 C319.1 ; v1(95.46,75.1) 95.45,75.11 C361.1 ; C374.1 95.58,74.18 v1(95.46,74.3) ; C309.1 89.98,80.82 v1(89.86,80.7) ; C337.1 95.58,77.62 v1(95.46,77.5) 95.58,77.38 C343.1 ; v1(94.66,74.3) 94.85,74.11 C376.1 ; v1(87.46,78.3) 87.58,78.42 C333.1 ; C331.1 94.65,78.31 v1(94.66,78.3) ; v1(86.66,79.1) 86.78,79.22 C326.1 ; C378.1 v1(88.26,73.5) ; C328.1 95.61,79.1 v1(95.46,79.1) ; C351.1 v1(94.66,75.9) ; v1(89.06,81.5) 88.94,81.62 C304.1
  vias: v1(103.35,73.5) v1(104.41,73.5) v1(133.35,92.6) v1(133.35,91.58) v1(133.35,90.57) v1(133.35,89.55) v1(134.37,92.6) v1(134.37,91.58) v1(134.37,90.57) v1(134.37,89.55) v1(135.38,92.6) v1(135.38,91.58) v1(135.38,90.57) v1(135.38,89.55)
SOC_EMU0: length 187.6
  TOP w0.147: U23.D10 v1(97.06,78.3) ; U45.5 96.89,35.94 97.32,36.37 102.4,36.37 106.17,40.15 106.17,46.09 113.33,53.25 116.22,53.25 117.73,54.76 122.07,54.76 122.21,54.89 126.4,54.89 128.55,57.05 128.55,59.77 126.72,61.6 124.49,61.6 124.35,61.45 124.35,61.11 v1(124.08,60.85) ; U55.5 139.05,25.77 138.68,25.4 v1(135.59,25.4) ; J39.1 R634.2
  L03_SIG1 w0.091: v1(97.06,78.3) 97.46,78.71 101.5,78.71 101.78,78.43 102.92,78.43 103.59,77.77 111.4,77.77 116.1,73.07 116.1,67.29 116.74,66.65 120.02,66.65 124.36,62.32 124.36,61.13 v1(124.08,60.85)
  L08_SIG2 w0.091: v1(124.08,60.85) 124.41,60.52 124.41,59.22 128.01,55.61 128.01,40.59 128.04,40.56 128.04,39.16 134.75,32.46 134.75,27.97 135.59,27.13 v1(135.59,25.4)
  BOTTOM w0.147: J39.1 161.16,42.42 161.16,40.16 165.68,35.64 165.68,33.91 165.15,33.38 151.41,33.38 146.02,27.99 140.87,27.99 139.17,26.29 136.47,26.29 v1(135.59,25.4)
SOC_EMU1: length 187.4
  TOP w0.147: J40.1 R635.2 ; v1(134.98,23.62) 136.07,24.71 138.65,24.71 139.05,24.31 U55.4 ; U23.E10 v1(96.26,78.3) ; v1(98.04,35.83) 98.08,35.83 98.2,35.94 U45.4
  L03_SIG1 w0.091: v1(107.61,59.35) 107.61,57.46 107.9,57.17 107.9,56.66 110.23,54.34 123.23,54.34 124.51,53.06 124.51,51.26 125.6,50.17 125.6,27.07 128.71,23.95 134.64,23.95 v1(134.98,23.62)
  L08_SIG2 w0.091: v1(134.98,23.62) 134.49,24.1 119.81,24.1 111.49,32.43 104.99,32.43 103.15,34.26 99.61,34.26 v1(98.04,35.83) ; v1(107.61,59.35) 107.88,59.09 109.8,59.09 110.29,59.58 110.29,63.26 108.2,65.35 108.2,68.57 108.16,68.61 108.16,68.68 103.86,72.98 103.86,73.78 103.33,74.31 100.33,74.31 98.04,76.6 97.16,76.6 96.66,77.09 96.66,77.73 96.26,78.13 v1(96.26,78.3)
  BOTTOM w0.147: v1(134.98,23.62) 136.98,25.63 139.17,25.63 141.07,27.53 146.05,27.53 151.33,32.82 165.2,32.82 165.99,33.6 165.99,36.09 162.71,39.37 162.71,42.21 163.86,43.36 164,43.36 164.16,43.51 J40.1
SOC_I2C0_SCL: length 135.2
  TOP w0.147: J2.E1 v1(74.55,132.35) ; v1(105.99,119.44) 105.9,119.53 U7.6 103.64,119.53 103.38,119.79 103.38,122.93 J5.3 106.02,125.57 107.87,125.57 108.58,124.86 108.58,123.54 109.29,122.83 113.41,122.83 115.88,120.36 115.88,116.14 112.18,112.44 112.18,90.05 113.37,88.86 113.37,83.02 116.28,80.11 116.28,69.64 112.69,66.05 109.27,66.05 109.17,66.16 v1(108.71,66.16)
  L03_SIG1 w0.091: v1(74.55,132.35) 75.76,132.35 77.5,130.61 77.5,129.46 79.92,127.05 83.41,127.05 85.85,124.6 88.77,124.6 94.16,119.21 101.94,119.21 104.85,122.12 J5.3
  BOTTOM w0.147: R598.1 103.9,66.17 104.34,65.73 108.28,65.73 v1(108.71,66.16) 109.45,65.42 R358.2 ; v1(105.99,119.44) 105.9,119.53 U7.6
SOC_I2C0_SCL_RC: length 7.2
  TOP w0.147: v1(101.94,67.95) 100.85,69.04 100.85,69.52 100.36,70.01 100.36,70.98 99.84,71.5 U23.A18
  BOTTOM w0.147: v1(101.94,67.95) C492.1 R598.2
SOC_I2C0_SDA: length 126.4
  TOP w0.147: J2.E2 v1(73.28,132.35) ; v1(109.47,66.69) 109.8,66.37 112.59,66.37 115.98,69.76 115.98,79.99 113.08,82.9 113.08,88.74 111.89,89.93 111.89,112.56 115.59,116.26 115.59,120.24 113.29,122.54 109.17,122.54 108.22,123.49 108.22,123.56 J5.2 104.77,121.77 U7.5 v1(105.96,120.18)
  L03_SIG1 w0.091: v1(73.28,132.35) 73.79,131.84 75.95,131.84 77.28,130.5 77.28,129.37 79.83,126.83 83.31,126.83 85.76,124.38 88.68,124.38 94.07,118.99 101.98,118.99 J5.2
  BOTTOM w0.147: U7.5 v1(105.96,120.18) ; R599.1 107.29,66.45 107.53,66.69 v1(109.47,66.69) R354.2
SOC_I2C0_SDA_RC: length 11.3
  TOP w0.147: U23.B18 98.66,71.9 99.85,71.9 100.65,71.1 100.65,70.1 101.29,69.46 101.29,69.31 v1(101.87,68.74)
  BOTTOM w0.147: v1(101.87,68.74) 103.2,68.74 103.38,68.56 104.44,68.56 104.76,68.24 104.76,68.03 105.35,67.43 C493.1 R599.2
SOC_I2C1_SCL: length 493.1
  TOP w0.147: v1(125.6,103.52) 125.6,104.56 U14.5 ; U29.1 v1(124.08,67.58) ; U29.1 123.38,68.51 123.57,68.7 TP25.1 ; U29.1 123.38,66.75 123.19,66.56 120.8,66.56 120.43,66.93 114.26,66.93 113.03,65.7 104.87,65.7 103.76,66.82 102.36,66.82 100.57,68.61 100.57,69.4 100.08,69.89 100.08,70.86 99.82,71.12 99.47,71.12 99.46,71.1 97.86,71.1 U23.C18 ; U11.2 147.57,107.72 147.83,107.98 147.83,108.85 147.46,109.22 U11.5 144.54,109.22 v1(144.53,109.23) ; v1(135.76,102.5) 135.85,102.42 U16.5 ; U28.5 137.56,70.77 v1(137.54,70.75) 137.54,69.86 137.79,69.61 139.06,69.61 139.56,70.1 U28.1 ; U1.5 v1(85.36,127.54) ; v1(51.97,42.09) 46.63,42.09 45.85,41.3 43.68,41.3 43.05,41.93 U34.15 ; U6.5 152.17,118.85 152.25,118.76 v1(152.78,118.76) ; R659.1 55.63,57.87 55.39,58.12 54.75,58.12 v1(54.69,58.17) ; U51.7 v1(66.02,31.47) ; J27.B5 13.78,28.78 15.79,26.77 30,26.77 37.7,19.06 49.28,19.06 51.44,21.22 51.44,28.71 53.48,30.75 57.46,30.75 58.78,32.07 59.32,32.07 v1(59.9,32.65) ; v1(71.5,100.81) 71.18,100.49 71.18,93.02 71.4,92.8 U18.1
  TOP w0.254: R13.1 v1(129.29,119.14)
  TOP w0.305: v1(138.4,103.65) 138.41,103.64 U16.1
  L03_SIG1 w0.091: v1(8.49,18.14) 10.17,19.83 10.41,19.83 13.74,23.16 13.74,29.85 13.71,29.88 13.71,30.42 13.78,30.49 J27.B5 ; v1(66.02,31.47) 64.84,32.65 v1(59.9,32.65) 59.51,33.04 59.51,33.81 56.31,37 51.94,37 51.64,37.3 51.64,41.76 v1(51.97,42.09) 51.97,44.65 52.91,45.59 52.91,56.39 v1(54.69,58.17) 53.83,59.03 49.15,59.03 47.62,60.55 47.62,64.38 50.12,66.87 50.12,85.31 49.02,86.41 49.02,88.15 v1(50.16,89.3) ; v1(124.08,67.58) 124.56,67.1 126.4,67.1 126.71,67.42 134.21,67.42 v1(137.54,70.75) ; v1(138.4,103.65) 138.67,103.91 138.83,103.91 144.15,109.23 v1(144.53,109.23) 147.14,109.23 147.8,108.57 147.8,105.2 148.18,104.82 152.76,104.82 153.77,105.83 153.77,117.77 v1(152.78,118.76) 151.99,117.97 130.45,117.97 v1(129.29,119.14) 128.03,120.4 120.4,120.4 115.02,125.77 104.04,125.77 103.66,125.39 103.66,121.83 101.26,119.44 95.04,119.44 92.65,121.83 92.65,124.41 90.93,126.13 86.09,126.13 85.36,126.85 v1(85.36,127.54)
  L08_SIG2 w0.091: v1(137.54,70.75) 138.36,71.58 138.36,98.37 139.45,99.46 139.45,102.12 138.4,103.16 v1(138.4,103.65) 136.91,103.65 v1(135.76,102.5) 135,101.74 128.02,101.74 126.24,103.52 v1(125.6,103.52) ; v1(71.5,100.81) 70.66,101.65 70.66,105.6 71.12,106.06 71.12,120.35 75.24,124.47 80.9,124.47 81.69,125.26 83.08,125.26 v1(85.36,127.54)
  BOTTOM w0.147: v1(124.08,67.58) 124.62,67.58 124.79,67.41 R353.2 ; J36.5 5.76,17.81 6.29,17.29 8.09,17.29 8.49,17.69 v1(8.49,18.14) ; v1(59.9,32.65) 59.57,32.97 59.5,32.97 59.44,33.03 58.67,33.03 58.55,32.91 U91.29 ; v1(71.5,100.81) 72.16,100.81 73.3,99.67 73.3,93.5 70.23,90.42 60.55,90.42 58.85,88.72 50.74,88.72 v1(50.16,89.3) ; R265.2 135.51,102.25 v1(135.76,102.5)
SOC_I2C1_SDA: length 485.1
  TOP w0.147: U16.4 136.91,101.24 v1(136.91,101.23) ; v1(146.68,108.72) U11.4 144.47,108.72 144.32,108.57 144.32,107.37 144.47,107.22 U11.1 ; U28.2 139.06,70.24 138.94,70.12 v1(138.05,70.12) 138.05,70.57 138.06,70.57 U28.4 ; U14.4 126.12,103.34 126.11,103.34 v1(126.11,102.88) ; U1.4 85.86,127.47 85.85,127.47 v1(85.85,127.01) 85.98,126.89 86.61,126.89 86.86,127.13 U1.2 ; v1(152.78,119.65) 152.4,120.03 151.26,120.03 151.12,119.89 U6.4 ; U34.2 43.05,49.23 42.01,50.27 42.01,52.76 40.49,54.28 40.49,56.44 41.34,57.29 v1(45.61,57.29) 45.83,57.29 R660.1 ; U51.6 66.67,31.83 v1(66.02,32.48) ; J27.B6 17.05,27.18 31.62,27.18 39.1,19.7 48.77,19.7 51.05,21.99 51.05,29.99 53.59,32.53 v1(58.8,32.53) ; TP27.1 124.44,64.78 124.43,64.78 v1(124.08,64.78) U29.6 123.38,65.87 123.06,66.18 120.77,66.18 120.31,66.64 114.38,66.64 113.16,65.41 103.26,65.41 100.28,68.39 100.28,69.28 99.26,70.3 98.83,70.3 98.54,70.59 98.37,70.59 U23.B19 ; v1(72.16,100.15) 72.16,96.85 72.01,96.7 U18.6
  TOP w0.254: R12.1 v1(131.7,119.27)
  L03_SIG1 w0.091: J27.B6 14.78,23.41 v1(9.51,18.14) ; v1(138.05,70.12) 137.29,69.36 136.46,69.36 131.88,64.78 v1(124.08,64.78) ; v1(136.91,101.23) 137.92,102.25 138.43,102.25 138.84,102.66 138.84,103.61 143.95,108.72 v1(146.68,108.72) 146.41,108.45 146.41,105.91 147.78,104.54 152.88,104.54 153.97,105.63 153.97,118.46 v1(152.78,119.65) 151.56,118.43 132.54,118.43 v1(131.7,119.27) 130.32,120.65 120.48,120.65 115.13,126 103.96,126 103.44,125.47 103.44,121.92 101.17,119.66 95.13,119.66 92.87,121.92 92.87,124.5 91.02,126.35 86.52,126.35 v1(85.85,127.01) ; v1(66.02,32.48) 66.46,32.04 66.46,31.28 66.2,31.03 65.84,31.03 65.23,31.64 59.69,31.64 v1(58.8,32.53) 58.8,33.26 56.42,35.64 52.53,35.64 51.16,37.01 51.16,44.02 47.92,47.25 47.92,54.98 v1(45.61,57.29) 47.4,59.09 47.4,64.41 49.94,66.95 49.94,85.06 48.79,86.21 48.79,88.78 v1(49.94,89.93)
  L08_SIG2 w0.091: v1(72.16,100.15) 72.16,101.51 72.39,101.74 72.39,120.28 76.4,124.29 80.98,124.29 81.73,125.04 83.88,125.04 v1(85.85,127.01) ; v1(138.05,70.12) 137.54,70.12 136.91,70.75 136.91,81.56 136.02,82.44 136.02,85.61 138.14,87.74 138.14,99.63 136.91,100.86 v1(136.91,101.23) 136.38,101.23 135.49,100.34 128.65,100.34 v1(126.11,102.88)
  BOTTOM w0.147: v1(49.94,89.93) 50.28,89.93 51.18,89.03 58.65,89.03 60.43,90.81 69.98,90.81 72.95,93.78 72.95,99.36 v1(72.16,100.15) ; v1(136.91,101.23) 136.46,101.23 136.2,100.98 R270.2 ; U91.30 58.69,32.41 v1(58.8,32.53) ; v1(124.08,64.78) 124.62,64.78 124.79,64.95 R357.2 ; J36.4 5.84,17.31 6.19,16.97 8.33,16.97 v1(9.51,18.14)
SOC_I2C1_TA_SCL: length 19.5
  TOP w0.147: v1(65.91,15.13) 67.56,16.78 67.56,21.73 68.33,22.49 68.33,26.81 67.44,27.7 66.45,27.7 v1(65.68,26.94) 66.02,26.6 U51.2
  BOTTOM w0.147: R495.2 v1(65.68,26.94) ; J38.36 v1(65.91,15.13)
SOC_I2C1_TA_SDA: length 17.4
  TOP w0.147: v1(64.91,15.13) 65.66,15.88 65.66,20.33 68.03,22.71 68.03,26.56 67.65,26.94 v1(67.01,26.94) 66.67,26.6 U51.3
  BOTTOM w0.147: J38.38 v1(64.91,15.13) ; R494.2 v1(67.01,26.94)
SOC_MAIN_UART0_CTS_3V3: length 55.6
  TOP w0.147: v1(102.79,71.87) 102.23,72.43 101.29,72.43 100.22,73.5 98.66,73.5 U23.B16
  L03_SIG1 w0.091: v1(102.79,71.87) 103.22,72.3 103.61,72.3 104.66,71.25 104.66,67.7 107.52,64.83 107.52,60.04 108.84,58.73 108.84,56.54 110.82,54.56 123.6,54.56 124.94,53.21 127.98,53.21 128.63,53.86 131.9,53.86 132.78,52.97 v1(137.03,52.97)
  BOTTOM w0.147: U84.9 136.74,52.56 137.03,52.85 v1(137.03,52.97)
SOC_MAIN_UART0_RTS_3V3: length 52.9
  TOP w0.147: v1(101.78,71.85) 101.27,71.85 100.02,73.1 U23.A16
  L03_SIG1 w0.091: v1(101.78,71.85) 102.41,72.48 103.58,72.48 103.58,72.48 103.68,72.48 104.84,71.32 104.84,67.77 107.71,64.91 107.71,60.12 109.06,58.77 109.06,56.62 110.92,54.76 123.95,54.76 125.32,53.4 127.74,53.4 128.42,54.08 131.99,54.08 132.53,53.54 135.21,53.54 v1(135.64,53.96)
  BOTTOM w0.147: v1(135.64,53.96) 135.58,53.91 U84.7
SOC_MAIN_UART0_RX_3V3: length 62.3
  TOP w0.147: U23.D15 v1(97.06,73.5)
  L03_SIG1 w0.091: v1(97.06,73.5) 96.66,73.9 96.66,73.91 96.66,73.92 96.66,74.43 96.93,74.7 97.26,74.7 97.46,74.9 97.46,75.23 97.71,75.49 98.37,75.49 99.33,74.53 101.7,74.53 101.89,74.34 102.69,74.34 102.98,74.64 111.51,74.64 113.53,72.61 113.53,66.04 115.23,64.34 115.23,58.65 116.66,57.23 118.34,57.23 118.67,57.56 124.75,57.56 125.41,58.22 130.51,58.22 131.69,57.04 135.62,57.04 v1(137.02,55.64)
  BOTTOM w0.147: U84.8 136.53,53.16 137.02,53.65 v1(137.02,55.64)
SOC_MAIN_UART0_TX_3V3: length 53.1
  TOP w0.147: U23.C16 v1(97.86,72.7)
  L03_SIG1 w0.091: v1(134.87,53.99) 132.39,53.99 132.08,54.3 125.66,54.3 125.01,54.95 111.82,54.95 110.04,56.73 110.04,58.35 107.89,60.5 107.89,65.02 105.79,67.12 105.79,70.63 103.76,72.66 103.66,72.66 98.33,72.66 98.3,72.7 v1(97.86,72.7)
  BOTTOM w0.147: U84.6 135.18,53.68 v1(134.87,53.99) 135.47,54.58 R608.2
SOC_MAIN_UART1_RX_3V3: length 81.1
  TOP w0.147: U23.E15 v1(96.26,73.5)
  L03_SIG1 w0.091: v1(109.19,60.04) 109.52,60.37 109.85,60.37 112.72,57.5 112.72,56.42 113.83,55.31 121.32,55.31 122.1,56.09 124.06,56.09 125.64,57.67 129.91,57.67 131.28,56.3 134.72,56.3 137.89,53.13 137.89,50.92 138.02,50.79 138.59,50.22 138.59,48.3 148.9,37.99 v1(151,37.99)
  L08_SIG2 w0.091: v1(109.19,60.04) 109.19,60.49 107.54,62.15 107.54,68.53 104.93,71.13 100.84,71.13 98.07,73.91 96.66,73.91 v1(96.26,73.5)
  BOTTOM w0.147: U89.8 151.8,38.29 151.5,37.99 v1(151,37.99)
SOC_MAIN_UART1_TX_3V3: length 85
  TOP w0.147: U23.E14 v1(96.26,74.3)
  L03_SIG1 w0.091: v1(152.4,37.23) 149.35,37.23 138.37,48.21 138.37,50.12 137.93,50.57 137.67,50.82 137.67,52.97 134.52,56.12 131.2,56.12 129.84,57.48 126.75,57.48 125.17,55.91 122.17,55.91 121.39,55.13 113.63,55.13 112.49,56.26 112.49,56.91 109.99,59.41 109.99,59.42 v1(109.73,59.68)
  L08_SIG2 w0.091: v1(109.73,59.68) 109.73,60.52 107.76,62.49 107.76,68.57 104.99,71.34 100.92,71.34 98.76,73.5 98.76,74.11 98.16,74.7 96.66,74.7 v1(96.26,74.3)
  BOTTOM w0.147: U89.6 152.6,38.24 152.66,38.18 152.66,37.48 v1(152.4,37.23) 152.4,36.77 152.25,36.63 R609.2
SOC_MAIN_UART3_RX_3V3: length 80
  TOP w0.147: U23.D16 v1(97.06,72.7)
  L03_SIG1 w0.091: v1(150.75,39.13) 148.46,39.13 145.23,42.36 145.23,50.24 141.73,53.74 137.92,53.74 134.91,56.75 131.47,56.75 130.18,58.03 125.49,58.03 123.91,56.45 121.94,56.45 121.17,55.68 114.14,55.68 113.16,56.66 113.16,57.58 108.07,62.66 108.07,65.1 105.97,67.2 105.97,70.71 103.81,72.87 98.6,72.87 98.36,73.1 97.46,73.1 v1(97.06,72.7)
  BOTTOM w0.147: U89.9 151.04,39.42 v1(150.75,39.13)
SOC_MAIN_UART3_TX_3V3: length 82.6
  TOP w0.147: U23.E16 v1(96.26,72.7)
  L03_SIG1 w0.091: v1(108.56,60.43) 108.92,60.79 109.68,60.79 112.94,57.54 112.94,56.57 114.01,55.49 121.24,55.49 122.02,56.27 123.98,56.27 125.56,57.85 130.08,57.85 131.41,56.52 134.81,56.52 138.11,53.23 138.11,51.01 138.81,50.31 138.81,48.39 148.78,38.42 151.71,38.42 v1(152.15,37.99)
  L08_SIG2 w0.091: v1(96.26,72.7) 96.66,73.1 98.27,73.1 100.46,70.91 104.9,70.91 107.31,68.49 107.31,61.67 v1(108.56,60.43)
  BOTTOM w0.147: U89.7 152.2,38.04 v1(152.15,37.99) 151.54,37.39 R610.2
SOC_MMC0_CLK: length 21
  TOP w0.147: U23.G18 v1(94.66,71.1)
  L03_SIG1 w0.091: v1(94.66,71.1) 94.84,70.92 94.84,70.85 95.06,70.63 95.06,69.47 95.4,69.12 95.4,67.71 99.53,63.58 99.53,62.3 104.66,57.17 104.66,56.03 v1(104.39,55.77)
  BOTTOM w0.147: v1(104.39,55.77) 104.27,55.64 R404.2
SOC_MMC0_CMD: length 59.2
  TOP w0.147: U23.J21 92.66,68.62 92.74,68.54 92.74,67.46 93.47,66.72 v1(93.47,66.31) ; U44.M5 117.62,35.17 v1(117.49,35.31)
  L03_SIG1 w0.091: v1(117.49,35.31) 115.46,35.31 113.28,37.48 113.28,42.76 113.84,43.32 113.84,44.59 112.82,45.61 112.35,45.61 112.27,45.53 112.27,44.77 112.19,44.69 112.07,44.69 111.99,44.77 111.99,45.53 111.91,45.61 111.8,45.61 111.72,45.53 111.72,44.77 111.64,44.69 111.53,44.69 111.44,44.77 111.44,45.53 111.36,45.61 110.22,45.61 110.14,45.53 110.14,44.8 110.06,44.72 109.94,44.72 109.86,44.8 109.86,45.53 109.78,45.61 109.67,45.61 109.59,45.53 109.59,44.8 109.51,44.72 109.39,44.72 109.31,44.8 109.31,45.53 109.23,45.61 109.12,45.61 109.04,45.53 109.04,44.8 108.96,44.72 108.84,44.72 108.76,44.8 108.76,45.53 108.68,45.61 107.44,45.61 102.21,50.84 102.21,55.95 96.1,62.06 96.1,62.69 93.92,64.87 93.3,64.87 93.05,65.12 93.05,65.88 v1(93.47,66.31)
  BOTTOM w0.147: R457.2 117.13,34.95 v1(117.49,35.31)
SOC_MMC0_DAT0: length 60.2
  TOP w0.147: U23.K20 92.26,69.5 92.26,68.62 92.45,68.42 92.45,67.33 92.96,66.82 92.96,66.17 93.47,65.67 v1(93.47,65.29) ; R161.2 115.65,44.95 115.18,44.47 115.18,43.95 v1(114.55,43.32) 116.34,41.53 116.34,41.18 116.62,40.9 U44.A3
  L03_SIG1 w0.091: v1(93.47,65.29) 94.03,65.29 96.29,63.04 96.29,62.13 102.43,55.99 102.43,52.06 107.43,47.06 107.65,47.06 107.73,46.98 107.73,46.25 107.81,46.17 107.93,46.17 108.01,46.25 108.01,46.98 108.09,47.06 108.2,47.06 108.28,46.98 108.28,46.25 108.36,46.17 108.47,46.17 108.55,46.25 108.55,46.98 108.63,47.06 108.75,47.06 108.83,46.98 108.83,46.25 108.91,46.17 109.02,46.17 109.1,46.25 109.1,46.98 109.18,47.06 109.3,47.06 109.38,46.98 109.38,46.25 109.46,46.17 109.57,46.17 109.65,46.25 109.65,46.98 109.73,47.06 109.85,47.06 109.93,46.98 109.93,46.25 110.01,46.17 110.12,46.17 110.2,46.25 110.2,46.98 110.28,47.06 110.39,47.06 110.47,46.98 110.47,46.25 110.55,46.17 110.67,46.17 110.75,46.25 110.75,46.98 110.83,47.06 110.94,47.06 111.02,46.98 111.02,46.25 111.1,46.17 111.22,46.17 111.3,46.25 111.3,46.98 111.38,47.06 111.49,47.06 111.57,46.98 111.57,46.25 111.65,46.17 111.77,46.17 111.85,46.25 111.85,46.98 111.93,47.06 112.04,47.06 112.12,46.98 112.12,46.25 112.2,46.17 112.31,46.17 112.39,46.25 112.39,46.98 112.48,47.06 113.61,47.06 114.06,46.61 114.06,43.81 v1(114.55,43.32)
SOC_MMC0_DAT1: length 58.2
  TOP w0.147: R163.2 v1(117.98,44.33) 117.12,43.47 U44.A4 ; U23.J20 93.06,69.5 93.06,68.67 93.03,68.63 93.03,67.77 v1(93.47,67.32)
  L03_SIG1 w0.091: v1(117.98,44.33) 115.85,46.45 115.85,46.57 116.24,46.95 116.24,47.07 116.16,47.15 116.05,47.15 115.66,46.76 115.55,46.76 115.47,46.84 115.47,46.96 115.85,47.34 115.85,47.45 115.77,47.53 115.66,47.53 115.27,47.15 115.16,47.15 115.08,47.23 115.08,47.34 115.46,47.73 115.46,47.84 115.38,47.92 115.27,47.92 114.88,47.54 114.77,47.54 114.69,47.62 114.69,47.73 115.08,48.12 115.08,48.23 115,48.31 114.88,48.31 114.5,47.93 114.38,47.93 114.16,48.15 113.33,48.15 113.25,48.23 113.25,48.62 113.17,48.7 113.06,48.7 112.98,48.62 112.98,48.23 112.9,48.15 112.79,48.15 112.71,48.23 112.71,48.62 112.63,48.7 112.51,48.7 112.43,48.62 112.43,48.23 112.35,48.15 112.24,48.15 112.16,48.23 112.16,48.62 112.08,48.7 111.96,48.7 111.88,48.62 111.88,48.23 111.8,48.15 111.69,48.15 111.61,48.23 111.61,48.62 111.53,48.7 111.41,48.7 111.33,48.62 111.33,48.23 111.25,48.15 111.14,48.15 111.06,48.23 111.06,48.62 110.98,48.7 110.87,48.7 110.79,48.62 110.79,48.23 110.7,48.15 110.59,48.15 110.51,48.23 110.51,48.62 110.43,48.7 110.32,48.7 110.24,48.62 110.24,48.23 110.16,48.15 110.04,48.15 109.96,48.23 109.96,48.62 109.88,48.7 109.77,48.7 109.69,48.62 109.69,48.23 109.61,48.15 109.49,48.15 109.41,48.23 109.41,48.62 109.33,48.7 109.22,48.7 109.14,48.62 109.14,48.23 109.06,48.15 108.95,48.15 108.87,48.23 108.87,48.62 108.78,48.7 108.67,48.7 108.59,48.62 108.59,48.23 108.51,48.15 107.02,48.15 102.65,52.52 102.65,56.02 96.47,62.21 96.47,64.33 v1(93.47,67.32)
SOC_MMC0_DAT2: length 59.7
  TOP w0.147: U23.J18 v1(93.06,71.1) ; U44.A5 117.62,41.03 119.13,42.53 v1(119.13,43.5) 119.75,44.13 119.75,44.47 120.23,44.95 R165.2
  L03_SIG1 w0.091: v1(119.13,43.5) 118.42,44.22 118.42,45.63 115.1,48.95 112.95,48.95 112.87,49.03 112.87,49.56 112.79,49.64 112.68,49.64 112.6,49.56 112.6,49.03 112.52,48.95 112.4,48.95 112.32,49.03 112.32,49.56 112.24,49.64 112.13,49.64 112.05,49.56 112.05,49.03 111.97,48.95 111.85,48.95 111.77,49.03 111.77,49.56 111.69,49.64 111.58,49.64 111.5,49.56 111.5,49.03 111.42,48.95 111.31,48.95 111.23,49.03 111.23,49.56 111.15,49.64 111.03,49.64 110.95,49.56 110.95,49.03 110.87,48.95 110.76,48.95 110.68,49.03 110.68,49.56 110.6,49.64 110.48,49.64 110.4,49.56 110.4,49.03 110.32,48.95 110.21,48.95 110.13,49.03 110.13,49.56 110.05,49.64 109.93,49.64 109.85,49.56 109.85,49.03 109.77,48.95 109.66,48.95 109.58,49.03 109.58,49.56 109.5,49.64 109.39,49.64 109.31,49.56 109.31,49.03 109.22,48.95 109.11,48.95 109.03,49.03 109.03,49.56 108.95,49.64 108.84,49.64 108.76,49.56 108.76,49.03 108.68,48.95 108.32,48.95 107.54,49.73 105.76,49.73 102.88,52.61 102.88,56.12 96.7,62.29 96.7,64.91 94.34,67.27 94.34,68.24 92.66,69.91 92.66,70.71 v1(93.06,71.1)
SOC_MMC0_DAT3: length 58.5
  TOP w0.094: 115.87,40.6 115.87,40.1 U44.B2
  TOP w0.147: R159.2 v1(113.41,44.33) 113.41,43.07 115.87,40.6 ; U23.J17 v1(93.06,71.9)
  L03_SIG1 w0.091: v1(93.06,71.9) 92.66,71.51 92.08,71.51 91.86,71.28 91.86,70.12 92.81,69.17 92.81,64.04 93.28,63.57 94.89,63.57 95.92,62.54 95.92,61.98 101.99,55.91 101.99,50.79 108.45,44.33 109.73,44.33 109.81,44.25 109.81,43.26 109.89,43.18 110,43.18 110.08,43.26 110.08,44.25 110.16,44.33 110.28,44.33 110.36,44.25 110.36,43.26 110.44,43.18 110.55,43.18 110.63,43.26 110.63,44.25 110.71,44.33 110.83,44.33 110.91,44.25 110.91,43.26 110.99,43.18 111.1,43.18 111.18,43.26 111.18,44.25 111.26,44.33 111.38,44.33 111.46,44.25 111.46,43.26 111.54,43.18 111.65,43.18 111.73,43.26 111.73,44.25 111.81,44.33 111.92,44.33 112,44.25 112,43.26 112.09,43.18 112.2,43.18 112.28,43.26 112.28,44.25 112.36,44.33 v1(113.41,44.33)
SOC_MMC0_DAT4: length 58.3
  TOP w0.094: 116.37,40.6 116.37,40.1 U44.B3
  TOP w0.147: R160.2 v1(114.55,44.33) 113.92,43.7 113.92,43.05 116.37,40.6 ; U23.H17 v1(93.86,71.9)
  L03_SIG1 w0.091: v1(114.55,44.33) 116.07,42.81 119.36,42.81 119.97,43.43 119.97,46.06 115.1,50.94 105.48,50.94 103.54,52.88 103.54,57.67 99.06,62.15 99.06,63.43 94.96,67.53 94.96,68.94 94.26,69.65 94.26,71.51 v1(93.86,71.9)
SOC_MMC0_DAT5: length 58.2
  TOP w0.094: 116.87,40.6 116.87,40.1 U44.B4
  TOP w0.147: R162.2 v1(116.84,44.33) 116.84,43.87 116.66,43.7 116.66,41.29 116.87,41.08 116.87,40.6 ; U23.H19 v1(93.86,70.3)
  L03_SIG1 w0.091: v1(116.84,44.33) 118.1,43.07 119.31,43.07 119.76,43.52 119.76,45.96 115.01,50.72 109.07,50.72 108.99,50.64 108.99,50.25 108.91,50.16 108.79,50.16 108.71,50.25 108.71,50.64 108.63,50.72 108.52,50.72 108.44,50.64 108.44,50.25 108.36,50.16 108.24,50.16 108.16,50.25 108.16,50.64 108.08,50.72 107.97,50.72 107.89,50.64 107.89,50.25 107.81,50.16 107.7,50.16 107.62,50.25 107.62,50.64 107.54,50.72 107.42,50.72 107.34,50.64 107.34,50.25 107.26,50.16 107.15,50.16 107.07,50.25 107.07,50.64 106.99,50.72 106.87,50.72 106.79,50.64 106.79,50.25 106.71,50.16 106.6,50.16 106.52,50.25 106.52,50.64 106.44,50.72 106.32,50.72 106.24,50.64 106.24,50.25 106.16,50.16 106.05,50.16 105.97,50.25 105.97,50.64 105.89,50.72 105.39,50.72 103.32,52.79 103.32,57.58 98.81,62.09 98.81,63.37 94.74,67.43 94.74,68.85 93.86,69.73 v1(93.86,70.3)
SOC_MMC0_DAT6: length 58.4
  TOP w0.094: 117.37,40.6 117.37,40.1 U44.B5
  TOP w0.147: R164.2 v1(119.12,44.33) 118.58,43.78 118.58,42.47 117.37,41.26 117.37,40.6 ; U23.H18 v1(93.86,71.1)
  L03_SIG1 w0.091: v1(119.12,44.33) 119.12,45.95 115.14,49.93 113.99,49.93 113.91,50.01 113.91,50.45 113.83,50.53 113.72,50.53 113.64,50.45 113.64,50.01 113.56,49.93 113.45,49.93 113.36,50.01 113.36,50.45 113.28,50.53 113.17,50.53 113.09,50.45 113.09,50.01 113.01,49.93 112.9,49.93 112.82,50.01 112.82,50.45 112.74,50.53 112.62,50.53 112.54,50.45 112.54,50.01 112.46,49.93 112.35,49.93 112.27,50.01 112.27,50.45 112.19,50.53 112.07,50.53 111.99,50.45 111.99,50.01 111.91,49.93 111.8,49.93 111.72,50.01 111.72,50.45 111.64,50.53 111.52,50.53 111.44,50.45 111.44,50.01 111.36,49.93 111.25,49.93 111.17,50.01 111.17,50.45 111.09,50.53 110.98,50.53 110.9,50.45 110.9,50.01 110.82,49.93 110.7,49.93 110.62,50.01 110.62,50.45 110.54,50.53 110.43,50.53 110.35,50.45 110.35,50.01 110.27,49.93 110.15,49.93 110.07,50.01 110.07,50.45 109.99,50.53 109.88,50.53 109.8,50.45 109.8,50.01 109.72,49.93 105.87,49.93 103.1,52.7 103.1,56.43 102.42,57.11 102.42,58.09 101.78,58.72 100.58,58.72 96.9,62.4 96.9,64.99 94.54,67.35 94.54,68.66 93.46,69.74 93.46,70.71 v1(93.86,71.1)
SOC_MMC0_DAT7: length 58.4
  TOP w0.094: U44.B6 117.87,40.1 117.87,40.6
  TOP w0.147: R166.2 121.41,44.6 v1(121.77,44.24) 119.67,42.14 119.16,42.14 117.95,40.92 117.95,40.68 117.87,40.6 ; U23.G17 v1(94.66,71.9)
  L03_SIG1 w0.091: v1(94.66,71.9) 95.06,71.5 95.06,70.94 95.29,70.71 95.62,70.71 95.86,70.47 95.86,70.15 95.86,70.14 95.86,67.56 99.76,63.67 99.76,62.39 104.88,57.26 104.88,55.28 108.56,51.6 116.85,51.6 117.32,51.13 117.58,51.13 117.73,50.98 117.73,50.86 117.54,50.67 117.54,50.56 117.62,50.48 117.74,50.48 117.92,50.67 118.04,50.67 118.12,50.59 118.12,50.47 117.93,50.29 117.93,50.17 118.01,50.09 118.12,50.09 118.31,50.28 118.43,50.28 118.51,50.2 118.51,50.09 118.32,49.9 118.32,49.78 118.4,49.7 118.51,49.7 118.7,49.89 118.81,49.89 118.89,49.81 118.89,49.7 118.71,49.51 118.71,49.4 118.79,49.32 118.9,49.32 119.09,49.5 119.2,49.5 119.28,49.42 119.28,49.31 119.09,49.12 119.09,49.01 119.17,48.93 119.29,48.93 119.48,49.12 119.59,49.12 119.67,49.04 119.67,48.92 119.48,48.73 119.48,48.62 119.56,48.54 119.68,48.54 119.86,48.73 119.98,48.73 120.06,48.65 120.06,48.53 119.87,48.35 119.87,48.23 119.95,48.15 120.06,48.15 120.25,48.34 120.37,48.34 120.45,48.26 120.45,48.15 120.26,47.96 120.26,47.84 120.34,47.76 120.45,47.76 120.64,47.95 120.75,47.95 120.83,47.87 120.83,47.76 120.65,47.57 120.65,47.46 120.73,47.38 120.84,47.38 121.03,47.56 121.14,47.56 122.3,46.4 122.3,44.77 v1(121.77,44.24)
SOC_MMC0_DS: length 54.5
  TOP w0.147: U23.G19 v1(94.66,70.3)
  L03_SIG1 w0.091: v1(94.66,70.3) 94.66,69.56 95.18,69.03 95.18,67.62 99.31,63.49 99.31,62.2 103.79,57.73 103.79,52.94 105.58,51.16 115.19,51.16 120.16,46.19 120.16,43.39 120.16,43.35 119.44,42.63 116.15,42.63 113.75,40.23 v1(113.75,37.95)
  BOTTOM w0.147: R446.1 v1(113.75,37.95)
SOC_OSC0: length 0.6
  TOP w0.147: U23.G13 v1(94.66,75.1)
SOC_OSPI_DQ0: length 46.4
  TOP w0.147: U23.M19 v1(89.86,70.3)
  L03_SIG1 w0.091: v1(100.35,36.94) 100.82,37.41 100.82,46.63 99.72,47.73 99.72,48.61 99.9,48.8 99.9,55.12 99.76,55.27 99.65,55.27 99.45,55.07 99.34,55.07 99.26,55.15 99.26,55.26 99.45,55.46 99.45,55.57 99.37,55.66 99.26,55.66 99.06,55.46 98.95,55.46 98.87,55.54 98.87,55.65 99.07,55.85 99.07,55.96 98.98,56.04 98.87,56.04 98.67,55.85 98.56,55.85 98.48,55.93 98.48,56.04 98.68,56.24 98.68,56.35 98.6,56.43 98.48,56.43 98.29,56.23 98.17,56.23 98.09,56.31 98.09,56.43 98.29,56.63 98.29,56.74 98.21,56.82 98.1,56.82 97.9,56.62 97.78,56.62 97.7,56.7 97.7,56.82 97.9,57.01 97.9,57.13 97.82,57.21 97.71,57.21 97.51,57.01 97.4,57.01 97.32,57.09 97.32,57.2 97.51,57.4 97.51,57.51 97.43,57.6 97.32,57.6 97.13,57.4 97.01,57.4 96.93,57.48 96.93,57.6 97.13,57.79 97.13,57.9 96.94,58.09 96.94,59.23 94.9,61.27 91.71,61.27 90.01,62.97 90.01,64.78 90.27,65.04 90.27,65.98 90.16,66.09 90.16,70.01 v1(89.86,70.3)
  BOTTOM w0.147: R440.2 v1(100.35,36.94)
SOC_OSPI_DQ1: length 47.1
  TOP w0.147: U23.M18 v1(89.86,71.1)
  L03_SIG1 w0.091: v1(89.86,71.1) 89.46,70.71 89.46,68.39 89.18,68.11 89.18,67.18 88.65,66.65 88.65,65.66 89.47,64.83 89.47,62.87 91.33,61.01 91.33,60.34 91.71,59.96 94.1,59.96 95.78,58.28 95.78,48.23 94.46,46.91 94.46,46.64 94.38,46.56 94.04,46.56 93.96,46.48 93.96,46.37 94.04,46.29 94.38,46.29 94.46,46.21 94.46,46.09 94.38,46.01 94.04,46.01 93.96,45.93 93.96,45.82 94.04,45.74 94.38,45.74 94.46,45.66 94.46,45.55 94.38,45.47 94.04,45.47 93.96,45.38 93.96,45.27 94.04,45.19 94.38,45.19 94.46,45.11 94.46,45 94.38,44.92 94.04,44.92 93.96,44.84 93.96,44.72 94.04,44.64 94.38,44.64 94.46,44.56 94.46,44.45 94.38,44.37 94.04,44.37 93.96,44.29 93.96,44.17 94.04,44.09 94.38,44.09 94.46,44.01 94.46,43.9 94.38,43.82 94.04,43.82 93.96,43.74 93.96,43.63 94.04,43.55 94.38,43.55 94.46,43.46 94.46,43.35 94.38,43.27 94.04,43.27 93.96,43.19 93.96,43.08 94.04,43 94.38,43 94.46,42.92 94.46,42.8 94.38,42.72 94.04,42.72 93.96,42.64 93.96,42.53 94.04,42.45 94.38,42.45 94.46,42.37 94.46,41.43 94.68,41.21 95.59,41.21 v1(96.01,40.78)
  BOTTOM w0.147: v1(96.01,40.78) 95.42,41.38 93.92,41.38 93.36,40.82 R433.2
SOC_OSPI_DQ2: length 47.5
  TOP w0.147: v1(90.93,67.07) 90.93,68.19 90.66,68.46 90.66,69.5 U23.M20
  L03_SIG1 w0.091: v1(90.93,67.07) 91.6,66.4 91.6,65.4 91.83,65.17 92.02,65.17 92.38,64.81 92.38,62.9 93.02,62.26 95.21,62.26 95.55,61.92 95.55,61.83 101.55,55.84 101.55,50.54 102.1,49.99 102.1,49.88 101.52,49.29 101.52,49.17 101.6,49.09 101.71,49.09 102.3,49.68 102.41,49.68 102.49,49.6 102.49,49.49 101.9,48.9 101.9,48.79 101.98,48.71 102.1,48.71 102.69,49.29 102.8,49.29 102.88,49.21 102.88,49.1 102.29,48.51 102.29,48.4 102.37,48.32 102.49,48.32 103.07,48.91 103.19,48.91 103.27,48.83 103.27,48.71 102.68,48.12 102.68,48.01 102.76,47.93 102.87,47.93 103.46,48.52 103.58,48.52 103.66,48.44 103.66,48.32 103.07,47.74 103.07,47.62 103.15,47.54 103.26,47.54 103.85,48.13 103.96,48.13 104.04,48.05 104.04,47.94 103.46,47.35 103.46,47.24 103.54,47.15 103.65,47.15 104.24,47.74 104.35,47.74 104.43,47.66 104.43,47.55 103.84,46.96 103.84,46.85 103.92,46.77 104.04,46.77 104.63,47.35 104.74,47.35 105.66,46.43 v1(105.66,44.46)
  BOTTOM w0.147: R423.2 v1(105.66,44.46)
SOC_OSPI_DQ3: length 47
  TOP w0.147: U23.M21 90.26,68.46 90.52,68.2 90.52,66.44 v1(91.17,65.79)
  L03_SIG1 w0.091: v1(91.17,65.79) 91.17,65.56 91.74,64.98 91.95,64.98 92.2,64.73 92.2,62.63 92.79,62.04 95.18,62.04 95.37,61.84 95.37,61.76 101.22,55.91 101.22,47.51 101.84,46.89 101.84,46.78 101.33,46.27 101.33,46.16 101.41,46.08 101.53,46.08 102.04,46.58 102.15,46.58 102.23,46.5 102.23,46.39 101.72,45.88 101.72,45.77 101.8,45.69 101.92,45.69 102.42,46.2 102.54,46.2 102.62,46.12 102.62,46 102.11,45.49 102.11,45.38 102.19,45.3 102.3,45.3 102.81,45.81 102.92,45.81 103,45.73 103,45.61 102.5,45.11 102.5,44.99 102.58,44.91 102.69,44.91 103.2,45.42 103.31,45.42 103.39,45.34 103.39,45.23 102.89,44.72 102.89,44.6 102.97,44.52 103.08,44.52 103.59,45.03 103.7,45.03 103.78,44.95 103.78,44.84 103.27,44.33 103.27,44.22 103.35,44.14 103.47,44.14 103.97,44.64 104.09,44.64 104.17,44.56 104.17,44.45 103.66,43.94 103.66,43.83 103.74,43.75 103.85,43.75 104.36,44.26 104.48,44.26 v1(105.66,43.07)
  BOTTOM w0.147: v1(105.66,43.07) 105.15,43.58 104.47,43.58 103.99,43.11 R425.2
SOC_OSPI_DQ4: length 48.3
  TOP w0.147: U23.P21 88.66,67.34 v1(88.32,67)
  L03_SIG1 w0.091: v1(88.32,67) 88.32,66.01 88.24,65.93 87.6,65.93 87.52,65.85 87.52,65.73 87.6,65.65 88.24,65.65 88.32,65.57 88.32,65.46 88.24,65.38 87.5,65.38 87.42,65.3 87.42,65.19 87.5,65.11 88.24,65.11 88.32,65.03 88.32,62.57 91.33,59.56 92.51,59.56 94.61,57.46 94.61,49.95 93.78,49.11 93.78,40.53 94.53,39.78 99.22,39.78 100.2,40.76 v1(100.2,42.05)
  BOTTOM w0.147: v1(100.2,42.05) 101.18,41.08 103.44,41.08 103.99,41.63 R432.2
SOC_OSPI_DQ5: length 46.9
  TOP w0.147: v1(87.37,63.64) 87.05,63.96 87.05,65.08 89.06,67.09 89.06,69.5 U23.P20
  L03_SIG1 w0.091: v1(99.08,36.94) 98.64,37.38 97.59,37.38 96.68,36.46 95.68,36.46 93.48,38.67 93.48,47.99 92.76,48.71 92.76,57.11 91.51,58.36 87.91,58.36 87.37,58.89 87.37,60.38 87.45,60.46 87.61,60.46 87.69,60.54 87.69,60.65 87.61,60.73 87.45,60.73 87.37,60.81 87.37,60.93 87.45,61.01 87.61,61.01 87.69,61.09 87.69,61.2 87.61,61.28 87.45,61.28 87.37,61.36 87.37,61.47 87.45,61.55 87.61,61.55 87.69,61.63 87.69,61.75 87.61,61.83 87.45,61.83 87.37,61.91 87.37,62.02 87.45,62.1 87.61,62.1 87.69,62.18 87.69,62.3 87.61,62.38 87.45,62.38 87.37,62.46 87.37,62.57 87.45,62.65 87.61,62.65 87.69,62.73 87.69,62.85 87.61,62.93 87.45,62.93 87.37,63.01 v1(87.37,63.64)
  BOTTOM w0.147: R441.2 v1(99.08,36.94)
SOC_OSPI_DQ6: length 47.7
  TOP w0.147: U23.N18 v1(89.06,71.1)
  L03_SIG1 w0.091: v1(89.06,71.1) 88.66,70.71 88.66,69.6 88.44,69.38 88.44,69.27 88.69,69.02 88.69,68.91 88.61,68.83 88.49,68.83 88.25,69.07 88.13,69.07 88.05,68.99 88.05,68.88 88.3,68.63 88.3,68.52 88.22,68.44 88.11,68.44 87.86,68.69 87.75,68.69 87.67,68.6 87.67,68.49 87.91,68.25 87.91,68.13 87.83,68.05 87.72,68.05 87.47,68.3 87.36,68.3 86.91,67.85 86.91,62.84 87.14,62.6 87.14,58.79 87.86,58.08 91.54,58.08 92.54,57.07 92.54,48.67 93.29,47.91 93.29,38.59 95.68,36.21 97.08,36.21 v1(97.81,36.94)
  BOTTOM w0.147: R442.2 v1(97.81,36.94)
SOC_OSPI_DQ7: length 48.6
  TOP w0.147: U23.M17 v1(89.86,71.9)
  L03_SIG1 w0.091: v1(96.54,36.94) 97.19,37.6 99.07,37.6 100.16,36.5 100.53,36.5 101.04,37.01 101.04,46.67 99.9,47.81 99.9,48.54 100.09,48.72 100.09,54.04 100.85,54.81 100.85,55.76 94.94,61.67 92.63,61.67 91.98,62.33 91.61,62.33 91.09,62.85 91.09,64.86 90.45,65.51 90.45,66.27 90.36,66.36 90.36,70.09 90.3,70.15 90.3,71.47 v1(89.86,71.9)
  BOTTOM w0.147: R443.2 v1(96.54,36.94)
SOC_POWER_MON_PORZ: length 65.5
  TOP w0.147: U41.1 v1(139.56,39.86)
  L08_SIG2 w0.091: v1(130.05,96.41) 130.05,87.9 136.65,81.29 136.65,69.48 140.46,65.67 140.46,41.54 139.56,40.64 v1(139.56,39.86)
  BOTTOM w0.147: v1(130.05,96.41) 129.9,96.26 R285.2 129.9,95.01 129.58,94.68 U76.4
SOC_SPI0_CLK: length 41
  TOP w0.147: U23.D13 v1(97.06,75.1)
  L03_SIG1 w0.091: v1(116.81,59.38) 116.31,59.88 116.31,65.41 114.77,66.95 114.77,72.5 111.97,75.3 103.21,75.3 102.73,75.78 99.11,75.78 98.57,76.32 97.71,76.32 97.46,76.07 97.46,75.56 97.06,75.16 v1(97.06,75.1)
  BOTTOM w0.147: U83.2 116.13,56.32 115.88,56.57 R395.1 115.88,58.16 115.37,58.67 TP77.1 116.12,59.45 116.19,59.38 v1(116.81,59.38)
SOC_SPI0_CS0: length 48.2
  TOP w0.147: U23.D12 v1(97.06,75.9)
  L03_SIG1 w0.091: v1(97.06,75.9) 97.06,76.28 97.63,76.85 102.36,76.85 103.47,75.74 112.16,75.74 115.22,72.68 115.22,67.08 116.72,65.58 116.72,60.62 v1(117.75,59.59)
  BOTTOM w0.147: U83.1 R399.1 TP80.1 111.89,56.17 112.62,56.9 112.62,57.66 115.04,60.07 117.27,60.07 v1(117.75,59.59)
SOC_SPI0_MISO: length 41.7
  TOP w0.147: U23.A14 100.24,74.7 100.35,74.59 100.35,74.59 100.51,74.44 100.78,74.44 v1(101.4,73.82)
  L03_SIG1 w0.091: v1(120.6,56.11) 115.84,56.11 114.09,57.86 114.09,64.96 112.61,66.45 112.61,69.73 110.41,71.92 110.41,73.75 109.98,74.18 103.12,74.18 102.76,73.82 v1(101.4,73.82)
  BOTTOM w0.147: v1(120.6,56.11) 121.03,55.68 TP79.1 R398.1 U83.4
SOC_SPI0_MOSI: length 36
  TOP w0.147: v1(101.47,75.07) 101.02,75.52 100.28,75.52 100.27,75.5 U23.A13
  L03_SIG1 w0.091: v1(101.47,75.07) 101.91,74.64 102.67,74.64 102.89,74.86 111.6,74.86 113.72,72.74 113.72,66.11 115.42,64.41 115.42,59.48 v1(116.2,58.69)
  BOTTOM w0.147: v1(116.2,58.69) 116.25,58.64 116.66,58.64 116.68,58.66 TP76.1 117.19,58.16 117.04,58.01 R394.1 117.04,56.57 116.78,56.32 U83.3
SOC_SPI1_CLK: length 114.2
  TOP w0.147: J2.C1 v1(74.55,129.81) ; U23.C14 v1(97.86,74.3)
  L03_SIG1 w0.091: v1(97.86,74.3) 99.09,73.07 101.56,73.07 101.56,73.07 105.28,73.07 v1(105.61,73.4) ; v1(121.28,109.87) 120.18,109.87 116.18,113.87 96.57,113.87 94.18,116.26 94.18,117.78 88.46,123.5 85.39,123.5 82.95,125.94 79.46,125.94 75.59,129.81 v1(74.55,129.81)
  L08_SIG2 w0.091: v1(121.28,109.87) 120.3,108.89 120.3,88.24 118.02,85.96 118.02,77.02 114.03,73.04 105.97,73.04 v1(105.61,73.4)
SOC_SPI1_CS0: length 108.6
  TOP w0.147: U23.B14 98.66,75.1 99.97,75.1 100,75.07 v1(100.46,75.07) ; J2.D1 v1(74.55,131.08)
  L03_SIG1 w0.091: v1(74.55,131.08) 75.44,131.08 76.84,129.68 76.84,129.19 79.64,126.39 83.13,126.39 85.58,123.94 88.55,123.94 93.86,118.62 114.31,118.62 v1(120.27,112.66)
  L08_SIG2 w0.091: v1(100.46,75.07) 100.9,75.52 110.89,75.52 113.03,77.66 113.03,80.95 114.48,82.4 114.48,83.37 119.64,88.53 119.64,112.03 v1(120.27,112.66)
SOC_SPI1_CS1: length 118.8
  TOP w0.147: J2.D2 v1(73.28,131.08) ; U23.D14 v1(97.06,74.3)
  L03_SIG1 w0.091: v1(97.06,74.3) 97.29,74.3 97.69,74.7 98.02,74.7 99.33,73.39 102.59,73.39 103.13,73.93 105.71,73.93 106.6,73.04 107.44,73.04 v1(107.95,72.53) ; v1(73.28,131.08) 73.91,130.44 75.27,130.44 79.55,126.16 83.04,126.16 85.49,123.72 86.85,123.72 86.89,123.68 88.54,123.68 94.36,117.86 94.36,116.34 96.6,114.09 116.58,114.09 120.29,110.39 121.4,110.39 v1(122.05,109.74)
  L08_SIG2 w0.091: v1(122.05,109.74) 122.05,109.1 120.52,107.58 120.52,88.15 118.24,85.87 118.24,76.99 114.11,72.86 108.91,72.86 108.59,72.53 v1(107.95,72.53)
SOC_SPI1_MISO: length 89.3
  TOP w0.147: v1(106.68,81.29) 106.68,80.41 103.76,77.48 103.76,75.06 101.81,73.11 101.02,73.11 100.23,73.9 U23.A15 ; J2.B1 v1(74.55,128.54)
  L03_SIG1 w0.091: v1(106.68,81.29) 107.38,82 107.38,103.01 97.65,112.74 78.3,112.74 75.39,115.65 74.65,115.65 73,117.29 73,119.27 71.88,120.39 71.88,125.87 v1(74.55,128.54)
SOC_SPI1_MOSI: length 90.5
  TOP w0.147: U23.B15 98.66,74.3 100.23,74.3 101.13,73.4 101.68,73.4 103.46,75.18 103.46,77.61 105.28,79.43 v1(105.28,80.64) ; J2.B2 v1(73.28,128.54)
  L03_SIG1 w0.091: v1(105.28,80.64) 107.16,82.52 107.16,102.92 97.56,112.51 78.2,112.51 75.29,115.42 73.85,115.42 72.04,117.23 72.04,118.14 70.89,119.29 70.89,126.15 v1(73.28,128.54)
SOC_TCK: length 87.9
  TOP w0.147: v1(126.16,60.42) 126.48,60.09 126.48,58.77 124.18,56.46 121.87,56.46 120.95,55.55 117.32,55.55 115.66,53.89 111.63,53.89 108.16,50.42 100.85,50.42 99.55,51.72 97.57,51.72 95.95,53.34 R147.2 ; v1(101.6,77.99) 101.11,77.5 100.9,77.5 100.88,77.49 100.54,77.49 100.52,77.5 98.66,77.5 U23.B11
  L03_SIG1 w0.091: v1(101.6,77.99) 102.05,77.55 111.31,77.55 115.88,72.97 115.88,67.25 117.34,65.78 117.34,61.94 118.74,60.55 123.06,60.55 123.19,60.42 v1(126.16,60.42)
  BOTTOM w0.147: v1(126.16,60.42) 126.21,60.37 R506.2
SOC_TDI: length 91.8
  TOP w0.147: U23.C11 v1(97.86,77.5) ; v1(125.43,59.59) 124.92,59.08 120.02,59.08 115.41,54.48 111.36,54.48 107.89,51.01 101.09,51.01 99.79,52.31 97.81,52.31 95.93,54.19 86.31,54.19 85.23,53.11 85.23,51.87 85.69,51.41 U37.7
  L03_SIG1 w0.091: v1(97.86,77.5) 98.29,77.07 102.45,77.07 103.56,75.96 112.25,75.96 115.44,72.77 115.44,67.17 116.94,65.67 116.94,61.6 119.33,59.2 122.87,59.2 122.89,59.22 125.06,59.22 v1(125.43,59.59)
  BOTTOM w0.147: U98.4 126.32,58.7 125.97,59.05 125.96,59.05 v1(125.43,59.59)
SOC_TDO: length 84.1
  TOP w0.147: U46.2 v1(90.48,33.03) ; U56.2 120.3,50.62 120.44,50.48 v1(120.45,50.48)
  L03_SIG1 w0.091: v1(120.45,50.48) 117.51,53.42 110.54,53.42 107.72,56.24 107.72,56.95 107.19,57.48 107.19,64.82 104.48,67.53 104.48,70.83 v1(103.43,71.87)
  BOTTOM w0.147: v1(103.43,71.87) 103.43,72.33 102,73.76 102,75.22 102.09,75.32 R323.1 ; v1(90.48,33.03) 92.72,35.28 93.01,35.28 94.02,36.28 99.2,36.28 102.06,33.43 109.67,33.43 110.39,34.14 110.39,34.29 113.21,37.11 113.21,40.87 115.21,42.88 115.21,44.48 116.83,46.09 117.02,46.09 117.29,46.35 117.29,46.55 120.45,49.71 v1(120.45,50.48)
SOC_TMS: length 104.5
  TOP w0.147: v1(126.21,61.14) 125.65,60.58 125.65,60.07 125.95,59.78 125.95,58.92 124.66,57.63 118.98,57.63 115.53,54.18 111.5,54.18 108.02,50.71 100.97,50.71 99.67,52.01 97.69,52.01 95.81,53.89 86.44,53.89 85.69,53.14 85.69,52.43 86.19,51.93 U37.6 ; U23.C12 v1(97.86,75.9)
  L03_SIG1 w0.091: v1(97.86,75.9) 98.61,75.9 98.93,75.58 102.62,75.58 103.12,75.08 111.88,75.08 114.55,72.4 114.55,66.91 115.95,65.51 115.95,59.64 116.99,58.6 116.99,58.09 117.47,57.61 118.19,57.61 118.32,57.74 124.68,57.74 125.36,58.42 127.28,58.42 128.35,59.49 128.35,60.3 127.51,61.14 v1(126.21,61.14)
  BOTTOM w0.147: v1(126.21,61.14) 127.05,61.14 127.43,60.76 127.43,58.75 127.32,58.63 U98.6
SOC_TRST#: length 97.3
  TOP w0.147: v1(127.91,59.74) 127.91,58.68 125.22,55.98 121.89,55.98 121.01,55.09 117.4,55.09 115.86,53.56 111.73,53.56 108.3,50.12 100.73,50.12 99.42,51.42 97.44,51.42 96.04,52.83 87.91,52.83 87.46,52.38 87.46,51.96 87.19,51.69 U37.4 ; U23.D11 v1(97.06,77.5)
  L03_SIG1 w0.091: v1(127.91,59.74) 126.09,59.74 125.81,60.02 125.02,60.02 124.69,59.69 120.32,59.69 119.74,60.27 118.66,60.27 117.16,61.78 117.16,61.93 117.16,65.71 115.66,67.21 115.66,72.88 112.36,76.18 103.65,76.18 102.55,77.29 98.87,77.29 98.26,77.9 97.46,77.9 v1(97.06,77.5)
  BOTTOM w0.147: v1(127.91,59.74) 127.91,58.83 127.82,58.73 U98.7 ; R322.1 98.77,77.38 98.29,76.9 97.66,76.9 v1(97.06,77.5)
SOC_USB0_VBUS: length 104.1
  TOP w0.147: U23.T14 v1(86.66,74.3)
  L08_SIG2 w0.091: v1(86.66,74.3) 86.28,73.93 82.51,73.93 80.87,75.56 76.56,75.56 76.5,75.63 76.48,75.63 74.95,77.15 61.55,77.15 47.35,62.95 47.35,62.38 46.99,62.03 46.99,59.82 43.64,56.46 21.47,56.46 v1(6.91,41.9)
  BOTTOM w0.147: R436.1 7.35,38.26 5.95,39.66 R427.2 6.63,42.18 v1(6.91,41.9)
SOC_VSENSE: length 10.4
  TOP w0.147: TP30.1 97.29,63.45 96.66,64.09 U23.D21
SOC_WARM_RESETZ: length 68
  TOP w0.147: TP70.1 124.59,29.61 124.59,27.7 v1(124.46,27.58) U50.2 ; U23.E18 v1(96.26,71.1)
  L03_SIG1 w0.091: v1(96.26,71.1) 96.26,70.99 96.66,70.59 96.66,67.08 99.98,63.76 99.98,62.48 105.1,57.35 105.1,55.44 107.89,52.65 117.6,52.65 119.84,50.41 119.84,50.23 121.2,48.87 v1(121.97,48.87)
  L08_SIG2 w0.091: v1(121.97,48.87) 122.45,48.39 122.45,46.74 125.04,44.15 125.04,28.16 v1(124.46,27.58)
  BOTTOM w0.147: R476.1 125.11,27.58 v1(124.46,27.58)
SUPERVISOR_DEBOUNCE_RSTN: length 37.6
  TOP w0.147: Q9.2 128,23.49 v1(127.64,23.13) ; v1(136.42,19.01) 136.64,18.8 SW7.2 136.64,16.7 136.09,16.15 136.09,11.29 136.64,10.75 SW7.1 ; U57.2 v1(122,21.55)
  BOTTOM w0.147: R540.1 139.25,17.96 139.21,17.92 C468.2 137.42,17.92 137.31,18.03 D10.2 136.73,18.71 v1(136.42,19.01) 134.98,19.01 133.48,20.51 133.48,23.89 132.33,25.03 129.67,25.03 129.16,24.53 127.89,24.53 127.64,24.27 v1(127.64,23.13) 122.94,23.13 122,22.19 v1(122,21.55)
SUPERVISOR_MR_RSTN: length 76.6
  TOP w0.147: U57.4 v1(122.65,25.63)
  L08_SIG2 w0.091: v1(122.65,25.63) 123.42,25.63 125.4,27.61 125.4,46.08 122.45,49.02 122.45,56.06 121.64,56.87 121.64,65.23 121.35,65.52 121.35,73.42 121.35,73.42 121.35,89.11 v1(124.21,91.96)
  BOTTOM w0.147: U76.1 127.41,93.14 126.24,91.96 v1(124.21,91.96)
SYNC1_OUT_TP: length 68.8
  TOP w0.147: U23.D18 v1(97.06,71.1) ; v1(103.56,70.12) 104.13,69.55 104.13,69.12 105.51,67.73 111.18,67.73 111.48,68.04 113.01,68.04 115.1,70.13 115.1,79.22 v1(114.3,80.02)
  L03_SIG1 w0.091: v1(103.56,70.12) 103.29,69.86 101.74,69.86 100.49,71.1 v1(97.06,71.1)
  L08_SIG2 w0.091: J12.1 120.96,112.47 120.96,112.23 120.08,111.34 120.08,88.35 114.94,83.2 114.94,80.66 v1(114.3,80.02)
SYS_BOOTMODE0: length 70.4
  TOP w0.147: SW2.1 v1(83.19,20.77)
  L08_SIG2 w0.091: v1(68.81,66.72) 68.81,66.28 70.18,64.92 70.18,60.14 72.39,57.93 72.39,55.49 72.73,55.15 72.73,52.78 73.1,52.41 73.1,46.09 79.35,39.85 79.35,35.28 82.84,31.79 82.84,29.16 83.62,28.38 83.62,21.2 v1(83.19,20.77)
  BOTTOM w0.147: R529.1 v1(83.19,20.77) 85.27,18.68 92.23,18.68 94.6,21.06 U96.1 ; v1(68.81,66.72) 69.31,67.22 U79.3
SYS_BOOTMODE1: length 71.4
  TOP w0.147: SW2.2 v1(84.46,20.77)
  L08_SIG2 w0.091: v1(84.46,20.77) 84.01,20.32 82.99,20.32 82.66,20.66 82.66,31.71 79.16,35.21 79.16,39.77 72.87,46.06 72.87,52.33 71.75,53.45 71.75,54.44 71.91,54.6 71.91,58.1 69.95,60.05 69.95,64.83 68.38,66.41 68.38,67.42 v1(68.81,67.86)
  BOTTOM w0.147: U79.4 v1(68.81,67.86) ; R519.1 v1(84.46,20.77) 86.24,18.98 92.1,18.98 93.85,20.73 93.85,21.97 94,22.11 U96.2
SYS_BOOTMODE2: length 72.3
  TOP w0.147: SW2.3 v1(85.73,20.77)
  L08_SIG2 w0.091: v1(67.81,66.72) 68.16,66.38 68.16,66.31 69.27,65.2 69.27,61.54 68.83,61.1 68.83,58.04 70.61,56.26 70.61,54.27 72.69,52.2 72.69,45.99 78.98,39.69 78.98,35.13 82.47,31.64 82.47,20.56 82.93,20.11 85.06,20.11 v1(85.73,20.77)
  BOTTOM w0.147: U96.3 93.85,22.61 93.56,22.33 93.56,20.85 91.98,19.27 87.22,19.27 v1(85.73,20.77) R514.1 ; v1(67.81,66.72) 68.31,67.22 U79.5
