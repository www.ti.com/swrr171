# Allegro board PROC101A_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LM5140_COMP1: length 6.8
  TOP w0.147: U30.29 158.34,59.48 157.81,58.96 156.2,58.96 155.58,59.58 154.44,59.58 154.03,59.16 R142.2 154.03,57.94 C135.1
LM5140_COMP2: length 4
  TOP w0.147: C130.1 168.2,59.14 168.18,59.16 R141.2 166.94,59.16 166.63,59.48 U30.2
MCAN0_H: length 7.8
  TOP w0.104: U4.7 21.97,126.78 22.07,126.88 22.37,126.88 22.48,126.99 22.48,127.4 R4.1 22.48,128.16 22.48,129.43 J31.1
MCAN0_L: length 7.8
  TOP w0.104: J31.3 22.73,129.42 22.73,128.16 R5.2 22.73,127.4 22.73,126.99 22.83,126.88 23.13,126.88 23.24,126.78 U4.6
MCAN0_RX: length 41.8
  L08_SIG2 w0.091: J9.1 27.1,117.16 27.1,117.98 28.31,119.19 40.29,119.19 41.09,118.4 41.82,118.4 45.13,115.09 50.05,115.09 51.31,116.35 51.31,118.52 v1(50.66,119.17)
  BOTTOM w0.147: R220.1 24.51,118.5 24.13,118.12 24.13,116.08 24.51,115.7 J9.1 ; v1(50.66,119.17) 50.18,119.65 U67.2
MCAN0_RX/HSE: length 123.1
  TOP w0.147: v1(72.9,115.2) 78.36,115.2 79.37,114.18 97.49,114.18 107.49,104.18 107.49,92.29 112.49,87.3 112.49,82.65 115.39,79.74 115.39,70.01 113.13,67.75 111.6,67.75 111.3,67.44 105.28,67.44 103.83,68.88 103.83,69.16 103.38,69.61 101.99,69.61 101.25,70.35 101.25,71.31 99.86,72.7 98.66,72.7 U23.B17
  BOTTOM w0.147: v1(72.9,115.2) 71.87,116.22 60.96,116.22 59.69,117.49 54.22,117.49 53.36,118.35 U67.4
MCAN0_STB_3V3: length 120.6
  TOP w0.381: U4.8 R9.2 19.05,126.5 v1(19.05,126.51)
  L03_SIG1 w0.091: v1(19.05,126.51) 21.21,124.35 30.88,124.35 35.69,119.54 35.69,114.57 34.67,113.55 34.67,109.68 33.78,108.8 33.78,95.14 37.03,91.89 37.03,88.43 37.97,87.48 37.97,78.69 38.73,77.92 38.73,70.82 39.63,69.93 39.63,63.26 39.88,63.01 39.88,45.8 42.67,43 43.96,43 46.34,40.63 46.34,36.52 50.37,32.49 50.37,31.75 50.7,31.41 v1(51.07,31.41)
  BOTTOM w0.147: U91.9 v1(51.07,31.41)
MCAN0_T: length 8
  TOP w0.147: v1(19.92,128.52) C2.1 R4.2 ; R5.1 v1(24.89,127.78)
  BOTTOM w0.147: v1(19.92,128.52) 20.66,127.78 v1(24.89,127.78)
MCAN0_TX: length 41.5
  L08_SIG2 w0.091: J9.2 24.82,117.42 25.21,117.42 27.23,119.43 40.62,119.43 41.33,118.73 41.82,118.73 45.23,115.31 49.89,115.31 50.79,116.21 v1(50.79,117.14)
  BOTTOM w0.147: U67.5 50.23,117.7 v1(50.79,117.14) ; R221.1 20.7,117.74 21.97,116.47 J9.2
MCAN0_TX/HSE: length 122.2
  TOP w0.147: v1(71.63,115.71) 73.28,115.71 73.41,115.58 78.38,115.58 79.49,114.48 97.61,114.48 108.08,104.01 108.08,92.12 112.78,87.42 112.78,82.77 115.69,79.87 115.69,69.89 113.26,67.45 111.73,67.45 111.42,67.14 105.06,67.14 102.94,69.27 101.91,69.27 100.97,70.22 100.97,71.19 99.85,72.3 U23.A17
  BOTTOM w0.147: v1(71.63,115.71) 56.9,115.71 56.01,116.6 54.48,116.6 54.28,116.4 U67.7
MCAN1_H: length 7.8
  TOP w0.104: U3.7 12.07,126.78 12.17,126.88 12.47,126.88 12.57,126.99 12.57,127.4 R2.1 12.57,128.15 12.57,129.43 J32.1
MCAN1_L: length 7.8
  TOP w0.104: 13.34,125.78 13.34,126.78 13.23,126.88 12.93,126.88 12.83,126.99 12.83,127.4 R3.2 12.82,128.16 12.82,129.42 J32.3
MCAN1_RX: length 40.7
  L08_SIG2 w0.091: v1(44.15,117.05) 42.09,119.11 41.41,119.11 40.79,119.73 19.39,119.73 J10.1
  BOTTOM w0.147: J10.1 13.84,115.44 14.6,116.2 R222.1 ; U67.11 v1(44.15,117.05)
MCAN1_RX/HSE: length 91
  TOP w0.147: U23.D17 v1(97.06,71.9)
  L03_SIG1 w0.091: v1(97.06,71.9) 96.98,71.9 96.58,72.31 88.93,72.31 88.69,72.55 88.69,75.26 88.95,75.52 89.2,75.52 89.43,75.75 89.43,78.46 89.18,78.71 84.11,78.71 81.66,81.16 81.66,82 78.93,84.73 78.93,94.95 v1(77.53,96.34)
  BOTTOM w0.147: U67.9 44.75,115.75 46.19,114.31 54.23,114.31 55.24,113.3 59.78,113.3 60.55,114.07 70.73,114.07 77.09,107.71 77.09,96.79 v1(77.53,96.34)
MCAN1_STB_3V3: length 131.7
  TOP w0.381: v1(9.15,126.51) 9.14,126.5 R8.2 U3.8
  L03_SIG1 w0.091: v1(9.15,126.51) 11.56,124.09 29.73,124.09 35.45,118.38 35.45,114.97 33.73,113.24 33.73,111.58 34.36,110.94 34.36,109.69 33.56,108.89 33.56,94.98 36.03,92.51 36.03,88.43 36.56,87.9 37.08,87.9 37.75,87.23 37.75,78.59 38.51,77.83 38.51,63.74 39.66,62.59 39.66,44.01 41.25,42.42 42.34,42.42 43.69,41.07 43.69,38.86 50.14,32.41 50.14,31.41 50.68,30.88 51.31,30.88 51.69,31.26 51.69,31.81 v1(51.82,31.94)
  BOTTOM w0.147: U91.10 51.84,31.91 v1(51.82,31.94)
MCAN1_T: length 8
  TOP w0.147: R2.2 C1.1 v1(10.01,128.52) ; R3.1 v1(14.99,127.78)
  BOTTOM w0.147: v1(14.99,127.78) 10.76,127.78 v1(10.01,128.52)
MCAN1_TX: length 43.4
  L08_SIG2 w0.091: J10.2 17.2,120.09 43.14,120.09 v1(44.44,118.79)
  BOTTOM w0.147: v1(44.44,118.79) 44.23,119 U67.14 ; R223.1 10.8,115.95 11.3,115.44 J10.2
MCAN1_TX/HSE: length 93.5
  TOP w0.147: U23.C17 v1(97.86,71.9)
  L03_SIG1 w0.091: v1(97.86,71.9) 97.46,72.31 96.92,72.31 96.66,72.57 96.66,72.85 96.4,73.11 89.64,73.11 89.48,73.27 89.48,75.26 89.7,75.49 89.98,75.49 90.27,75.78 90.27,79.23 89.99,79.52 84.11,79.52 82.04,81.58 82.04,81.93 79.15,84.82 79.15,95.82 v1(77.54,97.42)
  BOTTOM w0.147: U67.12 44.57,117.7 44.78,117.49 44.78,116.18 46.14,114.82 54.36,114.82 55.5,113.68 57.4,113.68 58.17,114.44 70.99,114.44 77.54,107.89 v1(77.54,97.42)
MCU_GPIO0_6: length 161.9
  TOP w0.147: v1(123.38,31.95) 123.38,41.86 131.44,49.93 131.44,54.94 129.95,56.44 129.95,59.21 125.75,63.4 125.75,66.03 124.84,66.94 124.84,70.23 123.44,71.63 122.06,71.63 v1(116.87,76.82) ; U23.B7 98.66,80.7 99.22,80.7 99.27,80.66 100.72,80.66 100.76,80.7 v1(101.22,80.7)
  L03_SIG1 w0.091: v1(116.87,76.82) 116.87,78.48 116.47,78.87 106.2,78.87 103.92,81.15 101.67,81.15 v1(101.22,80.7)
  L08_SIG2 w0.091: J1.8 147.96,129.81 147.96,127.9 144.21,124.15 142.06,124.15 140.24,122.33 122.42,122.33 116.57,116.48 116.57,97.46 111.99,92.88 110.85,92.88 108,90.03 108,86.98 102.13,81.11 101.62,81.11 v1(101.22,80.7)
  BOTTOM w0.147: R470.2 v1(123.38,31.95)
MCU_GPIO0_7: length 89.3
  TOP w0.147: U23.D7 v1(97.06,80.7)
  L08_SIG2 w0.091: v1(97.06,80.7) 97.46,80.3 98.34,80.3 98.44,80.2 105.45,80.2 106.17,80.93 106.17,82.62 106.26,82.71 106.26,84.46 108.59,86.79 108.59,88.51 117.24,97.16 117.24,115.33 122.78,120.88 140.44,120.88 141.3,121.74 144.96,121.74 J1.9
MCU_GPIO0_8: length 83.2
  TOP w0.147: U23.C7 v1(97.86,80.7)
  L08_SIG2 w0.091: v1(97.86,80.7) 98.84,80.7 99.14,80.41 100.39,80.41 101.28,81.29 102.05,81.29 107.78,87.02 107.78,90.13 110.76,93.1 111.9,93.1 116.35,97.55 116.35,116.58 122.33,122.55 140.15,122.55 142.95,125.36 143,125.36 144.53,125.36 146.18,127.01 146.18,128.03 J1.5
MCU_GPIO0_9: length 93.3
  TOP w0.147: U23.C8 v1(97.86,79.9)
  L08_SIG2 w0.091: J1.12 153.16,129.94 153.16,128.37 152.35,127.56 151.08,127.56 144.22,120.7 122.88,120.7 117.46,115.28 117.46,97.12 108.77,88.44 108.77,86.72 107.19,85.14 107.19,81.18 105.99,79.98 100.6,79.98 100.53,79.9 v1(97.86,79.9)
MCU_I2C0_SCL: length 91.5
  L08_SIG2 w0.091: v1(111.76,83.07) 113.1,83.07 113.74,83.71 114.54,83.71 119.19,88.35 119.19,113.26 123.46,117.54 153.21,117.54 163.19,127.53 163.19,129.81 J1.20
  BOTTOM w0.147: R593.1 113.39,82.28 113.25,82.42 112.51,82.42 112.41,82.52 R311.2 v1(111.76,83.07)
MCU_I2C0_SCL_RC: length 23.2
  TOP w0.147: U23.E9 v1(96.26,79.1)
  L08_SIG2 w0.091: v1(112.41,79.68) 112.41,77.71 110.47,75.76 100.14,75.76 97.98,77.92 97.7,77.92 97.48,78.15 97.48,78.43 97.2,78.71 96.73,78.71 96.33,79.1 v1(96.26,79.1)
  BOTTOM w0.147: R593.2 C487.1 v1(112.41,79.68)
MCU_I2C0_SDA: length 85.7
  L08_SIG2 w0.091: v1(111.76,84.34) 119,91.59 119,113.39 123.37,117.76 153.17,117.76 162.05,126.64 J1.17
  BOTTOM w0.147: R594.1 110.81,85.79 111.76,84.84 v1(111.76,84.34) R309.2
MCU_I2C0_SDA_RC: length 23.9
  TOP w0.147: U23.A10 v1(100.71,77.9)
  L08_SIG2 w0.091: v1(110.89,84.81) 111.25,84.45 111.25,82.06 111.81,81.5 111.81,77.36 110.39,75.95 102.67,75.95 v1(100.71,77.9)
  BOTTOM w0.147: C488.1 R594.2 v1(110.89,84.81)
MCU_I2C1_SCL: length 105.4
  TOP w0.147: v1(102.74,77.99) 101.85,77.1 U23.A11
  L08_SIG2 w0.091: J1.18 160.61,129.77 160.61,126.72 159.89,126 159.89,124.86 153.02,117.98 123.28,117.98 118.78,113.48 118.78,91.67 112.73,85.61 v1(111.76,85.61) 111.07,85.61 109.65,84.19 109.65,78.2 108.76,77.32 103.42,77.32 v1(102.74,77.99)
  BOTTOM w0.147: R306.2 v1(111.76,85.61)
MCU_I2C1_SDA: length 98.6
  TOP w0.147: v1(102.74,79.14) 102.05,78.45 101.41,78.45 101.34,78.37 100.59,78.37 100.52,78.3 98.66,78.3 U23.B10
  L08_SIG2 w0.091: J1.14 156.72,131.21 155.57,130.06 155.57,128.03 154.43,126.89 151.01,126.89 144.46,120.33 124.38,120.33 117.9,113.85 117.9,96.91 113.36,92.37 113.36,88.48 v1(111.76,86.88) 109.72,86.88 107.74,84.91 107.74,79.99 105.85,78.1 104.15,78.1 103.12,79.14 v1(102.74,79.14)
  BOTTOM w0.147: R303.2 v1(111.76,86.88)
MCU_OSC0_XI: length 9
  TOP w0.147: R138.2 99.19,63.99 97.46,65.73 U23.C21
MCU_OSC0_XO: length 11.3
  TOP w0.147: U23.B20 97.86,69.5 97.86,68.86 98.42,68.29 98.42,66.25 100.36,64.31 100.36,61.69 101.28,60.77 R140.2
MCU_PORZ: length 343.7
  TOP w0.147: TP33.1 123.33,50.97 v1(123.33,50.3) 123.78,50.3 123.99,50.51 R575.2 124.61,50.51 ; J2.E30 v1(37.72,132.35) ; 124.61,50.51 125.19,51.09 125.19,53.18 126.37,54.36 127.46,54.36 128.85,55.75 128.85,59.88 126.85,61.89 124.36,61.89 123.22,60.75 120.85,60.75 120.52,61.08 120.52,62.09 117.23,65.39 117.23,65.58 R606.1 116.66,66.16 115.3,66.16 113.96,64.82 100.88,64.82 98.77,66.93 98.77,68.35 98.37,68.75 98.37,68.99 U23.B21 ; 124.61,50.51 U35.4
  L03_SIG1 w0.091: v1(37.72,132.35) 36.52,131.14 36.52,129.27 34.49,127.25 27.79,127.25 25.28,124.74 21.36,124.74 20.7,125.4 20.7,126.31 19.76,127.25 17.3,127.25 14.59,124.54 11.84,124.54 9.32,127.05 8.81,127.05 8.5,126.74 8.5,125.64 10.33,123.81 23.72,123.81 28.42,119.1 28.42,117.71 28.18,117.47 27.64,117.47 26.36,118.75 23.32,118.75 20.77,116.2 20.77,93.98 24.71,90.05 24.71,88.51 28.93,84.29 28.93,64.83 26.62,62.53 26.62,45.34 28.96,43.01 29.92,43.01 35.83,37.1 43.61,37.1 47.4,33.31 47.4,32.2 47.27,32.08 47.27,31.57 47.63,31.22 48.43,31.22 52.32,27.32 55.5,27.32 66.93,15.89 78.36,15.89 79.33,14.92 90.51,14.92 94.05,11.38 103.05,11.38 108.07,16.4 112.9,16.4 118.36,21.86 118.36,28.02 123.19,32.85 123.19,49.79 123.33,49.93 v1(123.33,50.3)
MCU_RESETSTATZ: length 212.1
  TOP w0.147: J2.E3 v1(72.01,132.35) ; J1.19 164.59,127.54 TP1.1 ; U23.B13 98.66,75.9 101.66,75.9 v1(102.49,75.07)
  L03_SIG1 w0.091: v1(72.01,132.35) 72.45,132.79 75.64,132.79 77.72,130.7 77.72,129.55 80.01,127.27 82.3,127.27 85.22,130.19 85.22,131.97 86.11,132.86 93.32,132.86 99.15,127.02 134.88,127.02 137.79,129.94 163.32,129.94 J1.19
  L08_SIG2 w0.091: v1(102.49,75.07) 110.72,75.07 113.28,77.64 113.28,80.89 114.7,82.31 114.7,83.28 119.86,88.44 119.86,111.43 120.74,112.32 120.74,113.82 124.24,117.32 153.25,117.32 J1.19
MCU_RESETZ: length 173.3
  TOP w0.147: U23.B12 98.66,76.7 99.22,76.7 99.34,76.82 100.87,76.82 v1(101.35,76.34) 101.67,76.66 102.06,76.66 103.31,77.92 103.31,79.35 104.39,80.43 104.39,81.48 104.83,81.91 v1(105.28,81.91) ; v1(121.41,27.83) 121.41,27.72 121.55,27.58 U50.7 122.43,27.57 123.24,27.57 123.93,26.89 123.93,26.28 123.72,26.08 TP46.1 ; J2.D3 v1(72.01,131.08)
  L03_SIG1 w0.091: v1(72.01,131.08) 72.01,131.08 72.62,130.47 72.62,128.26 70.67,126.31 70.67,118.03 73.49,115.2 75.2,115.2 78.11,112.29 97.47,112.29 106.93,102.83 106.93,84.47 105.94,83.48 105.94,82.57 v1(105.28,81.91) ; v1(124.03,58.19) 123.66,58.19 123.58,58.12 118.62,58.12 117.24,59.49 117.24,59.72 116.5,60.46 116.5,65.49 115,66.99 115,72.59 112.06,75.52 103.31,75.52 102.49,76.34 v1(101.35,76.34)
  L08_SIG2 w0.091: v1(121.41,27.83) 121.41,25.54 122.17,24.78 123.15,24.78 125.78,27.41 125.78,46 122.68,49.1 122.68,56.29 124.03,57.63 v1(124.03,58.19)
  BOTTOM w0.147: R477.2 121.79,27.45 v1(121.41,27.83)
MCU_SAFETY_ERRORZ_1V8: length 75.7
  TOP w0.147: U23.A20 99.95,69.01 99.95,68.21 103.05,65.11 113.61,65.11 v1(114.68,66.18) ; U10.4 v1(126.73,115.06)
  L08_SIG2 w0.091: v1(126.73,115.06) 124.16,112.5 124.16,109.24 120.96,106.04 120.96,71.17 117.87,68.07 116.57,68.07 v1(114.68,66.18)
  BOTTOM w0.147: TP72.1 v1(114.68,66.18)
MCU_SAFETY_ERRORZ_3V3: length 51.1
  TOP w0.147: U10.1 v1(125.23,115.06)
  L08_SIG2 w0.091: v1(125.23,115.06) 125.23,115.73 126.6,117.1 155.17,117.1 165.74,127.66 165.74,129.81 J1.22
MCU_SPI0_CLK: length 78.7
  L08_SIG2 w0.091: J1.16 159.26,131.21 158.24,130.19 158.24,126.25 154.76,122.77 147.42,122.77 143.07,118.42 123.1,118.42 118.34,113.67 118.34,92.45 v1(114.05,88.15)
  BOTTOM w0.147: R302.1 v1(114.05,88.15)
MCU_SPI0_CLK_R: length 21
  TOP w0.147: U23.E6 v1(96.26,81.5)
  BOTTOM w0.114: 99.69,81.9 96.66,81.9 v1(96.26,81.5)
  BOTTOM w0.147: R302.2 111.45,88.15 110.01,86.72 101.94,86.72 99.95,84.72 99.95,82.16 99.69,81.9
MCU_SPI0_CS0: length 85.8
  TOP w0.147: U23.D6 v1(97.06,81.5)
  L08_SIG2 w0.091: J1.6 145.48,129.88 145.48,128.2 144.3,127.02 143.9,127.02 143.38,126.5 143.38,126.1 140.05,122.78 122.24,122.78 116.13,116.67 116.13,97.64 111.81,93.32 110.67,93.32 107.56,90.22 107.56,87.06 102,81.49 101.19,81.49 100.36,80.66 99.31,80.66 98.87,81.1 97.46,81.1 v1(97.06,81.5)
MCU_SPI0_CS1: length 80.3
  TOP w0.147: U23.C6 v1(97.86,81.5)
  L08_SIG2 w0.091: v1(97.86,81.5) 100.21,81.5 101.14,82.44 102.68,82.44 107.34,87.1 107.34,90.31 110.58,93.54 111.72,93.54 115.91,97.73 115.91,116.76 122.15,123 139.96,123 143.13,126.16 143.13,127.52 J1.3
MCU_SPI0_D0: length 85
  TOP w0.147: U23.E7 v1(96.26,80.7)
  L08_SIG2 w0.091: J1.4 142.88,129.81 142.88,126.22 139.87,123.22 122.06,123.22 115.69,116.85 115.69,97.83 111.63,93.76 110.48,93.76 107.12,90.4 107.12,87.13 102.66,82.67 101.09,82.67 100.34,81.92 96.91,81.92 96.66,81.67 96.66,81.11 v1(96.26,80.7)
MCU_SPI0_D1: length 81.2
  TOP w0.147: v1(103.72,88.24) 102.97,87.48 102.11,87.48 100.84,86.2 100.84,82.95 99.4,81.5 98.66,81.5 U23.B6
  L08_SIG2 w0.091: v1(103.72,88.24) 105.76,88.24 106.91,89.38 106.91,90.5 110.39,93.98 111.54,93.98 115.47,97.92 115.47,116.94 121.96,123.44 139.6,123.44 140.43,124.26 140.43,129.9 J1.2
MCU_UART0_CTS_3V3: length 65.4
  TOP w0.147: U23.D8 v1(97.06,79.9)
  L03_SIG1 w0.091: v1(144.02,54.24) 140.17,54.24 135.31,59.1 133.64,59.1 130.72,62.02 125.26,62.02 120.26,67.02 116.89,67.02 116.52,67.39 116.52,68.44 v1(116.78,68.7)
  BOTTOM w0.114: 98.3,79.5 97.46,79.5 v1(97.06,79.9)
  BOTTOM w0.147: 98.3,79.5 98.36,79.45 99.22,79.45 99.72,78.95 99.72,74.31 100.63,73.4 101.49,73.4 102.34,72.56 102.34,71.67 102.61,71.4 107.14,71.4 107.89,70.65 107.89,68.59 108.52,67.96 112.77,67.96 113.51,68.7 v1(116.78,68.7) ; U82.9 143.6,53.83 v1(144.02,54.24)
MCU_UART0_RTS_3V3: length 65.4
  TOP w0.147: U23.E8 v1(96.26,79.9)
  L03_SIG1 w0.091: v1(117.08,67.5) 120.1,67.5 125.35,62.24 130.81,62.24 133.73,59.32 135.4,59.32 140.22,54.5 142.11,54.5 142.51,54.89 142.51,55.41 v1(142.77,55.68)
  BOTTOM w0.114: v1(96.26,79.9) 96.66,79.5 96.66,78.94 96.89,78.7 98.19,78.7 98.51,79.02
  BOTTOM w0.147: v1(117.08,67.5) 116.18,68.4 113.63,68.4 112.89,67.66 108.4,67.66 107.59,68.46 107.59,70.53 107.02,71.1 102.48,71.1 102.29,71.3 101.39,71.3 99.41,73.27 99.41,78.85 99.24,79.02 98.51,79.02 ; v1(142.77,55.68) 142.77,55.22 142.57,55.02 142.57,54.43
MCU_UART0_RX_3V3: length 63
  TOP w0.147: U23.A9 99.54,78.7 99.56,78.69 101.01,78.69 101.04,78.71 101.31,78.71 v1(101.73,79.14)
  L03_SIG1 w0.091: v1(145.03,54.24) 144.45,53.66 142.13,53.66 141.77,54.02 140.07,54.02 135.21,58.88 133.55,58.88 130.63,61.8 125.13,61.8 120.1,66.84 116.81,66.84 116.32,67.33 116.32,73.16 111.49,77.99 103.68,77.99 103.02,78.65 102.21,78.65 v1(101.73,79.14)
  BOTTOM w0.147: v1(145.03,54.24) 144.35,54.93 143.26,54.93 142.97,54.63 U82.8
MCU_UART0_TX_3V3: length 61.9
  TOP w0.147: U23.A8 100.65,79.5 100.76,79.62 102.56,79.62 v1(103.6,80.66)
  L03_SIG1 w0.091: v1(142.99,56.6) 140.61,56.6 140.42,56.78 138.43,56.78 132.72,62.5 125.48,62.5 119.96,68.01 118.26,68.01 116.59,69.69 116.59,73.42 115.37,74.64 115.37,76.62 113.34,78.65 106.17,78.65 104.16,80.66 v1(103.6,80.66)
  BOTTOM w0.147: 142.99,57.42 R611.2 ; 142.99,57.42 142.17,56.59 U82.6 ; 142.99,57.42 v1(142.99,56.6)
MCU_UART1_CTS_3V3: length 89.5
  TOP w0.147: U23.B8 98.66,79.9 101.34,79.9 101.35,79.91 101.99,79.91 v1(102.74,80.66)
  L08_SIG2 w0.091: J1.10 150.46,129.78 150.46,128.12 146.05,123.71 142.24,123.71 139.59,121.06 122.62,121.06 117.02,115.46 117.02,97.28 112.14,92.4 110.94,92.4 108.41,89.87 108.41,86.87 106.08,84.54 106.08,82.78 105.64,82.34 104.42,82.34 v1(102.74,80.66)
MCU_UART1_RTS_3V3: length 96.9
  TOP w0.147: U23.B9 98.66,79.1 v1(100.84,79.1)
  L08_SIG2 w0.091: v1(100.84,79.1) 101.24,78.7 102.93,78.7 103.71,77.92 106.06,77.92 108.24,80.1 108.24,84.26 110.43,86.45 111.94,86.45 113.59,88.09 113.59,92.29 118.12,96.82 118.12,113.76 123.01,118.65 143.03,118.65 147.41,123.03 154.25,123.03 155.83,124.6 155.83,127.52 J1.13
MCU_UART1_RX_3V3: length 91.8
  TOP w0.147: U23.C9 v1(97.86,79.1)
  L08_SIG2 w0.091: J1.11 152.87,127.11 150.98,127.11 144.38,120.51 122.98,120.51 117.68,115.21 117.68,97.23 117.64,97.19 117.64,97.04 108.96,88.36 108.96,86.64 107.56,85.24 107.56,80.98 106.14,79.56 100.76,79.56 100.3,79.1 v1(97.86,79.1)
MCU_UART1_TX_3V3: length 100.8
  TOP w0.147: U23.D9 v1(97.06,79.1)
  L08_SIG2 w0.091: v1(97.06,79.1) 97.31,79.1 97.73,78.69 98.67,78.69 98.88,78.48 102.86,78.48 103.72,77.62 106.28,77.62 108.58,79.91 108.58,83.9 110.8,86.12 112.78,86.12 118.56,91.91 118.56,113.58 123.19,118.2 143.11,118.2 147.42,122.52 155.02,122.52 159.51,127.01 J1.15
MIPI_TCK: length 31.2
  TOP w0.147: U60.2 97.83,13.43 v1(97.18,14.08) ; R194.1 v1(72.52,21.74)
  L03_SIG1 w0.091: v1(97.18,14.08) 95.86,14.08 91.73,18.21 76.55,18.21 73.01,21.74 v1(72.52,21.74)
MIPI_TDI_R: length 3.4
  BOTTOM w0.147: J33.5 63.72,48.56 63.63,48.65 63.63,49.39 63.37,49.64 R410.1
MIPI_TDO_R: length 4.4
  BOTTOM w0.147: R450.2 64.26,38.11 63.22,39.15 J33.4
MIPI_TMS_R: length 4.3
  BOTTOM w0.147: R451.2 62.95,37.21 62.48,37.68 62.48,38.82 62.72,39.06 J33.2
MIPI_TRC_CLK: length 39.5
  TOP w0.147: v1(57.12,59.78) 59.28,59.78 62.68,63.18 62.68,65.24 65.36,67.93 65.36,68.15 66.05,68.85 66.56,68.85 68.02,70.31 68.02,71.06 67.79,71.29 RA2.16
  BOTTOM w0.147: v1(57.12,59.78) 61.42,55.48 61.42,55.27 61.23,55.08 61.23,54.91 61.35,54.79 61.52,54.79 61.73,55.01 62.07,55.01 62.19,54.89 62.19,54.72 61.99,54.52 61.99,54.36 62.11,54.24 62.27,54.24 62.47,54.44 62.64,54.44 62.75,54.32 62.75,54.16 62.56,53.96 62.56,53.79 62.67,53.67 62.84,53.67 63.04,53.87 63.2,53.87 63.32,53.75 63.32,53.59 63.12,53.39 63.12,53.22 63.24,53.11 63.41,53.11 63.61,53.3 63.77,53.3 63.89,53.19 63.89,53.02 63.69,52.82 63.69,52.66 64.01,52.34 64.01,49.67 64.97,48.71 65.38,48.71 65.72,48.37 J33.13
MIPI_TRC_CTL: length 36.7
  TOP w0.147: RA2.15 67.16,73.12 67.16,70.74 67.06,70.63 67.06,70.36 65.99,69.3 65.74,69.3 63.75,67.31 63.75,66.74 62.38,65.37 62.38,63.65 59.79,61.06 v1(56.78,61.06)
  BOTTOM w0.147: J33.17 66.72,51.37 57.89,60.2 57.64,60.2 v1(56.78,61.06)
MIPI_TRC_DAT00: length 36.7
  TOP w0.147: v1(57.03,62.73) 60.32,62.73 62.09,64.5 62.09,65.49 63.12,66.52 63.12,68.07 65.09,70.05 65.72,70.05 66.04,70.36 66.04,71.13 66.7,71.79 RA2.14
  BOTTOM w0.147: J33.19 67.22,51.28 57.03,61.47 v1(57.03,62.73)
MIPI_TRC_DAT01: length 36.9
  TOP w0.147: RA2.13 66.2,72.04 64.39,70.23 63.37,70.23 62.99,69.85 62.99,68.79 62.37,68.16 62.22,68.16 62.1,68.04 62.1,67.88 62.22,67.76 62.37,67.76 62.48,67.64 62.48,67.48 62.37,67.36 62.22,67.36 62.1,67.24 62.1,67.07 62.22,66.96 62.37,66.96 62.48,66.84 62.48,66.3 61.79,65.61 61.79,64.84 60.14,63.19 58.37,63.19 v1(58.04,63.51)
  BOTTOM w0.147: v1(58.04,63.51) 58.04,61.1 67.72,51.42 J33.21
MIPI_TRC_DAT02: length 36.6
  TOP w0.147: v1(59.18,63.64) 60.18,63.64 61.5,64.96 61.5,65.73 61.81,66.04 61.81,67.41 61.69,67.53 61.23,67.53 61.11,67.65 61.11,67.81 61.23,67.93 61.69,67.93 61.81,68.05 61.81,68.21 61.69,68.33 61.23,68.33 61.11,68.45 61.11,68.62 61.23,68.73 62.34,68.73 62.48,68.88 62.48,70.46 62.63,70.61 64.03,70.61 65.7,72.29 RA2.12
  BOTTOM w0.147: J33.23 68.22,48.15 68.02,48.35 68.02,51.54 59.18,60.38 v1(59.18,63.64)
MIPI_TRC_DAT03: length 36.8
  TOP w0.147: RA2.11 65.2,72.88 64.64,72.32 64.64,71.75 64.01,71.12 63.59,71.12 63.46,71.25 63.46,71.5 63.33,71.63 63.15,71.63 63.02,71.5 63.02,71.25 62.89,71.12 62.71,71.12 62.58,71.25 62.58,71.5 62.45,71.63 62.27,71.63 62.14,71.5 62.14,71.25 62.01,71.12 61.12,71.12 60.82,70.82 60.82,65.95 60.82,65.95 60.82,65.52 60.33,65.04 v1(59.18,65.04)
  BOTTOM w0.147: v1(59.18,65.04) 59.8,65.04 60.18,64.67 60.18,59.8 68.31,51.66 68.31,48.56 68.72,48.15 J33.25
MIPI_TRC_DAT04: length 36.7
  TOP w0.147: v1(59.69,65.93) 60.38,65.93 60.53,66.08 60.53,69.18 60.41,69.3 59.91,69.3 59.79,69.42 59.79,69.59 59.91,69.7 60.41,69.7 60.53,69.82 60.53,69.99 60.41,70.1 59.91,70.1 59.79,70.22 59.79,70.39 59.91,70.51 60.41,70.51 60.53,70.62 60.53,70.94 61.82,72.24 64.06,72.24 64.7,72.88 RA2.10
  BOTTOM w0.147: v1(59.69,65.93) 60.33,65.93 61.11,65.14 61.11,59.28 68.61,51.79 68.61,48.73 69.22,48.12 J33.27
MIPI_TRC_DAT05: length 36.8
  TOP w0.147: v1(59.82,67.07) 59.5,67.39 59.5,71.89 60.22,72.62 63.09,72.62 63.62,73.15 RA2.9
  BOTTOM w0.147: v1(59.82,67.07) 62.06,64.83 62.06,64.52 61.94,64.41 61.59,64.41 61.48,64.29 61.48,64.12 61.59,64.01 61.94,64.01 62.06,63.89 62.06,63.72 61.94,63.6 61.59,63.6 61.48,63.49 61.48,63.32 61.59,63.2 61.94,63.2 62.06,63.09 62.06,62.92 61.94,62.8 61.59,62.8 61.48,62.68 61.48,59.33 68.9,51.91 68.9,49.99 69.54,49.34 69.54,48.54 69.72,48.36 J33.29
MIPI_TRC_DAT06: length 36.9
  TOP w0.147: RA4.16 75.15,57 75.44,56.72 75.44,55.26 74.8,54.62 74.04,54.62 72.28,52.87 63.59,52.87 62.48,53.98 62.48,58.05 v1(63.12,58.69)
  BOTTOM w0.147: J33.31 70.22,48.36 70.48,48.62 70.48,49.53 70.29,49.73 69.92,49.73 69.65,49.99 69.65,51.58 63.12,58.11 v1(63.12,58.69)
MIPI_TRC_DAT07: length 36.7
  TOP w0.147: v1(64.14,57.92) 63.67,57.92 63.43,57.68 63.43,57.41 63.55,57.29 64.01,57.29 64.13,57.17 64.13,57.01 64.01,56.89 63.55,56.89 63.43,56.77 63.43,56.61 63.55,56.49 64.01,56.49 64.13,56.37 64.13,56.2 64.01,56.09 63.55,56.09 63.43,55.97 63.43,55.8 63.55,55.69 64.01,55.69 64.13,55.57 64.13,55.4 64.01,55.28 63.55,55.28 63.43,55.17 63.43,54.09 64.36,53.16 72.16,53.16 73.07,54.07 73.07,54.24 72.89,54.41 72.89,54.58 73.01,54.7 73.18,54.7 73.35,54.52 73.52,54.52 74.48,55.48 74.48,55.83 74.57,55.92 RA4.15
  BOTTOM w0.147: J33.33 70.72,48.36 70.83,48.46 70.83,50.82 64.46,57.18 64.46,57.6 v1(64.14,57.92)
MIPI_TRC_DAT08: length 36.9
  TOP w0.147: RA4.14 74.07,56.68 73.35,55.97 73.35,55.45 73.09,55.19 72.57,55.19 70.98,53.59 64.35,53.59 63.85,54.09 63.85,54.82 64.02,54.99 64.16,54.99 64.44,55.27 64.44,55.65 64.55,55.76 65.67,55.76 65.79,55.88 65.79,56.05 65.67,56.16 64.55,56.16 64.44,56.28 64.44,56.45 64.55,56.57 65.67,56.57 65.79,56.68 65.79,56.85 65.67,56.97 64.55,56.97 64.44,57.08 64.44,57.58 64.59,57.73 64.59,58.21 64.86,58.48 65.09,58.48 65.32,58.25 65.32,57.72 v1(65.28,57.67)
  BOTTOM w0.147: v1(65.28,57.67) 65.28,56.78 71.12,50.94 71.12,48.53 71.22,48.43 J33.35
MIPI_TRC_DAT09: length 36.8
  TOP w0.147: v1(66.13,57.27) 66.13,56.82 66.29,56.66 66.29,55.8 65.96,55.47 64.93,55.47 64.73,55.27 64.73,55.14 64.2,54.61 64.2,54.26 64.35,54.11 65.13,54.11 65.25,54.23 65.25,54.94 65.37,55.05 65.53,55.05 65.67,54.92 65.67,54.23 65.79,54.11 65.95,54.11 66.07,54.23 66.07,55.02 66.19,55.13 66.36,55.13 66.47,55.02 66.47,54.23 66.59,54.11 66.76,54.11 66.88,54.23 66.88,54.76 66.99,54.88 67.16,54.88 67.28,54.76 67.28,54.23 67.39,54.11 67.56,54.11 67.68,54.23 67.68,54.76 67.8,54.88 67.96,54.88 68.08,54.76 68.08,54.23 68.2,54.11 68.36,54.11 68.48,54.23 68.48,54.76 68.6,54.88 68.76,54.88 68.88,54.76 68.88,54.23 69,54.11 69.36,54.11 69.48,54.23 69.48,54.49 69.6,54.6 69.76,54.6 69.88,54.49 69.88,54.23 70,54.11 70.78,54.11 70.93,54.26 70.93,55.08 71.2,55.35 71.83,55.35 72.58,56.1 72.84,56.1 73.57,56.82 RA4.13
  BOTTOM w0.147: v1(66.13,57.27) 66.13,56.34 71.43,51.05 71.43,48.86 71.72,48.56 J33.37
MIPI_TRC_DAT10: length 37
  TOP w0.147: v1(66.17,57.92) 66.58,57.51 66.94,57.51 67.17,57.27 67.17,57.13 67.04,57 66.8,57 66.67,56.87 66.67,56.68 66.8,56.55 67.04,56.55 67.17,56.42 67.17,56.24 67.04,56.11 66.8,56.11 66.67,55.98 66.67,55.8 66.8,55.67 67.04,55.67 67.17,55.54 67.17,55.32 67.32,55.17 70.61,55.17 71.08,55.64 71.7,55.64 73.07,57 RA4.12
  BOTTOM w0.147: J33.39 72.22,48.49 72.34,48.6 72.34,50.55 67.69,55.2 67.69,56.25 67.58,56.37 66.87,56.37 66.75,56.48 66.75,56.65 66.87,56.77 67.58,56.77 67.69,56.88 67.69,57.05 67.58,57.17 66.87,57.17 66.75,57.29 66.75,57.45 66.87,57.57 67.58,57.57 67.69,57.69 67.69,57.85 67.58,57.97 66.87,57.97 66.75,58.09 66.75,58.25 66.87,58.37 67.58,58.37 67.69,58.49 67.69,58.66 67.58,58.77 66.87,58.77 66.75,58.89 66.75,59.06 66.87,59.18 67.58,59.18 67.69,59.29 67.69,59.63 67.55,59.77 65.85,59.77 65.65,59.57 65.65,58.44 v1(66.17,57.92)
MIPI_TRC_DAT11: length 36.6
  TOP w0.147: RA4.11 72.57,56.93 71.57,55.93 70.95,55.93 70.74,55.72 70.49,55.72 70.24,55.47 69.73,55.47 69.61,55.59 69.61,56.08 69.5,56.2 69.33,56.2 69.21,56.08 69.21,55.59 69.09,55.47 68.93,55.47 68.81,55.59 68.81,56.08 68.69,56.2 68.53,56.2 68.41,56.08 68.41,55.59 68.29,55.47 67.7,55.47 67.51,55.65 67.51,57.35 67.67,57.51 69.03,57.51 69.13,57.4 69.13,56.7 69.02,56.59 68.63,56.59 v1(68.56,56.66)
  BOTTOM w0.147: J33.41 72.72,50.59 72.04,51.26 72.04,51.43 72.32,51.7 72.32,51.87 72.2,51.99 72.03,51.99 71.76,51.71 71.59,51.71 71.48,51.83 71.48,52 71.75,52.27 71.75,52.44 71.63,52.55 71.46,52.55 71.19,52.28 71.03,52.28 70.91,52.4 70.91,52.57 71.18,52.84 71.18,53 71.06,53.12 70.9,53.12 70.62,52.85 70.46,52.85 70.34,52.97 70.34,53.13 70.61,53.41 70.61,53.57 70.5,53.69 70.33,53.69 70.06,53.42 69.89,53.42 69.77,53.53 69.77,53.7 70.05,53.97 70.05,54.14 69.93,54.26 69.76,54.26 69.49,53.98 69.32,53.98 69.21,54.1 69.21,54.27 69.48,54.54 69.48,54.71 69.36,54.82 69.19,54.82 68.92,54.55 68.76,54.55 67.99,55.32 67.99,58.05 68.27,58.33 68.85,58.33 69.12,58.06 69.12,57.78 69.01,57.67 68.59,57.67 68.48,57.55 68.48,57.38 68.59,57.27 69.01,57.27 69.12,57.15 69.12,56.87 69.01,56.76 68.66,56.76 v1(68.56,56.66)
MIPI_TRC_DAT12: length 36.9
  TOP w0.147: RA4.10 72.07,57 71.91,56.85 71.15,56.85 70.7,57.29 70.7,58.28 69.98,59.01 68.84,59.01 68.52,59.33 68.52,60.71 68.39,60.84 66.42,60.84 66.29,60.71 66.29,60.44 66.41,60.32 68.04,60.32 68.16,60.21 68.16,60.04 68.04,59.92 67.5,59.92 67.38,59.8 67.38,58.88 67.26,58.76 67.1,58.76 66.98,58.88 66.98,59.8 66.86,59.92 66.41,59.92 66.29,59.8 66.29,58.88 66.92,58.25 67.6,58.25 67.72,58.37 67.72,58.6 67.84,58.71 68,58.71 68.12,58.6 68.12,58.37 68.24,58.25 68.41,58.25 68.52,58.37 68.52,58.6 68.64,58.71 68.81,58.71 68.92,58.6 68.92,58.37 69.04,58.25 70.04,58.25 70.3,57.99 70.3,57.25 70.73,56.83 70.73,56.41 70.45,56.13 70.12,56.13 v1(69.6,56.66)
  BOTTOM w0.147: v1(69.6,56.66) 69.6,55.01 73.22,51.38 J33.43
MIPI_TRC_DAT13: length 36.7
  TOP w0.147: RA4.9 71.48,57.57 71,58.05 71,58.8 70.49,59.3 68.96,59.3 68.81,59.45 68.81,60.86 68.51,61.16 66.32,61.16 65.99,60.83 65.99,60.2 65.88,60.08 64.8,60.08 64.69,59.96 64.69,59.8 64.8,59.68 65.88,59.68 65.99,59.56 65.99,59.39 65.88,59.28 64.8,59.28 64.69,59.16 64.69,58.99 64.8,58.88 65.88,58.88 66.95,57.8 v1(69.85,57.8)
  BOTTOM w0.147: v1(69.85,57.8) 70.17,57.48 70.17,57.17 70.29,57.05 70.81,57.05 70.93,56.93 70.93,56.76 70.81,56.65 70.29,56.65 70.17,56.53 70.17,56.36 70.29,56.25 70.81,56.25 70.93,56.13 70.93,55.96 70.81,55.84 70.29,55.84 70.17,55.73 70.17,54.85 70.41,54.61 70.57,54.61 70.71,54.75 70.88,54.75 71,54.64 71,54.47 70.86,54.33 70.86,54.16 70.97,54.05 71.14,54.05 71.28,54.19 71.45,54.19 71.56,54.07 71.56,53.9 71.42,53.76 71.42,53.6 71.54,53.48 71.71,53.48 71.85,53.62 72.01,53.62 72.13,53.5 72.13,53.34 71.99,53.19 71.99,53.03 74.35,50.67 74.35,49.12 73.72,48.49 J33.45
MIPI_TRC_DAT14: length 36.8
  BOTTOM w0.147: J33.47 74.22,48.58 74.65,49 74.65,50.15 75.56,51.07 77.75,51.07 77.87,51.19 77.87,51.88 77.98,52 78.39,52 78.51,51.88 78.51,51.71 78.27,51.47 78.27,51.19 78.39,51.07 78.79,51.07 78.93,51.22 78.93,52.3 79.22,52.59 79.5,52.59 79.62,52.71 79.62,53.27 79.73,53.39 81.19,53.39 81.31,53.27 81.31,53.11 81.19,52.99 80.13,52.99 80.02,52.87 80.02,52.71 80.13,52.59 81.79,52.59 82.04,52.84 82.04,53.34 81.84,53.54 81.55,53.54 81.43,53.66 81.43,56.09 81.32,56.21 81.15,56.21 81.03,56.09 81.03,53.9 80.91,53.79 80.75,53.79 80.63,53.9 80.63,56.49 80.75,56.61 81.32,56.61 81.43,56.73 81.43,57.02 81.55,57.14 81.72,57.14 81.83,57.02 81.83,54.06 81.95,53.94 82.12,53.94 82.24,54.06 82.24,57.02 82.35,57.14 82.63,57.14 82.75,57.25 RA6.16
MIPI_TRC_DAT15: length 36.8
  BOTTOM w0.147: J33.49 74.72,48.66 74.94,48.88 74.94,49.74 75.89,50.69 79.11,50.69 79.23,50.81 79.23,52.18 79.35,52.29 81.66,52.29 81.78,52.18 81.78,52.01 81.66,51.89 79.75,51.89 79.63,51.77 79.63,51.61 79.75,51.49 81.66,51.49 81.78,51.37 81.78,51.21 81.66,51.09 79.75,51.09 79.63,50.97 79.63,50.81 79.75,50.69 82.06,50.69 83.33,51.97 83.33,55.28 83.22,55.4 83.05,55.4 82.93,55.28 82.93,52.23 82.81,52.11 82.65,52.11 82.53,52.23 82.53,55.68 82.65,55.8 83.22,55.8 83.33,55.91 RA6.15
MIPI_TRC_DAT16: length 36.9
  BOTTOM w0.147: J33.51 75.22,48.74 75.31,48.83 75.31,49.42 76.2,50.31 79.1,50.31 79.25,50.16 79.25,48.81 79.41,48.64 81.94,48.64 82.24,48.34 82.24,47.24 82.44,47.04 83.69,47.04 83.83,47.19 83.83,47.63 83.72,47.75 83.15,47.75 83.03,47.87 83.03,49.61 82.91,49.73 82.72,49.73 82.6,49.61 82.6,49.12 82.48,49.01 82.32,49.01 82.2,49.12 82.2,49.61 82.08,49.73 81.91,49.73 81.8,49.61 81.8,49.12 81.68,49.01 81.51,49.01 81.4,49.12 81.4,49.91 81.75,50.27 82.6,50.27 83.03,50.7 83.03,50.97 83.15,51.09 83.31,51.09 83.43,50.97 83.43,48.27 83.55,48.15 83.72,48.15 83.83,48.27 RA6.14
MIPI_TRC_DAT17: length 36.9
  BOTTOM w0.147: J33.53 75.72,49.05 76.6,49.93 77.84,49.93 78.5,49.26 78.5,46.64 78.77,46.37 78.98,46.37 79.22,46.61 79.22,48.23 79.34,48.35 81.82,48.35 81.93,48.23 81.93,48.06 81.82,47.95 79.74,47.95 79.62,47.83 79.62,47.66 79.74,47.54 81.82,47.54 81.93,47.43 81.93,47.26 81.82,47.14 79.74,47.14 79.62,47.03 79.62,46.86 79.74,46.74 84.04,46.74 84.33,47.03 RA6.13
MIPI_TRC_DAT18: length 36.9
  BOTTOM w0.147: J33.55 76.22,48.91 76.73,49.42 77.58,49.42 78.04,48.95 78.04,46.21 78.72,45.53 79.68,45.53 79.8,45.65 79.8,46.22 79.92,46.34 82.22,46.34 82.34,46.22 82.34,46.05 82.22,45.94 80.32,45.94 80.2,45.81 80.2,45.65 80.32,45.53 83.25,45.53 84.83,47.11 84.83,53.64 84.95,53.76 86.46,53.76 86.58,53.88 86.58,54.04 86.46,54.16 84.95,54.16 84.83,54.28 84.83,54.44 84.95,54.56 86.46,54.56 86.58,54.68 86.58,54.84 86.46,54.96 85.25,54.96 84.83,55.37 RA6.12
MIPI_TRC_DAT19: length 36.8
  L03_SIG1 w0.091: v1(85.33,56.42) 85.33,55.61 83.13,53.41 71.43,53.41 66.67,48.66 66.67,39.01 v1(66.21,38.54)
  BOTTOM w0.147: J33.18 66.72,39.06 v1(66.21,38.54) ; v1(85.33,56.42) 85.33,56.87 85.33,56.87 RA6.11
MIPI_TRC_DAT20: length 36.9
  L03_SIG1 w0.091: v1(67.39,38.6) 66.87,39.12 66.87,48.51 70.7,52.34 82.64,52.34 v1(85.83,55.53)
  BOTTOM w0.147: J33.20 67.22,39.26 67.07,39.11 67.07,38.92 v1(67.39,38.6) ; v1(85.83,55.53) 85.83,55.99 85.83,55.99 RA6.10
MIPI_TRC_DAT21: length 36.8
  L03_SIG1 w0.091: v1(67.72,39.38) 67.09,40.02 67.09,48.47 70,51.39 83.3,51.39 87.12,55.21 87.12,55.68 v1(86.38,56.42)
  BOTTOM w0.147: v1(86.38,56.42) 86.38,56.87 86.42,56.91 RA6.9 ; J33.22 v1(67.72,39.38)
MIPI_TRC_DAT22: length 37
  L08_SIG2 w0.091: v1(68.84,38.9) 69.22,38.9 70.57,40.26 73.91,40.26 76,38.17 76.65,38.17 v1(77.21,38.73)
  BOTTOM w0.147: J33.24 68.22,39.52 v1(68.84,38.9) ; R392.2 89.4,55.26 89.21,55.07 89.21,53.9 85.13,49.82 85.13,46.81 83.55,45.24 81.64,45.24 77.86,41.45 77.86,39.38 v1(77.21,38.73)
MIPI_TRC_DAT23: length 37
  L08_SIG2 w0.091: v1(68.95,39.53) 69.93,40.51 74.5,40.51 v1(76.37,38.64)
  BOTTOM w0.147: v1(68.95,39.53) 68.72,39.76 J33.26 ; R391.2 90.15,56.45 90.15,53.2 86.17,49.22 86.14,49.22 85.42,48.5 85.42,46.69 83.68,44.94 81.76,44.94 78.15,41.33 78.15,38.91 77.5,38.26 76.75,38.26 v1(76.37,38.64)
MIPI_TRST#_R: length 5.3
  BOTTOM w0.147: J33.8 64.22,39.42 65.88,37.76 66.21,37.76 66.76,37.21 R448.2
MMC0_CALPAD: length 22.4
  TOP w0.147: U23.F18 v1(95.46,71.1)
  L03_SIG1 w0.091: v1(95.46,71.1) 95.86,71.5 96.42,71.5 96.66,71.26 96.66,70.94 96.9,70.7 97.22,70.7 97.46,70.47 97.46,70.14 97.28,69.96 97.28,66.77 100.2,63.85 100.2,62.57 105.54,57.23 v1(105.54,55.77)
  BOTTOM w0.147: R405.1 v1(105.54,55.77)
MMC0_CLK: length 38.3
  TOP w0.147: R644.1 v1(104.27,53.35) ; U44.M6 118.12,35.1 v1(118.37,35.35)
  L03_SIG1 w0.091: v1(118.37,35.35) 118.82,34.9 120.1,34.9 121.17,35.96 121.17,45.5 117.35,49.31 117.35,49.43 117.48,49.56 117.48,49.67 117.4,49.75 117.29,49.75 117.16,49.62 117.04,49.62 116.96,49.7 116.96,49.81 117.1,49.95 117.1,50.06 117.02,50.14 116.9,50.14 116.77,50.01 116.66,50.01 116.58,50.09 116.58,50.2 116.71,50.33 116.71,50.45 116.63,50.53 116.51,50.53 116.38,50.4 116.27,50.4 116.19,50.48 116.19,50.59 116.32,50.72 116.32,50.84 116.24,50.92 116.13,50.92 115.99,50.78 115.88,50.78 115.8,50.86 115.8,50.98 115.93,51.11 115.93,51.22 115.85,51.3 115.74,51.3 115.61,51.17 115.49,51.17 115.28,51.38 106.24,51.38 v1(104.27,53.35)
  BOTTOM w0.147: R644.1 v1(104.27,53.35) ; R456.2 118.3,35.28 v1(118.37,35.35)
MMC0_DS: length 3
  TOP w0.147: v1(117.12,37.1) 117.37,36.85 U44.H5
  BOTTOM w0.147: v1(117.12,37.1) R444.2 R446.2
MMC0_VCTRL_TP: length 5.5
  TOP w0.147: U23.F17 v1(95.46,71.9)
  BOTTOM w0.114: v1(95.46,71.9) 95.06,71.5 95.06,70.06 95.83,69.29 95.83,67.98 TP74.1
MMC1_CLK: length 100.6
  TOP w0.147: U49.1 v1(47.38,29.22) 47.38,28 46.57,27.19 42.29,27.19 41.78,27.7 40.65,27.7 40.1,27.15 v1(40.1,25.38)
  BOTTOM w0.147: R389.1 R645.1 94.67,55.66 89.84,50.83 89.84,49.4 88.66,48.22 88.66,41.31 82.55,35.2 78.81,35.2 78.69,35.31 78.69,35.59 78.57,35.7 78.41,35.7 78.29,35.59 78.29,35.31 78.17,35.2 78,35.2 77.89,35.31 77.89,35.59 77.77,35.7 77.6,35.7 77.49,35.59 77.49,35.31 77.37,35.2 77.2,35.2 77.08,35.31 77.08,35.59 76.97,35.7 76.8,35.7 76.68,35.59 76.68,35.31 76.57,35.2 76.4,35.2 76.28,35.31 76.28,35.59 76.16,35.7 76,35.7 75.88,35.59 75.88,35.31 75.76,35.2 75.17,35.2 75.05,35.08 75.05,34.5 74.94,34.39 74.77,34.39 74.65,34.5 74.65,35.08 74.53,35.2 74.37,35.2 74.25,35.08 74.25,34.5 74.13,34.39 73.97,34.39 73.85,34.5 73.85,35.08 73.73,35.2 73.57,35.2 73.45,35.08 73.45,34.5 73.33,34.39 73.16,34.39 73.05,34.5 73.05,35.08 72.93,35.2 72.76,35.2 72.65,35.08 72.65,34.5 72.53,34.39 72.36,34.39 72.24,34.5 72.24,35.08 72.13,35.2 71.96,35.2 71.84,35.08 71.84,34.5 71.73,34.39 71.56,34.39 71.44,34.5 71.44,35.08 71.32,35.2 70.97,35.2 70.16,34.39 69.99,34.39 69.99,34.39 62.68,34.39 61.93,35.15 61.93,36.29 58.63,39.58 57.78,39.58 57.35,40.01 57.02,40.01 55.63,41.4 50.9,41.4 47.37,37.87 47.37,31.01 48.14,30.24 R646.2 48.14,29.98 v1(47.38,29.22) ; J37.5 v1(40.1,25.38)
MMC1_CLK_R: length 12.8
  TOP w0.147: v1(93.21,57.95) 93.21,63.64 92.72,64.12 92.72,65.32 91.67,66.37 91.67,68.26 91.46,68.47 91.46,69.5 U23.L20
MMC1_CMD: length 114.2
  TOP w0.147: v1(43.18,26.18) 43.85,26.85 46.65,26.85 47.88,28.08 v1(47.88,28.72) 47.88,29.17 47.88,29.18 U49.2 ; U23.J19 v1(93.06,70.3)
  BOTTOM w0.147: v1(93.06,70.3) 93.19,70.17 93.21,70.17 93.39,70 93.39,70 93.41,69.98 93.59,69.98 94.58,68.99 94.58,68.18 96.31,66.46 96.31,63.28 97.15,62.44 97.15,53.62 92.32,48.78 92.07,48.78 91.06,48.78 89.83,47.56 89.83,41.31 89.83,40.82 80.94,31.92 74.91,31.92 74.79,31.8 74.79,31.42 74.67,31.3 74.51,31.3 74.39,31.42 74.39,31.8 74.27,31.92 74.11,31.92 73.99,31.8 73.99,31.42 73.87,31.3 73.7,31.3 73.59,31.42 73.59,31.8 73.47,31.92 73.3,31.92 73.19,31.8 73.19,31.42 73.07,31.3 72.9,31.3 72.78,31.42 72.78,31.8 72.67,31.92 72.5,31.92 72.38,31.8 72.38,31.42 72.27,31.3 72.1,31.3 71.98,31.42 71.98,31.8 71.86,31.92 71.7,31.92 71.58,31.8 71.58,31.42 71.46,31.3 71.3,31.3 71.18,31.42 71.18,31.8 71.06,31.92 70.89,31.92 70.78,31.8 70.78,31.42 70.66,31.3 70.49,31.3 70.38,31.42 70.38,31.8 70.26,31.92 70.09,31.92 69.97,31.8 69.97,31.42 69.86,31.3 69.69,31.3 69.57,31.42 69.57,31.8 69.46,31.92 69.29,31.92 69.17,31.8 69.17,31.42 69.05,31.3 68.89,31.3 68.77,31.42 68.77,31.8 68.65,31.92 68.49,31.92 68.37,31.8 68.37,31.42 68.25,31.3 68.09,31.3 67.97,31.42 67.97,31.8 67.85,31.92 67.68,31.92 67.57,31.8 67.57,31.42 67.45,31.3 67.28,31.3 67.17,31.42 67.17,31.8 67.05,31.92 63.21,31.92 60.75,34.38 60.75,35.8 58.14,38.4 57.18,38.4 56.96,38.62 56.56,38.62 55.25,39.93 52.96,39.93 49.91,36.88 49.91,29.13 49.49,28.72 v1(47.88,28.72) ; v1(43.18,26.18) 43.07,26.07 R485.2 42.55,25.67 42.3,25.42 J37.3
MMC1_D0: length 113.4
  TOP w0.147: v1(93.34,64.15) 93.02,64.48 93.02,65.7 92.67,66.05 92.67,66.7 92.17,67.2 92.17,68.3 91.86,68.61 U23.K21 ; U49.8 v1(47.88,31.83) 47.69,32.02 47.12,32.02 46.1,31 46.1,28.97 45.32,28.19 45.11,28.19 45.07,28.15 44.13,28.15 44.13,28.16 42.36,28.16 42.35,28.15 40.08,28.15 38.86,26.94 v1(38.86,26.21)
  BOTTOM w0.147: v1(93.34,64.15) 93.67,63.83 93.85,63.83 95.89,61.8 95.89,55.78 90.77,50.66 90.77,49.84 88.95,48.02 88.95,41.19 81.86,34.09 80.84,34.09 80.72,34.21 80.72,34.79 80.6,34.9 80.43,34.9 80.32,34.79 80.32,34.21 80.2,34.09 80.03,34.09 79.92,34.21 79.92,34.79 79.8,34.9 79.63,34.9 79.51,34.79 79.51,34.21 79.4,34.09 79.23,34.09 79.11,34.21 79.11,34.79 79,34.9 78.83,34.9 78.71,34.79 78.71,34.21 78.59,34.09 78.43,34.09 78.31,34.21 78.31,34.79 78.19,34.9 78.03,34.9 77.91,34.79 77.91,34.21 77.79,34.09 77.63,34.09 77.51,34.21 77.51,34.79 77.39,34.9 77.22,34.9 77.11,34.79 77.11,34.21 76.99,34.09 76.82,34.09 76.71,34.21 76.71,34.79 76.59,34.9 76.42,34.9 76.3,34.79 76.3,34.21 76.19,34.09 76.02,34.09 75.9,34.21 75.9,34.79 75.79,34.9 75.62,34.9 75.5,34.79 75.5,34.21 75.38,34.09 62.51,34.09 61.63,34.97 61.63,36.16 58.51,39.29 57.54,39.29 57.31,39.52 56.95,39.52 55.45,41.02 50.94,41.02 47.88,37.96 47.88,32.53 47.88,32.52 v1(47.88,31.83) ; J37.7 37.9,25.31 38.1,25.51 R479.2 38.84,26.19 v1(38.86,26.21)
MMC1_D1: length 114.3
  TOP w0.147: v1(91.82,55.26) 92.71,56.15 92.71,63.72 92.43,64 92.43,65.2 91.35,66.27 91.35,68.18 91.06,68.47 U23.L21 ; U49.7 48.38,32.15 48.13,32.4 v1(46.86,32.4) 45.72,31.26 45.72,29.22 44.94,28.45 44.25,28.45 44.25,28.45 42.23,28.45 42.23,28.45 39.86,28.45 38.73,27.32 37.21,27.32 v1(36.07,26.18)
  BOTTOM w0.147: v1(36.07,26.18) 36.09,26.19 R480.2 36.83,25.34 36.8,25.31 J37.8 ; v1(91.82,55.26) 91.82,53.23 89.51,50.92 89.51,49.56 88.36,48.41 88.36,41.51 82.85,36 71.35,36 70.04,34.69 63.12,34.69 62.22,35.59 62.22,37.53 57.02,42.73 55.66,42.73 55.54,42.84 55.54,43.57 55.42,43.69 55.26,43.69 55.14,43.57 55.14,42.84 55.02,42.73 54.85,42.73 54.74,42.84 54.74,43.57 54.62,43.69 54.45,43.69 54.34,43.57 54.34,42.84 54.22,42.73 54.05,42.73 53.93,42.84 53.93,43.57 53.82,43.69 53.65,43.69 53.53,43.57 53.53,42.84 53.42,42.73 53.25,42.73 53.13,42.84 53.13,43.57 53.01,43.69 52.85,43.69 52.73,43.57 52.73,42.84 52.61,42.73 52.45,42.73 52.33,42.84 52.33,43.57 52.21,43.69 52.05,43.69 51.93,43.57 51.93,42.84 46.86,37.78 v1(46.86,32.4)
MMC1_D2: length 113.7
  TOP w0.147: U49.6 48.88,32.01 v1(48.9,32.02) 49.48,32.02 50.04,31.46 50.04,28.84 47.41,26.22 46.56,26.22 46.41,26.07 v1(45.96,26.07) ; U23.K19 v1(92.26,70.3)
  BOTTOM w0.147: v1(48.9,32.02) 48.9,36.7 52.55,40.35 52.72,40.52 55.49,40.52 56.81,39.21 57.2,39.21 57.42,38.99 58.38,38.99 61.34,36.04 61.34,34.85 62.39,33.8 73.2,33.8 73.32,33.68 73.32,32.8 73.43,32.68 73.6,32.68 73.72,32.8 73.72,33.68 73.84,33.8 74,33.8 74.12,33.68 74.12,32.8 74.24,32.68 74.4,32.68 74.52,32.8 74.52,33.68 74.64,33.8 74.8,33.8 74.92,33.68 74.92,32.8 75.04,32.68 75.21,32.68 75.32,32.8 75.32,33.68 75.44,33.8 75.61,33.8 75.72,33.68 75.72,32.8 75.84,32.68 76.01,32.68 76.13,32.8 76.13,33.68 76.24,33.8 76.41,33.8 76.53,33.68 76.53,32.8 76.64,32.68 76.81,32.68 76.93,32.8 76.93,33.68 77.05,33.8 77.21,33.8 77.33,33.68 77.33,32.8 77.45,32.68 77.61,32.68 77.73,32.8 77.73,33.68 77.85,33.8 81.98,33.8 89.25,41.06 89.25,47.89 90.72,49.37 92.07,49.37 96.56,53.86 96.56,62.16 95.72,63.01 95.72,65.97 94.99,66.7 94.99,66.71 94.01,67.69 94.01,68.49 93.13,69.37 92.51,69.37 92.26,69.62 v1(92.26,70.3) ; J37.1 44.5,25.31 44.6,25.41 45.11,25.41 45.29,25.59 R483.2 v1(45.96,26.07)
MMC1_D3: length 113.7
  TOP w0.147: v1(44.56,26.07) 45.05,26.56 47.11,26.56 48.38,27.82 v1(48.38,29.22) U49.3 ; U23.K18 v1(92.26,71.1)
  BOTTOM w0.114: v1(92.26,71.1) 92.66,70.7 92.66,70.12
  BOTTOM w0.147: 92.66,70.12 92.66,70.07 93.03,69.7 93.46,69.7 94.29,68.86 94.29,67.81 96.01,66.09 96.01,63.14 96.86,62.3 96.86,53.74 92.19,49.08 90.85,49.08 89.54,47.77 89.54,40.94 80.84,32.24 72.65,32.24 72.53,32.36 72.53,33.29 72.42,33.4 72.25,33.4 72.13,33.29 72.13,32.36 72.02,32.24 71.85,32.24 71.73,32.36 71.73,33.29 71.61,33.4 71.45,33.4 71.33,33.29 71.33,32.36 71.21,32.24 71.05,32.24 70.93,32.36 70.93,33.29 70.81,33.4 70.65,33.4 70.53,33.29 70.53,32.36 70.41,32.24 70.24,32.24 70.13,32.36 70.13,33.29 70.01,33.4 69.84,33.4 69.73,33.29 69.73,32.36 69.61,32.24 69.44,32.24 69.32,32.36 69.32,33.29 69.21,33.4 69.04,33.4 68.92,33.29 68.92,32.36 68.81,32.24 68.23,32.24 67.44,33.03 65.36,33.03 65.1,32.78 62.82,32.78 61.04,34.56 61.04,35.92 58.26,38.7 57.3,38.7 57.08,38.92 56.68,38.92 55.37,40.23 52.84,40.23 49.53,36.92 49.53,30.37 v1(48.38,29.22) ; v1(44.56,26.07) R484.2 43.94,25.54 43.4,25 J37.2
MMC1_SD_EN: length 33.4
  L03_SIG1 w0.091: v1(36.2,45.48) 36.2,43.83 41.04,38.99 43.24,38.99 49.94,32.3 49.94,31.36 52.43,28.86 v1(53.99,28.86)
  BOTTOM w0.147: v1(36.2,45.48) 35.57,46.1 33.62,46.1 33.04,45.52 R416.1 32.49,45.48 32.47,45.5 U86.1 ; U91.7 v1(53.99,28.86)
MMC1_SD_LS_EN: length 165.7
  TOP w0.254: U39.3 115.22,64.39 115.24,64.41 v1(115.24,65.21)
  L03_SIG1 w0.091: v1(123.9,41.31) 124.16,41.05 124.16,33.56 118.55,27.95 118.55,21.78 112.98,16.22 108.28,16.22 103.11,11.05 98.55,11.05 97.91,10.4 94.72,10.4 90.38,14.74 79.25,14.74 78.38,15.61 65.08,15.61 64.23,16.46 64.23,18.33 55.42,27.14 52.25,27.14 48.35,31.03 47.52,31.03 46.44,32.12 46.44,32.58 46.58,32.72 46.58,33.87 43.54,36.92 35.64,36.92 30,42.56 v1(28.96,42.56)
  L08_SIG2 w0.091: v1(115.24,65.21) 117.18,65.21 120.65,61.75 120.65,60.2 121.34,59.51 121.34,56.79 122.25,55.88 122.25,49.76 121.54,49.05 121.54,47.09 123.9,44.73 v1(123.9,41.31)
  BOTTOM w0.147: U86.4 28.9,43.36 29.66,42.6 R426.2 v1(28.96,42.56)
MMC1_SDCD: length 112.1
  TOP w0.147: U23.D19 v1(97.06,70.3)
  BOTTOM w0.147: J37.9 35.85,25.38 35.31,25.92 R481.2 34.69,26.19 34.42,26.47 34.42,27.7 35.05,28.34 45.97,28.34 46.23,28.08 49.28,28.08 50.29,29.1 50.29,36.83 53.1,39.64 55.13,39.64 56.44,38.33 56.84,38.33 57.11,38.05 58.06,38.05 60.45,35.66 60.45,34.26 63.71,31 80.44,31 91.11,41.68 91.11,46.29 94.6,49.79 94.6,49.97 97.74,53.1 97.74,62.7 96.9,63.54 96.9,66.3 97.39,66.79 97.39,68.06 97.06,68.39 v1(97.06,70.3)
Net_32: length 0.9
  TOP w0.147: 40.89,130.44 v1(41.53,131.08)
Net_33: length 0.9
  TOP w0.147: 40.89,129.17 v1(41.53,129.81)
OSC0: length 7.7
  TOP w0.147: Y2.1 167.02,25.43 166.91,25.54 164.14,25.54 163.78,25.17 C177.2 163.55,25.16 163.12,24.73 U59.88
OSC1: length 5.4
  TOP w0.147: Y2.3 164.65,25.87 C172.2 163.78,25.86 163.05,25.13 U59.89
OSPI0_CSN0: length 45.5
  TOP w0.147: U23.L19 v1(91.46,70.3)
  L03_SIG1 w0.091: v1(91.46,70.3) 91.46,66.87 91.78,66.55 91.78,65.54 91.98,65.35 92.1,65.35 92.58,64.86 92.58,63.01 93.11,62.48 95.25,62.48 95.74,62 95.74,61.91 101.77,55.87 101.77,50.64 106.1,46.31 106.1,42.89 105.84,42.63 103.43,42.63 v1(101.47,44.59)
  BOTTOM w0.147: v1(101.47,44.59) R422.2
OSPI0_LBCLK: length 23
  TOP w0.147: v1(94.11,52.32) 94.87,51.56 96.77,51.56 97.63,50.7 R600.2
  L03_SIG1 w0.091: v1(87.63,64.22) 88.01,63.84 88.01,62.61 88.65,61.98 88.65,60.07 89.66,59.05 92.2,59.05 92.71,58.55 92.71,57.66 94.11,56.26 v1(94.11,52.32)
  BOTTOM w0.147: v1(87.63,64.22) 87.52,64.33 R591.1
OSPI_CLK: length 45.1
  TOP w0.147: v1(95.11,46.63) 93.54,46.63 93.36,46.46 R157.1 R167.1 ; v1(89.84,65.8) 90.19,66.15 90.19,68.12 89.86,68.45 89.86,69.5 U23.N20
  L03_SIG1 w0.091: v1(95.11,46.63) 96.09,47.6 96.09,50.1 96.17,50.18 96.65,50.18 96.73,50.26 96.73,50.38 96.65,50.46 96.17,50.46 96.09,50.54 96.09,50.65 96.17,50.73 96.65,50.73 96.73,50.81 96.73,50.93 96.65,51.01 96.17,51.01 96.09,51.09 96.09,51.2 96.17,51.28 96.65,51.28 96.73,51.36 96.73,51.47 96.65,51.56 96.17,51.56 96.09,51.64 96.09,51.75 96.17,51.83 96.65,51.83 96.73,51.91 96.73,52.02 96.65,52.1 96.17,52.1 96.09,52.18 96.09,52.3 96.17,52.38 96.65,52.38 96.73,52.46 96.73,52.57 96.65,52.65 96.17,52.65 96.09,52.73 96.09,52.85 96.17,52.93 96.65,52.93 96.73,53.01 96.73,53.12 96.65,53.2 96.17,53.2 96.09,53.28 96.09,53.4 96.17,53.48 96.65,53.48 96.73,53.56 96.73,53.67 96.65,53.75 96.17,53.75 96.09,53.83 96.09,53.94 96.17,54.02 96.65,54.02 96.73,54.1 96.73,54.22 96.65,54.3 96.17,54.3 96.09,54.38 96.09,54.49 96.17,54.57 96.65,54.57 96.73,54.65 96.73,54.77 96.65,54.85 96.17,54.85 96.09,54.93 96.09,55.04 96.17,55.12 96.65,55.12 96.73,55.2 96.73,55.32 96.65,55.4 96.17,55.4 96.09,55.48 96.09,55.59 96.17,55.67 96.65,55.67 96.73,55.75 96.73,55.86 96.65,55.94 96.17,55.94 96.09,56.02 96.09,56.14 96.17,56.22 96.65,56.22 96.73,56.3 96.73,56.41 96.65,56.49 96.17,56.49 96.09,56.57 96.09,58.63 96.05,58.67 96.05,58.69 93.65,61.09 91.63,61.09 89.66,63.06 89.66,65.25 89.84,65.43 v1(89.84,65.8)
OSPI_CS: length 4.7
  TOP w0.147: R168.1 v1(95.05,44.59) 95.57,44.08 97.31,44.08 U40.C2
  BOTTOM w0.147: R422.1 v1(95.05,44.59)
OSPI_DQ0: length 5.4
  TOP w0.147: R181.2 v1(100.35,39.38) 100.35,39.83 99.31,40.87 99.31,42.08 U40.D3
  BOTTOM w0.147: R181.2 v1(100.35,39.38)
OSPI_DQ1: length 4.9
  TOP w0.147: R176.2 v1(95.05,40.78) 96.35,42.08 97.31,42.08 U40.D2
  BOTTOM w0.147: R176.2 v1(95.05,40.78)
OSPI_DQ2: length 4.3
  TOP w0.147: U40.C4 100.31,44.08 101.91,44.08 v1(102.3,44.46) R169.2
  BOTTOM w0.147: R169.2 v1(102.3,44.46)
OSPI_DQ3: length 4.1
  TOP w0.147: U40.D4 100.31,43.08 102.3,43.08 v1(102.3,43.07) R172.2
  BOTTOM w0.147: R172.2 v1(102.3,43.07)
OSPI_DQ4: length 3.3
  TOP w0.147: R173.2 v1(102.3,41.67) 101.71,41.67 U40.D5
  BOTTOM w0.147: R173.2 v1(102.3,41.67)
OSPI_DQ5: length 3.8
  TOP w0.147: U40.E3 98.81,39.59 v1(99.08,39.32) R180.2
  BOTTOM w0.147: R180.2 v1(99.08,39.32)
OSPI_DQ6: length 3.7
  TOP w0.147: R179.2 v1(97.81,39.32) U40.E2
  BOTTOM w0.147: R179.2 v1(97.81,39.32)
OSPI_DQ7: length 3.8
  TOP w0.147: U40.E1 96.54,41.31 v1(96.54,39.32) R178.2
  BOTTOM w0.147: R178.2 v1(96.54,39.32)
OSPI_DQS: length 7.8
  TOP w0.147: R155.2 97.41,49.65 97.79,49.28 97.79,48.9 97.94,48.74 R152.1 98.48,47.31 98.31,47.14 98.31,44.08 U40.C3
OSPI_DQS_SOC: length 27.3
  TOP w0.147: v1(99.44,50.62) 99.44,49.91 99.25,49.72 R600.1 ; U23.N19 v1(89.06,70.3)
  L03_SIG1 w0.091: v1(95.4,60.15) 96.64,58.91 96.64,57.06 97.43,56.28 97.43,52.63 v1(99.44,50.62)
  BOTTOM w0.147: v1(95.4,60.15) 95.4,61.75 93.95,63.2 93.26,63.2 92.71,63.76 92.71,65.16 91.62,66.25 90.6,66.25 89.06,67.79 v1(89.06,70.3)
OSPI_INTN: length 36.5
  TOP w0.147: U23.L17 v1(91.46,71.9) ; v1(100.33,48.36) 103.49,48.36 103.99,47.85 R156.1 R158.2
  L03_SIG1 w0.091: v1(91.46,71.9) 90.56,71 90.56,66.42 90.68,66.3 90.68,65.68 91.27,65.08 91.27,62.92 91.69,62.51 92.06,62.51 92.71,61.86 95.01,61.86 101.04,55.83 101.04,49.07 v1(100.33,48.36)
OSPI_RSTN: length 14.2
  TOP w0.147: v1(107.82,48.66) 107.31,49.16 100.2,49.16 99.81,48.77 U40.A4
  BOTTOM w0.147: U85.4 R414.1 v1(107.82,48.66)
PCIE_CLKREQN: length 3
  BOTTOM w0.147: J27.B12 22.78,28.47 23.39,27.86 R482.1
PCIE_MCU_PORZ: length 115.6
  TOP w0.147: J34.3 53.08,40.15 54.48,41.55 58.09,41.55 59.23,40.41 59.23,36.56 61.35,34.44 61.35,31.23 60.65,30.52 59.48,30.52 58.96,30.01 58.96,29.42 59.53,28.85 68.09,28.85 71.51,32.27 85.29,32.27 86.57,31 91.21,31 93.17,32.96 102.31,32.96 108.87,39.52 108.87,44.22 112.98,48.33 122.05,48.33 123.51,46.87 126.91,46.87 127.4,47.35 U35.6
  BOTTOM w0.147: R576.2 47.88,42.55 47.5,42.16 J34.3
PCIE_PRSNT1#: length 28.6
  TOP w0.147: J35.3 26.17,42.67 20.45,42.67 19.02,41.25 13.12,41.25 8.87,37 8.87,34.86 J27.A1
  BOTTOM w0.147: J35.3 28.13,40.72 R437.2
PCIE_PRSNT2#_1: length 15.7
  TOP w0.147: J35.2 21.62,38.25 21.62,34.62 23.42,32.82 26.41,32.82 J27.B17
PCIE_PRSNT2N: length 3.1
  BOTTOM w0.147: J35.1 20.87,41.47 20.71,41.31 R431.2
PCIE_RESET_OUTN: length 3.3
  BOTTOM w0.147: U88.4 41.11,40.02 41.24,40.15 J34.1
PCIE_RESETN: length 30.7
  BOTTOM w0.147: J27.A11 20.48,34.65 21.66,34.65 23.55,32.77 26.26,32.77 26.77,33.27 26.77,34.49 27.79,35.51 27.79,36.65 28.14,37.01 41.82,37.01 J34.2
PCIE_SERDES_REFCLK0_N: length 9.7
  TOP w0.108: R667.1 25.37,38.48 arc(25.33,38.57) 25.25,38.6 24.79,38.6 arc(24.52,38.55) 24.29,38.39 24.18,38.29 arc(24.1,38.16) 24.07,38.02 24.07,37.73 arc(24.13,37.58) 24.28,37.51 24.55,37.51 arc(24.77,37.3) 24.55,37.08 24.23,37.08 arc(24.11,37.03) 24.07,36.92 24.07,36.75 arc(24.08,36.67) 24.13,36.6 J27.A14
  BOTTOM w0.108: R667.1 24.86,38.6 24.38,38.6 24.07,38.29 24.07,36.66 J27.A14
PCIE_SERDES_REFCLK0_P: length 13
  TOP w0.108: J27.A13 23.78,38.02 arc(23.83,38.27) 23.97,38.49 24.08,38.6 arc(24.41,38.82) 24.79,38.89 25.19,38.89 arc(25.32,38.94) 25.37,39.07 R668.1
  BOTTOM w0.108: R668.1 24.86,38.89 24.26,38.89 23.78,38.41 J27.A13
PCIE_TCK: length 5.5
  BOTTOM w0.147: J27.A5 13.78,37.29 14.02,37.53 14.02,38.58 TP85.1
PCIE_TDI: length 5.9
  BOTTOM w0.147: J27.A6 14.78,39.85 TP83.1
PCIE_TDO: length 10.4
  BOTTOM w0.147: J27.A7 15.78,32.96 15.47,32.65 15.11,32.65 14.77,32.31 14.77,31.04 13.79,30.06 13.79,29.04 14.1,28.73 14.1,27.07 TP95.1
PCIE_TMS: length 3.7
  BOTTOM w0.147: TP84.1 16.78,38.23 J27.A8
PCIE_TRSTN: length 7.3
  BOTTOM w0.147: TP94.1 17.77,28.45 17.77,29.86 17.78,29.87 J27.B9
PCIE_WAKEN: length 5.1
  BOTTOM w0.147: J27.B11 19.78,30.47 20.21,30.03 R486.1
PORZ: length 28.2
  TOP w0.147: U35.1 127.4,53.82 127.81,54.24 R574.2 128.65,54.12 v1(128.65,53.12) ; v1(143.76,41.67) 143.71,41.62 TP32.1 142.49,42 R171.2
  L03_SIG1 w0.091: v1(128.65,53.12) 129.41,52.36 129.41,49.16 130.68,47.89 138.37,47.89 142.88,43.39 142.88,42.56 v1(143.76,41.67)
PORZ_OUT: length 257.4
  TOP w0.147: U19.2 v1(25.4,89.11) ; v1(109.96,39.78) 109.96,40.55 TP82.1 ; U31.2 29.69,59.96 29.08,59.36 v1(29.08,58.18) ; U23.E17 v1(96.26,71.9)
  L03_SIG1 w0.091: v1(107.19,56.43) 107.19,56.86 106.9,57.15 106.9,63.72 104.29,66.33 104.29,70.53 103.81,71.01 102.62,71.01 v1(102.01,70.4) 102.01,70.77 101.27,71.51 96.89,71.51 96.68,71.72 96.44,71.72 v1(96.26,71.9) ; v1(109.96,39.78) 112.98,36.77 112.98,29.2 114.15,28.03 114.15,20.82 110.49,17.16 108.52,17.16 102.96,11.61 94.14,11.61 90.61,15.14 79.6,15.14 78.6,16.14 66.99,16.14 58.93,24.2 58.93,26.56 57.5,27.99 55.83,27.99 55.67,27.83 52.35,27.83 48.46,31.71 48.46,32.83 43.04,38.25 38.83,38.25 37.25,39.83 34.95,39.83 30.43,44.34 29.2,44.34 v1(27.94,45.61) 27.94,57.04 v1(29.08,58.18) 28.77,58.49 28.77,60.03 28.77,60.39 28.93,60.55 28.93,63.21 29.32,63.6 29.32,85.2 v1(25.4,89.11)
  L08_SIG2 w0.091: v1(109.96,39.78) 109.96,53.65 v1(107.19,56.43) ; v1(45.85,107.2) 45.85,106.57 44.58,105.3 38.1,105.3 35.81,103.01 35.81,98.69 26.23,89.11 v1(25.4,89.11)
  BOTTOM w0.147: R348.2 103.17,69.23 v1(102.01,70.4) ; U69.2 v1(45.85,107.2) ; R434.2 v1(109.96,39.78) ; v1(27.94,45.61) 28.05,45.5 U86.6
